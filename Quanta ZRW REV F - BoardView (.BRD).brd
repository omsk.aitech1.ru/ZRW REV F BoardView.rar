# Allegro board Quanta ZRW REV F - BoardView (.BRD).brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
INT_HDMITX1P: length 139.5
  TOP w0.114: v1(33.49,66.14) 33.21,66.42 30.46,66.42 C407.1
  IN2 w0.127: v1(33.49,66.14) 33.76,66.42 34.36,66.42 36,68.06 36,68.45 35.4,69.06 35.4,69.24 35.58,69.42 35.76,69.42 36.36,68.81 36.75,68.81 37.08,69.14 37.08,69.53 36.48,70.14 36.48,70.31 36.66,70.5 36.84,70.5 37.44,69.89 37.83,69.89 38.16,70.22 38.16,70.61 37.56,71.21 37.56,71.39 37.74,71.57 37.92,71.57 38.52,70.97 38.91,70.97 42.38,74.44 42.38,77.74 49.7,85.06 49.7,89.23 58,97.53 76.03,97.53 84.09,105.58 88.1,105.58 94.05,111.53 95.8,111.53 99.15,114.88 99.15,116.84 98.92,117.06 98.92,122.42 104.18,127.68 104.66,127.68 108.02,131.05 108.91,131.05 109.58,131.72 113.37,131.72 115.99,129.1 118.32,129.1 118.78,128.65 121.88,128.65 122.77,127.76 123.56,127.76 123.86,127.45 124.21,127.45 v2(124.42,127.24)
  BOTTOM w0.114: v2(124.42,127.24) 124.09,127.57 U35.F58
INT_HDMITX1P_C: length 12.5
  TOP w0.114: CN12.4 10.9,64.96 11.71,64.96 13.77,67.02 14.97,67.02 R314.1 15.15,66.99 16.92,66.99 v3(17.26,66.65) 17.6,66.99 18.99,66.99 19.52,67.51 20.54,67.51 20.54,67.51 20.7,67.51 20.7,67.51 20.94,67.51 21.02,67.59 U18.27
INT_HDMITX1P_C_R: length 3.8
  TOP w0.114: U18.4 27.04,67.59 27.14,67.7 27.8,67.7 28.3,67.21 28.3,66.7 28.59,66.4 28.92,66.4 C407.2
INT_HDMITX2N: length 139.7
  TOP w0.114: C408.1 30.64,64.32 30.89,64.32 31.05,64.48 v1(31.05,64.72)
  IN2 w0.127: v1(31.05,64.72) 31.31,64.46 31.92,64.46 32.47,65.02 32.47,68.43 33.24,69.19 33.24,73.13 34.27,74.16 36.28,74.16 45.81,83.69 45.81,87.73 47.21,89.13 47.21,89.91 56.6,99.31 75.05,99.31 83.1,107.36 87.36,107.36 90.55,110.55 90.55,110.88 97.14,117.47 97.14,124.85 101.75,129.46 103.92,129.46 107.29,132.83 108.39,132.83 108.9,133.35 115.53,133.35 116.29,132.59 119.31,132.59 120.97,130.93 122.34,130.93 123.33,129.94 124.15,129.94 124.6,129.49 125.44,129.49 125.97,128.95 125.97,128.81 v5(126.29,128.5)
  BOTTOM w0.114: v5(126.29,128.5) 126.01,128.22 U35.E55
INT_HDMITX2N_C: length 15
  TOP w0.114: U18.29 21.17,66.79 21.1,66.73 20.82,66.73 20.38,66.29 18.78,66.29 17.66,65.18 16.8,65.18 16.47,65.5 v3(16.42,65.55) 16.05,65.18 15.18,65.18 R315.2 13.56,65.28 11.26,62.99 10.3,62.99 9.09,64.19 CN12.3
INT_HDMITX2N_C_R: length 4.5
  TOP w0.114: C408.2 29.29,64.59 29.18,64.48 28.95,64.48 28.61,64.82 28.61,65.58 27.52,66.67 27.26,66.67 27.14,66.79 U18.2
INT_HDMITX2P: length 139.7
  TOP w0.114: C411.1 30.4,64.08 30.87,64.08 v1(31.05,63.9)
  IN2 w0.127: v1(31.05,63.9) 31.36,64.21 32.02,64.21 32.73,64.91 32.73,68.32 33.49,69.08 33.49,73.02 34.38,73.91 36.39,73.91 46.06,83.58 46.06,87.63 47.46,89.02 47.46,89.81 56.71,99.06 75.15,99.06 83.2,107.11 87.46,107.11 90.8,110.45 90.8,110.77 97.4,117.37 97.4,124.75 101.86,129.21 104.02,129.21 107.39,132.57 108.49,132.57 109.01,133.09 115.43,133.09 116.18,132.34 119.2,132.34 120.86,130.68 122.24,130.68 123.23,129.69 124.04,129.69 124.5,129.23 125.33,129.23 125.72,128.85 125.72,128.43 v2(126.27,127.87)
  BOTTOM w0.114: U35.F55 125.97,127.57 v2(126.27,127.87)
INT_HDMITX2P_C: length 14.9
  TOP w0.114: CN12.1 9.28,63.2 10.06,62.42 11.5,62.42 13.8,64.71 14.69,64.71 14.9,64.5 R315.1 15.18,64.61 16.1,64.61 v3(16.42,64.28) 16.74,64.61 17.9,64.61 19.01,65.72 20.62,65.72 21.29,66.39 U18.30
INT_HDMITX2P_C_R: length 4.5
  TOP w0.114: U18.1 27.14,66.39 27.17,66.43 27.42,66.43 28.37,65.48 28.37,64.72 28.85,64.24 29.1,64.24 29.29,64.05 C411.2
INTRUDER#: length 31.4
  TOP w0.114: R249.1 163.79,93.87 162.8,94.86 162.39,94.86 161.63,95.63 158.31,95.63 158.07,95.39 155.12,95.39 149.95,100.57 v3(149.95,103.28) 149.69,103.53 149.69,105.55 150.19,106.04 150.19,108.72 149.95,108.96 149.95,109.5 148.65,110.79 148.65,112.61 v2(148.21,113.06)
  BOTTOM w0.127: U35.AP16 v2(148.21,113.06)
IOAC_LAN_WAKE#: length 176.6
  IN1 w0.127: v1(194.78,39.04) 190.69,43.13 187.34,43.13 185.99,41.78 180.41,41.78 179.35,40.72 179.35,38.77 177.66,37.08 170.69,37.08 168.03,39.75 138.9,39.75 137.81,40.84 100.22,40.84 78.73,62.33 77.36,62.33 73.15,66.54 68.53,66.54 65.57,69.51 65.57,72.34 64.55,73.35 64.55,74.12 60.98,77.69 59.74,77.69 57.72,79.72 57.72,80.87 57.47,81.12 56.6,81.12 51.87,85.85 v1(50.25,85.85)
  BOTTOM w0.114: R715.2 50.13,85.72 v1(50.25,85.85) ; U45.87 193.3,40.31 194.58,39.04 v1(194.78,39.04)
IOAC_LANPWR#: length 186.8
  TOP w0.114: v1(48.22,87) 48.22,87.49 R260.2 R259.1
  IN1 w0.127: v1(48.22,87) 48.22,86.89 50,85.11 51.89,85.11 56.45,80.55 56.45,80.27 59.56,77.16 60.77,77.16 64,73.94 64,73.05 64.99,72.06 64.99,69.37 68.32,66.04 72.93,66.04 77.23,61.74 78.55,61.74 101.1,39.19 167.78,39.19 170.52,36.44 176.75,36.44 181.19,32 191.05,32 193.53,34.48 193.95,34.48 194.9,35.43 194.9,36.14 195.34,36.57 195.34,39.11 194.96,39.48 194.79,39.48 191.02,43.25 v1(191.02,43.54)
  BOTTOM w0.114: v1(191.02,43.54) 191.05,43.52 U45.95
IOAC_RST#: length 248.8
  TOP w0.114: v1(48.17,86.25) 47.82,86.61 R263.1
  IN1 w0.127: v1(172.07,31.34) 172.07,31.77 167.14,36.7 100.55,36.7 79.51,57.73 79.51,58.09 72.77,64.83 68.12,64.83 63.45,69.5 63.45,73.57 60.36,76.65 59.35,76.65 56.69,79.31 56.03,79.31 54.44,80.89 54.44,82.2 51.79,84.86 49.57,84.86 v1(48.17,86.25)
  IN2 w0.127: v1(172.07,31.34) 172.07,32.79 178.96,39.67 178.96,40.89 179.6,41.54 187.55,41.54 v1(187.82,41.27)
  BOTTOM w0.114: R680.1 192.98,97.15 193.76,96.36 195.26,96.36 198.92,92.71 198.92,82.11 197.73,80.92 197.73,72.89 197.38,72.54 197.38,71.88 199.86,69.4 v3(199.86,68.6) 199.86,63.6 197.35,61.1 197.35,56.54 194.88,54.06 192.38,54.06 188.5,50.18 188.5,46.72 186.6,44.82 186.6,42.49 v1(187.82,41.27) 188.28,40.81 190.92,40.81 191.3,40.43 191.3,39.75 191.54,39.52 U45.85
IOAC_WLAN_WAKE#: length 85.9
  TOP w0.114: v1(186.47,92.71) v3(185.46,93.72) 184.63,93.72 R244.2 184.37,93.98 R243.1 185.13,96 185.13,96.16 185.51,96.54 186.78,96.54 186.92,96.4 Q23.6
  IN1 w0.127: v1(202.66,35.11) 202.66,36.31 201.86,37.11 201.86,48.84 202.63,49.61 202.63,51.11 201.79,51.96 198.81,51.96 197.51,53.26 196.76,53.26 196.49,53.53 196.49,55.43 197.31,56.24 197.31,58.02 197.94,58.65 197.94,60.93 199.99,62.98 199.99,68.13 199.8,68.32 199.8,73.85 198.27,75.38 198.27,78.42 195.48,81.21 194.3,81.21 192.71,82.8 191.36,82.8 188.15,86.01 188.15,90.83 186.47,92.5 v1(186.47,92.71)
  BOTTOM w0.114: v1(202.66,35.11) 203.82,35.11 205.79,37.08 206.39,37.08 207.22,37.91 U45.16
IOAC_WLANPWR#: length 100.3
  TOP w0.114: v1(181.44,95.04) 180.68,95.8 180.68,99.95 R231.2 180.46,100.96 R230.1
  IN1 w0.127: v1(194.41,57) 194.97,56.44 194.97,52.56 196.2,51.33 196.2,50.67 196.38,50.49 196.38,50.12 196.96,49.54 196.96,47.72 199.34,45.35 199.34,43.85 198.65,43.16 198.65,39.88 199.92,38.61 199.92,35.21 202.65,32.48 v1(202.65,31.58)
  IN2 w0.127: v1(179.16,86.86) 179.16,87.12 182,89.96 182,94.48 v1(181.44,95.04)
  BOTTOM w0.114: U45.35 205.51,30.79 205.32,30.98 204.23,30.98 203.63,31.58 v1(202.65,31.58) ; v1(194.41,57) 194.78,57.37 194.78,58.32 196.44,59.98 196.44,61.47 199.07,64.11 199.07,64.71 195.47,68.31 195.47,73.68 195.68,73.89 195.68,79.14 191.08,83.73 191.08,84.79 190.21,85.67 v3(188.3,85.67) 181.5,85.67 180.3,86.86 v1(179.16,86.86) 178.79,87.24 R710.1 177.64,86.74 R712.2
IRQ_SERIRQ: length 124.3
  IN1 w0.127: v1(212.74,42.82) 212.99,43.07 212.99,45.84 212.43,46.4 v1(212.43,47.27) ; v1(169.38,97.02) 169.45,96.96 169.45,96.38 169,95.93 169,94.99 169.82,94.16 169.82,93.52 169.58,93.27 169.58,90.36 170.31,89.63 172.82,89.63 172.94,89.52 172.94,88.23 175.75,85.41 175.75,83.14 177.99,80.89 178.99,80.89 180.24,79.65 180.24,75.84 183.59,72.49 183.59,65.13 188.56,60.17 188.56,51.57 191.26,48.87 191.26,47.91 191.91,47.26 192.91,47.26 194.12,46.06 194.12,42.29 v1(194.58,41.83)
  IN2 w0.127: v1(169.38,97.02) 168.95,97.46 168.95,98.55 168.81,98.69 168.81,102.57 168.43,102.95 168.43,104.3 167.21,105.52 166.34,105.52 v5(166.33,105.5)
  BOTTOM w0.076: U35.AY11 150.63,109.45 150.95,109.12 150.95,108.49 151.11,108.33 151.48,108.33 151.8,108 152.47,108 152.81,107.67 153.91,107.67 154.11,107.47 154.87,107.47 155.33,107.01 159.95,107.01
  BOTTOM w0.114: v1(212.74,42.82) 211.8,42.82 211.32,43.3 209.69,43.3 208.7,42.31 U45.5 206.13,42.31 206.03,42.41 205.58,42.41 205.14,42.85 202.77,42.85 202.37,42.45 199.71,42.45 199.1,43.05 197.85,43.05 196.77,41.97 194.72,41.97 v1(194.58,41.83) ; v5(166.33,105.5) 166.33,106.05 166.21,106.16 166.2,106.16 R629.2 165.38,106.98 164.24,106.98 164,107.23 160.16,107.23 159.95,107.01 ; v1(212.43,47.27) 212.43,48 212.16,48.27 U44.27
ISEN1_B: length 9.2
  TOP w0.203: v1(145.76,187.58) 145.76,187.8 146.01,188.06 PR19.1 ; PC18.1 v1(147.41,186.18) 147.41,185.8 148.43,184.78 PU1.9
  BOTTOM w0.203: PR188.2 144.74,187.99 144.77,187.96 145.14,187.58 v1(145.76,187.58) 146.29,187.05 v3(146.29,187.04) 146.3,187.04 147.16,186.18 v1(147.41,186.18)
ISEN2_B: length 8
  TOP w0.203: PU1.10 148.03,184.67 146.39,186.3 PC17.1 145.74,186.8 v1(145.55,186.99) 145.29,187.26 145.29,188.04 v1(145.33,188.08) 144.74,188.67 PR18.2
  BOTTOM w0.203: v1(145.33,188.08) 145.33,188.18 PR189.1
ISL95857_COMP_A: length 4.3
  TOP w0.201: PU1.16 146.14,181.48 145.88,181.73 145.88,181.96 145.38,182.47 v1(145.38,182.76)
  TOP w0.203: PC24.2 v1(145.38,182.76)
  BOTTOM w0.203: v1(145.38,182.76) PC24.2
ISL95857_COMP_B: length 6.5
  TOP w0.203: PC21.2 153.5,186.08 v1(153.1,185.67) v1(152.23,185.67) 151.09,185.67 150.43,185.01 PU1.4
  BOTTOM w0.203: PC21.2 153.5,186.08 v1(153.1,185.67)
ISL95857_COMP_C: length 3.5
  TOP w0.203: PC37.2 v1(148.55,177.54) 149.23,178.22 PU1.24
  BOTTOM w0.203: v1(148.55,177.54) PR216.1
ISL95857_FB_A: length 5.1
  TOP w0.203: v1(145.38,181.73) 145.38,181.74 PR34.1 PR36.1 145.02,181.08 145.79,181.08 v1(145.83,181.12) 145.87,181.08 PU1.17
  BOTTOM w0.203: PR34.1 145.38,181.74 v1(145.38,181.73)
ISL95857_FB_B: length 6.8
  TOP w0.201: PR23.1 151.47,186.56 150.03,185.12 PU1.5
  TOP w0.203: v1(152.74,186.2) 152.49,186.46 PR24.1 PR23.1
  BOTTOM w0.203: v1(152.74,186.2) 152.39,185.85 v1(152.21,185.85) 152.21,186.52 PR24.1
ISL95857_FB_C: length 5.2
  TOP w0.203: v1(150.2,177.54) 150.58,177.16 PR45.1 PR44.1 149.57,177.85 v1(149.62,177.9) 149.63,177.91 PU1.25
  BOTTOM w0.203: PR217.1 150.58,177.16 v1(150.2,177.54)
ISL95857_FCCM_A: length 3.7
  TOP w0.203: PU1.21 148.03,179.05 147.66,178.68 147.1,178.68 v1(146.34,177.92) 145.92,177.5 145.92,177.33 PR42.2
ISL95857_FCCM_B: length 6.7
  TOP w0.203: PR26.1 143.24,185.19 143.64,185.59 143.64,185.63 143.7,185.69 143.7,185.97 v1(143.85,186.13) 144.18,185.8 145.5,185.8 146.9,184.4 146.9,183.64 147.06,183.48 PU1.11
ISL95857_FCCM_C: length 4.6
  TOP w0.203: PU1.29 151.23,178.9 151.79,178.34 151.82,178.34 152.24,177.92 153.39,177.92 154.39,176.92 PR46.2
ISL95857_IMON_A: length 5.1
  TOP w0.203: PU1.14 146.77,182.28 146.56,182.49 v1(146.01,182.49) 146.01,182.88 145.5,183.38 145.5,183.65 PC23.1
  BOTTOM w0.203: v1(146.01,182.49) 146.65,182.49 146.9,182.24 PR202.1
ISL95857_IMON_B: length 6
  TOP w0.203: PU1.2 151.23,184.46 151.85,185.09 v1(151.85,185.11) 153.23,185.11 v1(153.73,185.62) 154.52,186.41 PC22.1
  BOTTOM w0.203: v1(151.85,185.11) 151.85,184.78 151.48,184.41 PR198.1
ISL95857_IMON_C: length 4.9
  TOP w0.203: PC36.1 147.54,177.29 v1(148.49,178.24) 148.83,178.58 PU1.23
  BOTTOM w0.254: v1(148.49,178.24) 147.87,178.86 v3(147.87,178.99) 147.93,179.06 PR207.1
ISL95857_ISUMN_A: length 4.1
  TOP w0.203: PC34.2 v1(145.5,178.18) 145.5,178.56 v1(146.44,179.5) 146.83,179.88 PU1.20
  BOTTOM w0.203: v1(145.5,178.18) PC34.2
ISL95857_ISUMN_B: length 3.5
  TOP w0.203: PU1.8 148.83,184.88 148.42,185.29 v1(148.42,185.49) v1(148.42,186.18) PC19.1
  BOTTOM w0.203: v1(148.42,186.18) PC19.1
ISL95857_ISUMN_C: length 5.1
  TOP w0.203: PC40.2 v1(153.13,177.42) 152.08,177.42 v1(151.63,177.87) 151.63,177.97 150.83,178.77 PU1.28
  BOTTOM w0.203: v1(153.13,177.42) PC40.2 PR220.1
ISL95857_NTC_A: length 16.6
  TOP w0.203: v1(146.39,181.99) 146.5,181.88 PU1.15
  BOTTOM w0.203: PR235.1 PR236.1 143.21,168.9 143.6,169.29 143.6,171.19 144.23,171.83 144.23,175.26 146.39,177.41 v3(146.39,181.1) v1(146.39,181.99)
ISL95857_NTC_B: length 57.9
  TOP w0.203: v1(151.22,185.11) 150.83,184.73 PU1.3
  IN2 w0.203: v1(151.22,185.11) 151.22,188.08 153.02,189.89 153.02,190.98 152.87,191.13 152.87,191.69 150.29,194.27 149.25,194.27 145.96,190.98 144.85,190.98 140.07,186.2 137.66,186.2 134.71,183.26 131.67,183.26 128.46,180.05 128.46,175.43 121.76,168.73 v1(121.42,168.73)
  BOTTOM w0.203: v1(121.42,168.73) 121.42,168.78 v1(121.86,169.21) 122.06,169.41 122.77,169.41 123.02,169.67 PR227.1 PR226.1
ISL95857_PROG1: length 3.3
  TOP w0.203: PU1.32 152.75,180.28 v1(152.95,180.08)
  BOTTOM w0.114: v3(152.82,182.01) 152.82,181.67 PR203.1
  BOTTOM w0.203: v1(152.95,180.08) 152.68,180.35 152.68,180.66 PR203.1
ISL95857_PROG2: length 2.5
  TOP w0.203: v1(152.62,179.32) 152.62,179.7 152.43,179.88 PU1.31
  BOTTOM w0.203: v1(152.62,179.32) 152.54,179.24 v1(151.96,179.24) 151.96,179.79 PR206.1
ISL95857_PSYS: length 6.3
  TOP w0.114: PR25.2 156.38,186.8 v3(156.48,186.71)
  TOP w0.203: PR25.2 154.24,185.51 154.24,185.31 153.81,184.88 153.62,184.88 153.36,184.63 151.85,184.63 151.63,184.4 PU1.1
ISL95857_PWM1_B: length 3.9
  TOP w0.203: PU1.12 146.95,183.08 146.52,183.51 146.52,183.92 v1(146.34,184.1) 146.22,184.22 146.22,184.58 145.5,185.29 PR27.1
ISL95857_PWM2_B: length 7
  TOP w0.114: PR29.1 142.85,183.29 v1(142.79,183.23)
  TOP w0.203: PR29.1 143.1,184.27 143.34,184.27 143.85,184.78 145.39,184.78 145.86,184.31 145.86,183.66 146.84,182.68 PU1.13
ISL95857_PWM_A: length 3.2
  TOP w0.203: PR43.2 146.52,177.03 147.65,178.15 v1(147.71,178.15) 147.71,178.22 148.43,178.94 PU1.22
ISL95857_PWM_C: length 5.3
  TOP w0.203: PU1.30 151.63,179.06 152.39,178.3 153.66,178.3 v1(153.71,178.35) 154.19,177.87 154.19,177.75 154.39,177.54 155.04,177.54 PR47.2
ISL95857_RTN_A: length 11.2
  TOP w0.203: PR38.2 138.38,180.33 138.62,180.08 PR39.1 139.8,180.86 PC29.2 140.04,181.34 PC27.2 141.27,181 141.27,180.68 v1(141.62,180.34) 141.96,180.68 145.17,180.68 145.32,180.54 146.14,180.54 146.28,180.68 PU1.18
ISL95857_RTN_B: length 12.1
  TOP w0.203: v1(150.96,191.51) 150.96,191.89 150.72,192.14 PC10.1 150.46,191.26 150.58,191.14 PC12.2 150.96,190.49 150.96,186.56 150.13,185.72 149.92,185.72 v1(149.87,185.67) 149.63,185.43 PU1.6
  BOTTOM w0.203: v1(150.96,191.51) 150.96,191.76 PR180.1 151.47,192.03 151.47,191 PR181.2
ISL95857_RTN_C: length 14.5
  TOP w0.201: PU1.26 150.03,178.35 v1(150.2,178.18)
  TOP w0.203: PR52.2 152.03,169.92 v1(151.9,170.05) 151.4,170.56 148.92,170.56 PR49.1 148.81,171.45 148.94,171.45 149.33,171.84 PC45.2 149.57,171.84 149.69,171.95 PC44.2 150.08,173.36 v1(150.08,173.6)
  BOTTOM w0.203: v1(150.2,178.18) 150.08,178.18 149.72,177.82 149.72,175.87 150.1,175.48 150.1,173.63 v1(150.08,173.6)
ISL95857_SCLK: length 2.6
  TOP w0.203: PR35.2 154.14,182.11 153.97,182.28 PU1.37
ISL95857_SDA: length 2.9
  TOP w0.201: PR40.1 154.14,180.72 153.38,181.48 v1(153.25,181.48) 153.25,181.48 PU1.35
ISL95857_VCC: length 4.6
  TOP w0.203: PU1.34 152.82,181.08 152.93,180.97 153.4,180.97 154.19,180.18 v1(154.19,179.68) 154.19,179.65 154.27,179.57 154.27,179.57 PC32.1
  BOTTOM w0.203: PR204.2 154.39,179.88 v1(154.19,179.68)
ISL95857_VIN: length 7.3
  TOP w0.203: v1(156.3,178.56) 155.27,178.56 PC35.1 153.58,179.23 v1(153.58,179.83) 153.58,180.31 153.28,180.62 152.72,180.62 152.65,180.68 PU1.33
  BOTTOM w0.203: v1(156.3,178.56) 156.04,178.56 155.78,178.82 PR212.2
ISL95857_VR_EN: length 3.4
  TOP w0.203: PR28.1 153.89,184.29 153.12,184.29 v1(152.97,184.15) 152.97,183.79 152.66,183.48 PU1.40
ISL95857_VR_HOT: length 2.7
  TOP w0.203: PR32.1 154.32,182.68 PU1.38
ISL95857_VR_READY: length 3
  TOP w0.203: PU1.39 153.71,183.08 v1(153.78,183.16) 154.15,183.52 154.15,183.53 PR30.1
ISOLATEB: length 4.9
  TOP w0.114: R261.1 40.42,87.24 40.07,86.89 v1(39.89,86.89) 39.74,86.74 38.9,86.74 38.72,86.92 U15.20
  BOTTOM w0.114: v1(39.89,86.89) 40.45,86.33 v3(40.45,86.31) 40.72,86.58 R261.1
ISUMN_A: length 39.6
  TOP w0.203: PC33.1 141.95,179.74 142.42,180.21 PC30.2 ; PC33.1 141.32,179.07 v1(141.31,179.07) ; PC33.1 PR41.2 143.48,179.07 143.6,179.19 PC31.1
  IN1 w0.203: v1(141.31,179.07) 141.82,178.56 141.82,177.83 138.09,174.09 138.09,171.8 141.08,168.81 141.08,165.6 142.16,164.53 142.16,162.47 140.4,160.71 140.4,157.7 v1(140.17,157.48)
  BOTTOM w0.203: PR214.1 142.33,178.05 v1(141.31,179.07) 141.44,179.19 142.05,179.19 v3(142.86,178.38) 143.07,178.18 PR211.2 144.49,178.57 144.49,178.8 PR208.1 ; PR243.2 140.53,157.11 v1(140.17,157.48)
ISUMN_B: length 70.9
  TOP w0.203: 148.9,189.14 PR21.1 149.83,188.72 149.95,188.84 PC14.1 PR22.1 PC20.1 ; 148.9,189.14 149.39,189.63 PR17.1 ; 148.9,189.14 148.69,189.35 v1(148.4,189.35) 148.37,189.35 147.94,188.92 147.94,187.98 147.54,187.58 PC18.2 PC17.2 ; v1(129.43,173.86) 129.43,174.04 129.93,174.54 129.93,181.8 131.49,183.36 133.85,183.36 137.05,186.56 142.38,186.56 v1(142.71,186.23)
  BOTTOM w0.203: 148.42,189.33 v1(148.4,189.35) ; 148.42,189.33 148.63,189.12 PR182.1 150.2,188.87 v3(150.38,188.69) 151.28,187.79 151.28,186.74 149.61,185.07 143.31,185.07 142.71,185.67 v1(142.71,186.23) ; 148.42,189.33 PR192.1 PC20.1 ; v1(129.43,173.86) 129.17,174.11 126.45,174.11 124.49,172.14 120.93,172.14 120.1,171.32 120.1,167 122,165.1 PR241.1
ISUMN_C: length 25.9
  TOP w0.203: PC38.2 151.6,175.76 151.98,175.38 v1(152.11,175.38) 152.11,174.65 v1(151.75,174.29) 152.06,173.99 PC43.1 PR48.2 152.73,175.51 152.62,175.63 PC39.1
  IN1 w0.203: v1(153.87,160.64) 154.37,161.13 154.37,163.19 153.96,163.6 153.96,164.84 153.66,165.15 153.66,165.58 154.37,166.29 154.37,167.86 154.9,168.4 154.9,172.16 152.11,174.95 v1(152.11,175.38)
  BOTTOM w0.203: v1(153.87,160.64) PR242.2 ; PR221.1 151.73,175 v1(152.11,175.38) 152.61,175.88 PR219.1 PR220.2
ISUMP_A: length 13.1
  TOP w0.203: v1(143.6,179.7) 144.37,179.7 PC31.2 PC30.1 146.7,180.21 146.77,180.28 PU1.19
  BOTTOM w0.203: PR208.2 144.1,179.2 v1(143.6,179.7) 144.37,179.7 PC30.1 145.25,180.21 146.01,179.45 146.01,177.92 145.1,177.01 v3(144.64,177.01) PR215.1
ISUMP_B: length 13.8
  TOP w0.203: PR20.1 147.28,188.46 v1(146.9,188.08) ; v1(149.44,186.18) 150.08,186.18 150.46,186.56 PR22.2 PC20.2 149.18,186.8 148.93,186.56 148.93,185.23 149.23,184.93 PU1.7
  BOTTOM w0.203: PR20.1 147.28,188.46 v1(146.9,188.08) v3(147.49,187.5) 147.92,187.07 147.92,186.02 148.23,185.71 148.97,185.71 v1(149.44,186.18) PC20.2 150.22,187.58 PR193.2
ISUMP_C: length 13.1
  TOP w0.203: PC39.2 PC38.1 151.6,177.03 v1(151.09,177.54) 151.03,177.61 151.03,178.11 150.43,178.71 PU1.27
  BOTTOM w0.203: PR222.1 153.61,174.6 154.14,175.13 154.14,177.54 153.76,177.92 152.39,177.92 v3(152.26,177.8) 152.01,177.54 v1(151.09,177.54) 151.6,177.03 PR218.2 PR219.2
IVDDO: length 14.8
  TOP w0.203: v1(23.53,112.16) 23.33,111.96 U13.32
  IN2 w0.762: 17.11,106.42 17.11,107.44 16.62,107.92 16.62,110.61 19.29,113.28 24.35,113.28 24.73,112.9
  vias: v1(16.93,105.41) v1(17.56,105.41) v1(24.02,111.71) v1(25.64,113.33) v1(25.69,112.7)
JTAG_TCK: length 9.4
  BOTTOM w0.114: U34.AE5 173.23,149.57 172.86,149.2 172.86,147.95 172.67,147.76 171.32,147.76 171.21,147.87 168.21,147.87 167.2,146.86 TP47.1 166.86,147.12 R497.1
JTAG_TDI: length 10.2
  BOTTOM w0.114: U34.AE6 173.23,150.36 172.81,149.93 172.81,149.53 172.57,149.29 172.28,149.29 172.03,149.04 172.03,148.81 171.75,148.53 171.38,148.53 170.98,148.13 TP46.1 167.35,148.05 165.7,148.05 165.26,148.49 R489.1
JTAG_TDO: length 5.8
  BOTTOM w0.114: U34.AF6 172.33,150.62 171.92,150.21 171.59,150.21 170.8,149.42 168.14,149.42 167.75,149.81 TP45.1
JTAG_TMS: length 14
  BOTTOM w0.114: U34.AD6 173.95,150.54 173.65,150.24 173.65,147.93 173.47,147.75 173.01,147.75 172.81,147.54 172.81,147.11 172.66,146.96 168.62,146.96 166.67,145.01 TP48.1 166.05,145.41 165.19,145.41 164.82,145.78 R498.1
JTAG_TRST#: length 6.1
  BOTTOM w0.114: U34.AG4 171.42,148.92 171.11,148.61 167.55,148.61 166.84,149.32 166.02,149.32 R490.1
KB_BL_LED: length 105.6
  TOP w0.114: Q19.2 209.23,129.03 v1(208.62,128.42)
  IN1 w0.127: v1(209.87,48.18) 211.57,49.88 211.57,51.82 212.27,52.52 212.27,54.34 212.75,54.82 212.75,59.75 213.54,60.54 213.54,63.9 211.44,65.99 211.44,68.05 207.96,71.53 207.96,96.16 207.28,96.85 207.28,100.02 207.48,100.22 207.48,101.01 207,101.49 207,102.87 212.18,108.05 212.18,115.18 209.7,117.66 209.7,121.21 207.99,122.92 207.99,127.78 v1(208.62,128.42)
  BOTTOM w0.114: v1(209.87,48.18) 209.11,47.42 v3(208.34,47.42) 208.14,47.21 207.66,47.21 206.67,46.22 206.67,44.64 205.58,43.56 205.19,43.56 204.81,43.94 202.9,43.94 202.08,43.13 200.41,43.13 200.11,43.43 200.11,44.32 200.31,44.52 U45.113
KBSMI#: length 127.7
  IN1 w0.127: v1(201.76,35.8) 201.36,36.2 201.36,48.84 200.03,50.17 199.03,50.17 198.63,50.57 198.63,51.42 197.31,52.74 196.56,52.74 195.99,53.32 195.99,55.64 196.8,56.46 196.8,59.36 197.43,59.99 197.43,61.53 198.78,62.88 198.78,72.43 197.22,73.99 197.22,77.88 194.65,80.45 193.83,80.45 192.47,81.81 191.27,81.81 187.39,85.69 187.39,90.3 185.52,92.17 185.52,93.81 186.4,94.69 186.4,106.35 185.81,106.93 184.72,106.93 183.5,108.15 183.5,110.69 182.83,111.36 182.4,111.36 180.87,112.89 180.87,118.64 180.19,119.33 180.19,121.38 179.8,121.77 179.8,122.45 179.39,122.86 179.39,123.76 178.63,124.52 178.14,124.52 174.64,128.01 173.34,128.01 172.68,128.67 172.68,129.54 171.69,130.53 171.11,130.53 v1(171.01,130.63)
  BOTTOM w0.114: v1(171.01,130.63) 170.18,130.63 R780.1 169.19,131.62 169.16,131.62 169.16,131.62 168.51,131.62 168.51,131.62 168.39,131.62 168.08,131.31 168.08,130.78 167.74,130.43 R567.1 ; U45.15 207.17,38.31 207.02,38.17 207.02,38.04 206.29,37.31 205.7,37.31 204.05,35.66 201.9,35.66 v1(201.76,35.8)
L_SPK+: length 67.6
  IN1 w1.016: 41.24,34.11 42.18,35.05 43.78,35.05 45.28,33.55 45.28,30.77 46.7,29.35 46.7,19.02 53.56,12.16 61.07,12.16 61.84,11.4 67.86,11.4 70.85,14.4 70.85,20.36 68.46,22.75 63.41,22.75 60.46,19.8 60.46,19.45
  vias: v1(37.81,33.68) v1(38.44,33.68) v1(60.03,18.79) v1(60.03,18.13) v3(59.52,17.47)
L_SPK+_1:
  vias: v1(60.87,14.47) v1(61.5,14.47) v1(61.91,13.89)
L_SPK-: length 61.4
  IN1 w1.016: 40.47,35.23 41.44,36.19 43.27,36.19 43.29,36.22 44.01,36.22 44.03,36.19 44.28,36.19 46.42,34.06 46.42,31.24 47.84,29.82 47.84,19.73 54.19,13.38 61.48,13.38 62.32,12.54 67.37,12.54 69.68,14.85 69.68,19.87 68.08,21.48 63.89,21.48 62.49,20.08
  vias: v1(37.88,34.49) v1(38.52,34.49) v1(61.73,18.64) v1(62.14,19.17) v1(62.88,19.17)
L_SPK-_1:
  vias: v1(62.54,13.58) v1(62.97,14.09) v1(63.16,13.43)
LAN_MCT0: length 2.3
  TOP w0.762: R251.2 v1(16.6,92.96)
  BOTTOM w0.508: v1(16.6,92.96) 16.6,92.96 U42.24
LAN_MCT1: length 1.4
  BOTTOM w0.508: v1(16.67,89.8) 16.82,89.96 U42.21
  vias: v3(16.73,90.88)
LAN_MCT2: length 1.4
  BOTTOM w0.508: U42.18 16.96,86.96 v1(16.7,87.22)
  vias: v3(16.98,88.01)
LAN_MCT3: length 1.4
  BOTTOM w0.508: U42.15 v1(16.6,83.96)
  vias: v3(16.95,82.95)
LAN_MX0+: length 6.1
  BOTTOM w0.114: CN11.1 14.34,90.98 14.57,90.98 14.67,90.88 14.67,90.45 14.73,90.38 14.99,90.38 15.58,90.97 15.58,91.44 v3(16.22,92.07) 16.33,91.96 U42.23
LAN_MX0-: length 6.1
  BOTTOM w0.114: U42.22 16.37,90.96 v3(16.22,90.8) 15.23,89.81 14.47,89.81 13.99,89.34 CN11.2
LAN_MX1+: length 7.1
  BOTTOM w0.114: CN11.3 13.72,87.46 14.47,86.71 14.75,86.71 15.01,86.97 15.01,87.92 16.19,89.1 v3(16.22,89.1) 16.36,88.96 U42.20
LAN_MX1-: length 7.1
  BOTTOM w0.114: CN11.6 14.1,85.26 15.58,86.74 15.58,87.69 15.73,87.83 v3(16.22,87.83) 16.34,87.96 U42.19
LAN_MX2+: length 6.3
  TOP w0.114: CN11.4 13.42,87.3 13.61,87.49 14.58,87.49 15.33,86.74 15.33,86.4 15.58,86.15 v1(16.52,86.15)
  BOTTOM w0.114: U42.17 16.72,85.96 v1(16.52,86.15)
LAN_MX2-: length 6.3
  TOP w0.114: v1(16.48,84.86) 16.48,85.42 16.32,85.58 15.34,85.58 14.76,86.17 14.76,86.5 14.34,86.91 13.86,86.91 13.72,86.78 CN11.5
  BOTTOM w0.114: v1(16.48,84.86) 16.58,84.96 U42.16
LAN_MX3+: length 6
  BOTTOM w0.114: U42.14 16.34,82.96 v3(16.22,83.08) 15.67,82.53 14.12,82.53 13.72,82.92 CN11.7
LAN_MX3-: length 6
  BOTTOM w0.114: CN11.8 13.88,81.96 16.07,81.96 v3(16.22,81.81) 16.36,81.96 U42.13
LANVCC: length 15.1
  BOTTOM w1.524: 32.09,96.13 32.09,97.02 32.98,97.91 40.24,97.91 42,96.16 42,95.25 43.65,93.59
  vias: v1(31.58,95.63) v1(31.84,94.86) v1(32.22,95.37) v1(35.92,82.34) v1(35.94,81.7) v1(42.76,91.54) v1(43.14,90.8) v1(43.45,91.54) v3(44.69,91.84)
LCDVCC:
  vias: v3(124.42,185.47)
LCDVCC_R:
  vias: v1(130.31,185.8) v1(131.64,186.64) v1(132.27,186.64)
LID#: length 278
  TOP w0.114: MR1.2 63.85,4.45 64.73,5.33 64.73,7.86 R435.1 65.4,8.12 65.49,8.02 D23.2 66.13,7.39 66.03,7.29 65.44,7.29 v1(65.24,7.49) ; v1(114.44,178.1) 113.86,178.68 113.5,178.68 113.25,178.94 R53.2 113.75,179.18 114.29,179.73 D1.1 113.37,181.13 R460.2
  IN1 w0.127: v1(114.44,178.1) 114.57,177.98 114.57,177.97 115.4,177.14 115.4,174.27 118.07,171.6 118.07,161.92 118.2,161.79 118.2,150.03 117.36,149.19 117.36,145.92 117.64,145.64 117.64,145.11 118.15,144.6 118.15,143.25 114.3,139.4 114.3,137.07 113.25,136.01 109.34,136.01 107.53,134.2 107.53,132.58 106.88,131.94 106.75,131.94 105.34,130.53 102.45,130.53 96.42,124.5 96.42,123.91 90.04,117.53 88.86,117.53 85.57,114.25 85.57,111.67 84.04,110.13 80.23,110.13 75.1,105 58.17,105 57.04,103.87 57.04,98.36 54.19,95.52 54.19,88.66 56.96,85.89 56.96,82.78 57.32,82.42 58.18,82.42 59.05,81.55 59.05,80.2 60.27,78.99 61.61,78.99 62.78,77.82 81.3,77.82 86.75,72.37 v1(86.75,61.97)
  IN2 w0.127: v1(65.24,7.49) 66.79,9.04 68.77,9.04 71.84,12.11 78.52,12.11 85.26,18.84 85.26,22.99 v1(90.68,28.41)
  BOTTOM w0.114: v1(90.68,28.41) 90.68,28.48 91.99,29.79 91.99,35.96 94.55,38.53 94.55,49.63 v3(93.13,51.05) 93.13,51.61 90.74,54 90.74,57.98 v1(86.75,61.97)
LINE1-L: length 29.1
  TOP w0.203: v1(28.44,32.08) 28.86,32.5 U23.22
  TOP w0.381: C552.1 17.46,15.55 v1(16.66,15.55) ; v1(28.44,32.08) 28.66,31.85 v1(28.66,31.24)
  IN1 w0.381: v1(28.66,31.24) 28.66,30.75 28.17,30.25 28.17,28.58 26.78,27.2 19.98,27.2 16,23.22 16,18.41 17.3,17.12 17.3,16.19 v1(16.66,15.55)
LINE1-R: length 28.7
  TOP w0.203: U23.21 28.58,32.9 v1(28.44,32.76)
  TOP w0.381: C549.1 v1(16.73,16.43)
  IN1 w0.381: v1(28.44,32.76) 27.28,31.61 27.28,28.95 26.49,28.16 19.57,28.16 15.11,23.71 15.11,18.04 v1(16.73,16.43)
LINE1-VREFO-L: length 30.9
  TOP w0.203: U23.31 32.8,28.72 32.78,28.7
  TOP w0.381: 32.78,28.7 32.78,27.75 v3(32.37,27.33) 32.08,27.05 v1(31.58,27.05) ; v1(19.77,14.86) 19.22,14.86 R421.2
  IN1 w0.381: v1(31.58,27.05) 31.18,27.45 28.66,27.45 27.52,26.31 20.35,26.31 17.75,23.72 17.75,17.92 18.19,17.48 18.19,16.06 19.39,14.86 v1(19.77,14.86)
LINE1-VREFO-R: length 25.9
  TOP w0.203: v1(32.33,29.05) 32.4,29.12 U23.30
  TOP w0.381: v1(32.07,28.06) 32.22,28.22 32.22,28.94 v1(32.33,29.05) ; v1(19.52,18.51) R418.2
  IN1 w0.381: v1(19.52,18.51) 19.19,18.51 18.64,19.06 18.64,23.35 20.49,25.19 31,25.19 32.22,26.41 32.22,27.91 v1(32.07,28.06)
LM393_PIN2: length 64.4
  TOP w0.114: v1(86.07,80.26) 85.81,80.26 85.39,79.83 85.39,78.92 83.93,77.46 77.17,77.46 74.76,75.05 72.22,75.05 71.85,74.68 PR146.2 71.85,73.28 71.08,72.51 PU4.2
  BOTTOM w0.076: PR262.2 109.69,112
  BOTTOM w0.114: 109.69,112 109.19,112 95.22,98.03 95.22,95.81 94.6,95.19 94.6,91.77 92.47,89.64 89.69,89.64 87.1,87.05 87.1,82.67 v3(86.55,82.11) 86.07,81.63 v1(86.07,80.26)
LPC_LAD0: length 133.8
  TOP w0.114: v1(194.14,86.86) 192.87,85.59 182.2,85.59 180.5,87.29 179.09,87.29 178.23,88.15 176.84,88.15 176.59,87.91 176.59,86.31 175.94,85.65 170.38,85.65 170.17,85.44 170.17,84.54 170.03,84.41 169.85,84.41 169.71,84.54 169.71,86.91 169.58,87.04 169.39,87.04 169.25,86.91 169.25,85.81 169.12,85.68 168.93,85.68 168.8,85.81 168.8,86.91 168.66,87.04 168.47,87.04 168.34,86.91 168.34,86.18 168.22,86.06 167.96,86.06 167.75,86.27 v1(167.75,87.8)
  IN1 w0.127: v1(209.13,40.25) 209.61,40.74 209.61,41.67 207.37,43.92 207.37,45.17 207.66,45.46 207.96,45.46 208.53,46.03 208.53,48.68 v1(209.38,49.53) 210.65,50.8 210.65,52.52 211.38,53.25 211.38,64.38 209.32,66.43 209.32,68.31 205.7,71.93 205.7,78.48 202.65,81.53 201.41,81.53 196.08,86.86 v1(194.14,86.86)
  BOTTOM w0.114: v1(209.38,49.53) 209.81,49.95 209.81,50.71 210.06,50.96 210.6,50.96 210.73,50.83 210.73,50.27 210.87,50.14 211.06,50.14 211.19,50.27 211.19,50.83 211.33,50.96 211.52,50.96 211.65,50.83 211.65,50.27 211.78,50.14 211.97,50.14 212.11,50.27 212.11,50.83 212.24,50.96 212.64,50.96 212.81,50.79 U44.26 ; R688.1 192.47,94.1 195.39,91.18 195.39,88.11 v1(194.14,86.86) ; v1(209.13,40.25) 209.07,40.31 U45.10 ; R659.2 159.37,98.56 159.37,96.26 159.69,95.95 161.56,95.95 162.85,94.66 162.85,93.56 164.43,91.99 164.43,91.27 165.68,90.02 165.68,89.49 167.37,87.8 v1(167.75,87.8)
LPC_LAD0_C: length 4.3
  BOTTOM w0.114: R688.2 v1(190.26,94.1) 189.73,94.1 188.6,92.97 CN10.64
LPC_LAD1: length 135.1
  TOP w0.114: v1(171.16,89.15) 169.95,87.94 169.95,86.04 170.1,85.89 170.34,85.89 170.47,86.03 170.47,86.25 170.61,86.39 170.8,86.39 170.93,86.25 170.93,86.03 171.06,85.89 171.25,85.89 171.39,86.03 171.39,86.25 171.52,86.39 171.71,86.39 171.84,86.25 171.84,86.03 171.98,85.89 172.17,85.89 172.3,86.03 172.3,86.25 172.44,86.39 172.62,86.39 172.76,86.25 172.76,86.03 172.89,85.89 173.08,85.89 173.22,86.03 173.22,86.25 173.35,86.39 173.54,86.39 173.67,86.25 173.67,86.03 173.81,85.89 174,85.89 174.13,86.03 174.13,86.25 174.26,86.39 174.45,86.39 174.59,86.25 174.59,86.03 174.72,85.89 175.84,85.89 176.35,86.41 176.35,88.01 176.74,88.39 178.33,88.39 179.19,87.53 180.6,87.53 182.29,85.85 192.49,85.85 v1(193.51,86.86)
  IN1 w0.127: v1(193.51,86.86) 193.52,86.86 194,86.38 196.13,86.38 202.13,80.37 202.13,78.85 203.64,77.34 203.64,73.63 209.07,68.21 209.07,66.33 211.12,64.27 211.12,53.35 210.4,52.63 210.4,51.82 209.38,50.81 v1(209.38,50.16) 209.38,50.15 208.94,49.71 208.94,49.44 208.28,48.78 208.28,46.22 208.02,45.96 207.61,45.96 207.11,45.46 207.11,42.91 v1(209.13,40.89)
  BOTTOM w0.114: v1(171.16,89.15) 170.73,88.72 167.13,88.72 166.16,89.69 166.16,90.22 164.91,91.47 164.91,92.19 163.33,93.76 163.33,94.86 161.74,96.46 159.94,96.46 159.85,96.54 159.85,98.8 158.56,100.09 158.56,102.89 158.2,103.25 158.2,103.75 R640.2 ; U44.23 214.76,49.91 215.3,50.45 215.3,50.9 215,51.2 214.23,51.2 214.09,51.34 214.09,51.7 213.96,51.84 213.77,51.84 213.64,51.7 213.64,51.34 213.5,51.2 213.31,51.2 213.18,51.34 213.18,51.7 213.04,51.84 212.85,51.84 212.72,51.7 212.72,51.34 212.59,51.2 209.51,51.2 209.38,51.08 v1(209.38,50.16) ; v1(209.13,40.89) 208.96,40.71 U45.9 ; R690.1 194.18,91.16 194.18,90.68 194.18,90.67 194.18,87.54 v1(193.51,86.86)
LPC_LAD1_C: length 4.1
  BOTTOM w0.114: CN10.66 189.01,92.48 v1(189.45,92.91) 189.62,93.09 R690.2
LPC_LAD2: length 134.1
  TOP w0.114: v1(192.87,86.86) 192.11,86.1 182.37,86.1 180.7,87.77 179.29,87.77 178.43,88.63 176.64,88.63 176.09,88.08 176.09,86.81 175.9,86.63 175.66,86.63 175.52,86.76 175.52,87.7 175.39,87.83 175.2,87.83 175.06,87.7 175.06,86.76 174.93,86.63 174.74,86.63 174.61,86.76 174.61,87.7 174.47,87.83 174.28,87.83 174.15,87.7 174.15,86.76 174.02,86.63 173.83,86.63 173.69,86.76 173.69,87.7 173.56,87.83 173.37,87.83 173.24,87.7 173.24,86.76 173.1,86.63 170.81,86.63 170.42,87.02 170.42,87.78 v1(171.79,89.15)
  IN1 w0.127: v1(206.57,41.09) 206.57,41.34 206.21,41.7 206.21,45.46 208.03,47.28 208.03,48.89 208.62,49.48 208.62,50.8 v1(208.88,51.05) 209.13,51.05 210.02,51.94 210.02,52.61 210.21,52.8 210.21,64.83 208.81,66.22 208.81,68.1 203.39,73.53 203.39,77.24 200.91,79.71 200.91,81.21 196.08,86.05 193.69,86.05 v1(192.87,86.86)
  BOTTOM w0.114: U44.20 216.71,50.35 214.99,52.08 214.24,52.08 214.1,52.21 214.1,52.47 213.97,52.6 213.78,52.6 213.65,52.47 213.65,52.21 213.51,52.08 213.32,52.08 213.19,52.21 213.19,52.47 213.06,52.6 212.87,52.6 212.73,52.47 212.73,52.21 211.96,51.44 209.27,51.44 v1(208.88,51.05) ; R653.2 158.09,102.1 158.32,101.86 158.32,99.99 159.61,98.7 159.61,96.4 159.81,96.2 161.65,96.2 163.09,94.76 163.09,93.66 164.67,92.09 164.67,91.37 165.92,90.12 165.92,89.59 167.03,88.48 170.83,88.48 171.07,88.72 171.37,88.72 v1(171.79,89.15) ; U45.8 206.59,41.11 v1(206.57,41.09) ; v1(192.87,86.86) 193.94,87.92 193.94,90.86 192.72,92.07 R693.1
LPC_LAD2_C: length 3.8
  BOTTOM w0.114: CN10.68 188.46,91.97 188.56,92.07 v1(190.46,92.07) R693.2
LPC_LAD3: length 121.6
  TOP w0.114: v1(192.24,86.86) 191.73,86.36 182.46,86.36 180.8,88.01 179.41,88.01 178.55,88.87 176.34,88.87 175.92,89.29 175.64,89.29 175.51,89.16 175.51,88.57 175.37,88.44 175.18,88.44 175.05,88.57 175.05,89.16 174.92,89.29 174.73,89.29 174.59,89.16 174.59,88.57 174.46,88.44 174.27,88.44 174.13,88.57 174.13,89.16 174,89.29 173.81,89.29 173.68,89.16 173.68,88.57 173.54,88.44 173.35,88.44 173.22,88.57 173.22,89.16 173.09,89.29 172.29,89.29 171.92,89.66 171.03,89.66 v1(170.52,89.15)
  IN1 w0.127: v1(205.96,41.32) 205.96,44.52 205.88,44.6 205.45,44.6 205.32,44.73 205.32,44.95 207.77,47.41 207.77,47.85 207.62,48 207.45,48 207.3,48.15 207.3,48.37 207.45,48.52 207.62,48.52 207.77,48.67 207.77,48.99 208.37,49.59 208.37,51.18 v1(208.88,51.68) 209.38,51.68 209.77,52.07 209.77,52.91 209.96,53.1 209.96,64.72 208.56,66.12 208.56,68 203.13,73.42 203.13,73.84 203.13,73.84 203.13,77.13 200.62,79.64 200.62,81.1 196.02,85.7 193.41,85.7 192.25,86.86 v1(192.24,86.86)
  BOTTOM w0.114: U45.7 206.92,41.52 206.91,41.52 206.16,41.52 v1(205.96,41.32) ; v1(208.88,51.68) 211.86,51.68 212.1,51.92 212.1,52.17 212.77,52.84 217.37,52.84 218.66,51.55 U44.17 ; v1(170.52,89.15) 170.35,88.97 167.22,88.97 166.4,89.79 166.4,90.41 167.63,91.64 167.63,95.65 168.11,96.13 168.11,98.5 167.59,99.02 R668.2 ; v1(192.24,86.86) 193.56,88.18 193.56,90.83 193.31,91.08 192.87,91.08 192.85,91.05 R696.1
LPC_LAD3_C: length 4.4
  BOTTOM w0.114: CN10.70 188.7,91.48 188.81,91.59 v1(189.27,91.59) 189.45,91.77 190.13,91.77 190.31,91.59 191.06,91.59 R696.2
LPC_LFRAME#: length 155.3
  IN1 w0.127: v1(169.4,97.77) 169.89,97.77 170.52,97.14 170.52,96.81 170.37,96.66 170.11,96.66 169.96,96.51 169.96,96.3 170.11,96.15 170.37,96.15 170.52,96 170.52,95.79 170.37,95.64 169.66,95.64 169.51,95.49 169.51,95.28 169.66,95.14 170.18,95.14 170.33,94.99 170.33,93.94 170.48,93.79 171.57,93.79 171.72,93.64 171.72,93.43 171.57,93.28 170.3,93.28 170.15,93.13 170.15,92.92 170.3,92.77 172.23,92.77 172.41,92.59 172.41,92.38 172.3,92.26 170.23,92.26 170.08,92.11 170.08,91.9 170.23,91.75 172.27,91.75 172.42,91.61 172.42,91.4 172.27,91.25 170.21,91.25 170.08,91.12 170.08,90.83 170.17,90.74 170.52,90.74 170.67,90.59 170.67,90.29 170.82,90.14 171.03,90.14 171.17,90.29 171.17,90.59 171.32,90.74 171.53,90.74 171.68,90.59 171.68,90.29 171.83,90.14 172.04,90.14 172.19,90.29 172.19,90.59 172.34,90.74 173,90.74 v1(173.44,90.29) 173.44,88.44 176.26,85.62 176.26,85.12 176.41,84.97 176.61,84.97 176.76,84.82 176.76,84.61 176.61,84.46 176.41,84.46 176.26,84.32 176.26,83.35 178.2,81.4 179.2,81.4 180.75,79.86 180.75,76.05 184.1,72.7 184.1,72.33 184.25,72.18 184.32,72.18 184.47,72.03 184.47,71.82 184.32,71.67 184.25,71.67 184.1,71.52 184.1,71.31 184.25,71.16 184.32,71.16 184.47,71.01 184.47,70.8 184.32,70.65 184.25,70.65 184.1,70.51 184.1,70.3 184.25,70.15 184.32,70.15 184.47,70 184.47,69.79 184.32,69.64 184.25,69.64 184.1,69.49 184.1,69.28 184.25,69.13 184.32,69.13 184.47,68.98 184.47,68.77 184.32,68.62 184.25,68.62 184.1,68.47 184.1,68.26 184.25,68.11 184.32,68.11 184.47,67.97 184.47,67.76 184.32,67.61 184.25,67.61 184.1,67.46 184.1,65.92 184.33,65.68 184.54,65.68 184.69,65.82 184.9,65.82 185.05,65.67 185.05,65.46 184.9,65.32 184.9,65.11 185.05,64.96 185.26,64.96 185.41,65.1 185.62,65.1 185.76,64.96 185.76,64.75 185.62,64.6 185.62,64.39 185.77,64.24 185.98,64.24 186.12,64.39 186.33,64.39 186.48,64.24 186.48,64.03 186.34,63.88 186.34,63.67 186.49,63.52 186.7,63.52 186.84,63.67 187.05,63.67 187.2,63.52 187.2,63.31 187.06,63.17 187.06,62.95 187.21,62.81 187.42,62.81 187.56,62.95 187.77,62.95 187.92,62.8 187.92,62.59 187.78,62.45 187.78,62.24 187.93,62.09 188.14,62.09 188.28,62.23 188.49,62.23 188.64,62.08 188.64,61.87 188.5,61.73 188.5,61.52 189.06,60.95 189.06,51.83 194.63,46.27 194.63,45.81 194.78,45.66 194.94,45.66 195.08,45.51 195.08,45.3 194.94,45.15 194.78,45.15 194.63,45 194.63,44.79 194.78,44.64 195.3,44.64 195.45,44.49 195.45,44.28 195.3,44.14 194.78,44.14 194.63,43.99 194.63,43.78 194.78,43.63 194.94,43.63 195.08,43.48 195.08,43.27 194.94,43.12 194.78,43.12 194.63,42.97 194.63,42.5 195.08,42.04 v1(195.08,41.45)
  BOTTOM w0.076: 158.1,105.99 157.81,105.99 157.49,106.32 155.09,106.32 154.6,106.81 153.76,106.81 153.57,107 152.49,107 152.18,107.31 151.47,107.31 151.32,107.46 150.49,107.46 150.09,107.86 150.09,109.01 150.06,109.04 U35.BA12
  BOTTOM w0.114: v1(169.4,97.77) 168.97,98.2 168.97,99.79 166.87,101.9 166.87,103.43 164.51,105.79 164.17,105.79 163.97,105.99 160.44,105.99 160.21,105.76 160.13,105.76 159.7,105.34 158.75,105.34 158.1,105.99 ; U44.22 215.41,48.15 215.84,47.72 215.84,43.81 214.16,42.13 211.77,42.13 211.11,42.79 209.89,42.79 209.26,42.16 209.11,42.16 208.86,41.91 U45.6 205.61,41.91 205.24,41.54 204.07,41.54 203.85,41.33 198.4,41.33 198.27,41.46 198.27,42.32 198.14,42.45 197.95,42.45 197.81,42.31 197.81,41.46 197.68,41.33 195.21,41.33 v1(195.08,41.45) ; R699.2 176.07,90.8 175.77,91.11 173.88,91.11 173.7,90.93 173.7,90.55 v1(173.44,90.29)
LPC_LFRAME#_C: length 2.4
  BOTTOM w0.114: R699.1 178.08,90.98 178.85,90.98 179.11,90.72 CN10.73
LPCPD: length 3.1
  BOTTOM w0.114: R744.2 v3(211.14,47.39) 211.14,48.18 211.51,48.55 U44.28
LPM_ZVM_N: length 49.4
  BOTTOM w0.114: R762.2 90.95,111.5 80.94,101.49 v3(75.78,101.49) 60.91,101.49 56.75,97.34 56.75,91.54 57.1,91.19 PR280.1
M_A_A0: length 66.4
  IN1 w0.216: v1(126.62,104.91) 127.9,103.63 127.9,98.55 127.97,98.48 127.97,82.09 129.42,80.64 129.42,75.64 130.52,74.54 130.52,68.08 131.28,67.32 131.28,51.05 v1(131.53,50.8)
  BOTTOM w0.076: v1(126.62,104.91) 127.2,104.91 127.5,105.22 127.5,105.81 128.48,106.79 128.48,107.98 128.31,108.16 128.31,108.42 128.34,108.5 128.35,108.51 128.36,108.54 128.36,108.68 128.3,108.91 128.3,109.04 128.37,109.26 128.57,109.46 U35.AY50
  BOTTOM w0.165: v1(131.53,50.8) 132.3,50.03 132.3,49.42 132.74,48.98 JDIM2.98
M_A_A1: length 65.4
  IN1 w0.216: v1(126.62,103.63) 126.71,103.63 127.6,102.74 127.6,97.12 127.5,97.02 127.5,81.9 128.95,80.45 128.95,75.44 130.05,74.34 130.05,67.89 130.81,67.13 130.81,61.69 130.6,61.47 130.27,61.47 130.05,61.26 130.05,60.83 130.27,60.61 130.6,60.61 130.81,60.39 130.81,51.81 130.64,51.64 v1(130.28,51.64)
  BOTTOM w0.076: 127.22,104.69 127.68,105.16 127.68,105.75 128.65,106.71 128.65,108.24 U35.BB50
  BOTTOM w0.102: 127.22,104.69 127.22,104.22 v1(126.62,103.63)
  BOTTOM w0.165: JDIM2.97 132.44,53.8 v1(130.28,51.64)
M_A_A2: length 67.3
  IN1 w0.216: v1(127.1,105.39) 128.21,104.28 128.21,99.79 128.44,99.56 128.44,82.29 129.89,80.84 129.89,75.83 131.04,74.68 131.04,68.22 131.76,67.5 131.76,51.58 132.8,50.54 132.8,49.78 132.42,49.4 v1(131.53,49.4)
  BOTTOM w0.076: v1(127.1,105.39) 127.1,105.65 128.32,106.86 128.32,107.91 128.14,108.09 128.14,108.46 128.19,108.57 128.19,108.69 128.12,108.91 128.12,109.05 128.18,109.21 128.18,109.71 U35.AY51
  BOTTOM w0.165: v1(131.53,49.4) 132.14,48.79 JDIM2.96
M_A_A3: length 66
  IN1 w0.216: v1(130.28,52.98) 130.28,54.26 130.06,54.48 129.8,54.48 129.58,54.7 129.58,55.13 129.8,55.34 130.06,55.34 130.34,55.62 130.34,55.99 129.58,56.75 129.58,58.62 130.34,59.38 130.34,59.87 129.58,60.63 129.58,63.87 130.34,64.63 130.34,66.93 129.58,67.69 129.58,74.07 129.3,74.36 128.99,74.36 128.71,74.08 128.41,74.08 128.1,74.39 128.1,74.69 128.48,75.07 128.48,80.25 127.03,81.7 127.03,97.07 127.27,97.32 127.27,102.55 126.87,102.96 v1(126.62,102.96)
  BOTTOM w0.076: U35.BA50 128.57,108.82 128.84,108.55 128.84,108.16 128.81,108.13 128.81,106.64 127.86,105.69 127.86,105.05 127.46,104.65 127.46,104.52
  BOTTOM w0.102: v1(126.62,102.96) 127.2,102.96 127.46,103.21 127.46,104.52
  BOTTOM w0.165: JDIM2.95 131.84,53.8 131.03,52.98 v1(130.28,52.98)
M_A_A4: length 65.6
  IN1 w0.076: v1(125.4,103.61) 126.02,102.99 126.02,99.13 125.98,99.09 125.98,98.15
  IN1 w0.216: 125.98,98.15 125.15,97.32 125.15,74.68 127.67,72.16 127.67,65.15 127.16,64.63 127.16,62.23 127.17,62.23 127.17,59.41 127.62,58.96 127.62,52.07 129.76,49.93 v1(129.88,49.93)
  BOTTOM w0.076: U35.BB52 127.15,108.21 127.15,106.46 125.88,105.19 125.88,104.76 125.81,104.69 125.81,104.61
  BOTTOM w0.102: 125.81,104.61 125.81,104.01 v1(125.4,103.61)
  BOTTOM w0.165: v1(129.88,49.93) 130.94,48.87 JDIM2.92
M_A_A5: length 68.2
  IN1 w0.076: 126.97,100.62 127.04,100.69 127.04,101.24 v1(126.62,101.66)
  IN1 w0.216: v1(129.12,52.29) 129.35,52.29 129.63,52.57 129.63,53.88 129.11,54.4 129.11,72.71 127.58,74.24 127.58,74.84 128.01,75.26 128.01,80.06 127.58,80.49 126.56,81.51 126.56,97.23 126.97,97.64 126.97,100.62
  BOTTOM w0.076: 126.22,104.55 126.22,105.06 127.48,106.32 127.48,107.89 127.68,108.09 127.68,108.45 127.68,108.45 127.64,108.54 127.64,108.74 127.68,108.83 127.68,108.83 127.68,108.83 127.69,108.84 127.69,109.07 U35.BA51
  BOTTOM w0.102: v1(126.62,101.66) 126.22,102.06 126.22,104.55
  BOTTOM w0.165: v1(129.12,52.29) 128.46,52.29 128.23,52.07 128.23,51.3 128.61,50.92 129.56,50.92 129.81,51.18 129.81,53.27 130.64,54.1 JDIM2.91
M_A_A6: length 65.7
  IN1 w0.076: v1(125.4,104.26) 126.21,103.45 126.21,97.75
  IN1 w0.216: v1(129.88,48.51) 130.52,49.14 130.52,50.14 128.17,52.48 128.17,72.32 125.62,74.88 125.62,97.15 126.21,97.75
  BOTTOM w0.076: U35.BA52 127.25,108.74 126.98,108.48 126.98,106.53 125.72,105.26 125.72,104.83 125.61,104.72 125.61,104.46 v1(125.4,104.26)
  BOTTOM w0.165: v1(129.88,48.51) 130.34,48.05 JDIM2.90
M_A_A7: length 68.6
  IN1 w0.076: 125.69,98.29 125.69,99.31 125.83,99.45 125.83,102.53 v1(125.4,102.96)
  IN1 w0.216: v1(128.02,50.39) 127.81,50.19 127.32,50.19 127.07,50.43 127.07,55.89 126.6,56.36 126.6,59.09 126.69,59.18 126.69,67.31 127.2,67.82 127.2,71.96 124.68,74.49 124.68,97.28 125.69,98.29
  BOTTOM w0.076: U35.AW52 127.35,110.08 127.03,109.75 127.03,109.21 126.82,109 126.82,106.59 125.55,105.33 125.55,104.98 125.01,104.44 125.01,103.35 v1(125.4,102.96)
  BOTTOM w0.165: v1(128.02,50.39) 128.89,50.39 129.14,50.14 JDIM2.86
M_A_A8: length 67.4
  IN1 w0.216: v1(129.12,53.59) 128.84,53.59 128.64,53.79 128.64,72.52 126.45,74.71 126.45,75.05 127.54,76.14 127.54,76.43 127.32,76.64 126.3,76.64 126.09,76.86 126.09,77.29 126.3,77.51 127.32,77.51 127.54,77.72 127.54,78.16 127.32,78.37 126.3,78.37 126.09,78.59 126.09,79.02 126.3,79.24 127.3,79.24 127.52,79.45 127.52,79.88 127.3,80.1 126.3,80.1 126.09,80.31 126.09,97.19 126.52,97.62 126.52,100.9 v1(126.62,101.01)
  BOTTOM w0.076: 126.01,104.51 126.01,104.66 126.05,104.69 126.05,105.12 127.31,106.39 127.31,107.96 127.51,108.16 127.51,108.42 127.48,108.51 127.48,108.52 127.48,108.77 127.51,108.86 127.51,109.07 127.48,109.15 127.48,109.15 127.45,109.25 127.45,109.51 U35.AY52
  BOTTOM w0.102: 126.01,104.51 126.01,101.23 126.24,101.01 v1(126.62,101.01)
  BOTTOM w0.165: JDIM2.89 130.04,54.13 129.88,53.97 129.5,53.97 v1(129.12,53.59)
M_A_A9: length 67.2
  IN1 w0.216: v1(125.4,99.7) 125.4,98.66 124.21,97.47 124.21,74.29 126.22,72.28 126.22,71.65 126.44,71.44 126.49,71.44 126.71,71.22 126.71,70.79 126.49,70.57 126.44,70.57 126.22,70.36 126.22,69.92 126.44,69.71 126.49,69.71 126.71,69.49 126.71,69.06 126.49,68.84 126.44,68.84 126.22,68.63 126.22,59.37 126.13,59.27 126.13,55.76 126.25,55.64 126.25,52.78 v1(126.58,52.45)
  BOTTOM w0.076: v1(125.4,99.7) 124.39,100.72 124.39,104.67 125.06,105.34 125.06,105.54 126.32,106.8 126.32,108.21 U35.BB54
  BOTTOM w0.165: JDIM2.85 128.84,54.08 127.6,52.83 127.6,50.92 127.34,50.67 126.83,50.67 126.58,50.92 v1(126.58,52.45)
M_A_A10: length 67
  IN1 w0.216: v2(128.98,111.76) 128.87,111.76 128.23,111.12 128.23,109.5 129.4,108.33 130.21,108.33 130.85,107.68 130.85,107.01 130.85,107.01 130.85,101 131.33,100.51 131.33,83.48 135.05,79.76 135.05,79.29 134.84,79.07 133.53,79.07 133.31,78.86 133.31,78.43 133.53,78.21 134.84,78.21 135.05,77.99 135.05,77.56 134.84,77.35 133.53,77.35 133.31,77.13 133.31,76.7 133.53,76.48 134.17,76.48 135.05,75.6 135.05,68.01 135.67,67.39 135.67,64.38 135.34,64.06 135.34,62.3 135.67,61.97 135.67,56.97 v1(135.37,56.66)
  BOTTOM w0.165: U35.AT50 v2(128.98,111.76) ; JDIM2.107 135.44,56.59 v1(135.37,56.66)
M_A_A11: length 67.1
  IN1 w0.076: 124.96,98.85 124.96,100.56 v1(125.4,101.01)
  IN1 w0.216: 124.96,98.85 123.74,97.63 123.74,74.1 125.75,72.08 125.75,70.06 125.18,69.49 125.18,68.58 125.75,68.01 125.75,59.67 125.64,59.56 125.64,55.51 125.71,55.44 125.71,51.67 126.58,50.8 126.58,49.4 126.88,49.1 v1(128.02,49.1)
  BOTTOM w0.076: U35.BA54 126.22,108.75 126.49,108.49 126.49,106.73 125.22,105.47 125.22,105.22 124.59,104.59 124.59,101.82 v1(125.4,101.01)
  BOTTOM w0.165: JDIM2.84 128.54,48.71 128.15,49.1 v1(128.02,49.1)
M_A_A12: length 69.1
  IN1 w0.216: v1(125.4,101.66) 125.35,101.66 124.7,101.01 124.7,99.16 123.27,97.72 123.27,73.9 124.43,72.74 124.43,70.57 124.64,70.35 124.64,62.37 125.17,61.84 125.17,59.35 124.64,58.82 124.64,55.85 125.24,55.25 125.24,52.53 v1(124.78,52.07)
  BOTTOM w0.076: U35.AW54 126.12,110.05 126.43,109.74 126.43,109.19 126.65,108.97 126.65,106.66 125.39,105.4 125.39,105.08 124.8,104.49 124.8,102.26 v1(125.4,101.66)
  BOTTOM w0.165: JDIM2.83 128.24,54.11 127.09,52.95 126.45,52.95 126.01,52.51 126.01,51.49 125.56,51.05 125.06,51.05 124.78,51.33 v1(124.78,52.07)
M_A_A13: length 69.5
  IN1 w0.216: v2(130.84,111.11) 130.84,110.79 133.54,108.1 133.54,106.17 133.74,105.98 133.74,84.4 135.64,82.5 135.64,82.5 138.66,79.48 138.66,75.08 138.44,74.86 138.34,74.86 138.13,74.64 138.13,74.21 138.34,74 138.44,74 138.66,73.78 138.66,73.35 138.44,73.13 138.34,73.13 138.13,72.92 138.13,72.49 138.34,72.27 138.44,72.27 138.66,72.05 138.66,71.62 138.44,71.41 138.34,71.41 138.13,71.19 138.13,70.76 138.34,70.54 138.44,70.54 138.66,70.33 138.66,69.89 138.44,69.68 138.34,69.68 138.13,69.46 138.13,69.03 138.34,68.82 138.44,68.82 138.66,68.6 138.66,67.86 139.14,67.38 139.14,64.49 138.53,63.89 138.53,61.06 138.75,60.85 139.15,60.85 139.57,60.42 139.57,59.15 138.82,58.41 138.82,56.16 139.05,55.93 139.42,55.93 139.62,55.73 139.62,55.27 139.42,55.07 139.05,55.07 138.85,54.87 138.85,53.2 138.99,53.06 v1(139.37,53.06)
  BOTTOM w0.165: v1(139.37,53.06) 138.9,53.53 138.9,53.97 139.04,54.12 JDIM2.119 ; v2(130.84,111.11) U35.AU46
M_A_A14: length 67
  IN1 w0.216: v1(126.07,50.03) 124.11,52 124.11,54.98 123.44,55.65 123.44,64.27 123.68,64.5 123.68,69.7 123.47,69.91 123.47,72.37 122.33,73.51 122.33,97.84 124.09,99.61 124.09,102.68 v1(123.56,103.21)
  BOTTOM w0.076: U35.AY54 126.02,109.51 126.02,109.26 125.94,109.04 125.94,108.91 126.01,108.68 126.01,108.54 125.95,108.42 125.95,108.16 126.16,107.96 126.16,106.87 124.89,105.61 124.89,105.41 124.18,104.71 124.18,104.52
  BOTTOM w0.102: 124.18,104.52 124.18,103.83 v1(123.56,103.21)
  BOTTOM w0.165: v1(126.07,50.03) 127.34,48.76 JDIM2.80
M_A_A15: length 66.8
  IN1 w0.216: v1(126.11,48.64) 125.31,49.44 125.31,50.11 123.64,51.78 123.64,54.79 122.97,55.45 122.97,64.46 123.21,64.7 123.21,69.15 123,69.36 123,72.18 121.86,73.32 121.86,97.8 123.79,99.73 123.79,101.6 123.1,102.28 123.1,104.1 123.51,104.51 v1(123.56,104.51)
  BOTTOM w0.076: v1(123.56,104.51) 123.74,104.69 123.74,104.79 124.56,105.61 124.56,105.74 125.45,106.63 125.45,107.17 125.2,107.42 125.2,107.92 125.32,108.04 125.32,108.45 125.27,108.59 125.27,108.7 125.32,108.83 125.32,109.06 U35.BA55
  BOTTOM w0.165: v1(126.11,48.64) 126.74,48 JDIM2.78
M_A_BS#0: length 66.3
  IN1 w0.216: v1(135.6,52.98) 135.07,53.51 135.07,55.84 134.6,56.31 134.6,61.39 134.75,61.55 134.75,64.77 135.18,65.19 135.18,67.22 134.58,67.82 134.58,74.76 132.84,76.5 132.84,77.81 132.63,78.03 132.51,78.03 132.3,78.24 132.3,78.68 132.51,78.89 132.63,78.89 132.84,79.11 132.84,79.54 132.63,79.76 132.51,79.76 132.3,79.97 132.3,80.4 132.51,80.62 132.63,80.62 132.84,80.83 132.84,81.3 130.86,83.28 130.86,100.18 130.52,100.52 130.52,106.57 127.47,109.62 127.47,110.81 v2(127.17,111.11)
  BOTTOM w0.165: JDIM2.109 136.04,53.43 v1(135.6,52.98) ; U35.AU52 v2(127.17,111.11)
M_A_BS#1: length 69.8
  IN1 w0.216: v2(129.92,111.76) 129.46,111.3 129.46,110.53 131.79,108.2 131.79,105.15 132.14,104.8 132.14,99.21 132.33,99.02 132.33,83.81 134.23,81.91 135.99,80.15 135.99,69.46 136.36,69.1 136.36,68.04 137.12,67.27 137.12,60.92 136.65,60.45 136.65,57.87 137.38,57.15 137.38,56.24 136.78,55.65 136.78,49.81 136.2,49.22 v1(136.17,49.22)
  BOTTOM w0.165: v1(136.17,49.22) 135.74,48.8 JDIM2.108 ; v2(129.92,111.76) U35.AT48
M_A_BS#2: length 67
  IN1 w0.216: v1(123.56,103.86) 124.57,103.86 124.93,103.5 124.93,101.85 124.4,101.32 124.4,99.28 122.8,97.68 122.8,73.71 123.96,72.55 123.96,70.19 124.15,70 124.15,64.31 123.91,64.07 123.91,63.6 124.17,63.34 124.17,62.74 123.91,62.48 123.91,61.61 124.13,61.4 124.49,61.4 124.7,61.18 124.7,60.75 124.49,60.53 124.13,60.53 123.91,60.32 123.91,59.56 124.17,59.3 124.17,58.8 123.91,58.54 123.91,58.04 124.17,57.77 124.17,57.15 123.91,56.89 123.91,55.84 124.75,55 v1(124.75,53.59)
  BOTTOM w0.076: U35.AY55 125.46,109.84 125.75,109.55 125.82,109.39 125.82,109.21 125.77,109.05 125.77,108.91 125.83,108.69 125.83,108.57 125.8,108.49 125.79,108.46 125.79,108.09 125.99,107.89 125.99,106.94 124.73,105.67 124.73,105.51 123.97,104.76 123.97,104.52
  BOTTOM w0.102: v1(123.56,103.86) 123.82,103.86 123.97,104.01 123.97,104.52
  BOTTOM w0.165: v1(124.75,53.59) 125.41,52.93 125.83,52.93 126.28,53.37 126.75,53.37 127.04,53.67 JDIM2.79
M_A_CAS#: length 69.6
  IN1 w0.216: v1(137.4,53.03) 137.68,53.03 137.86,53.21 137.86,54.06 137.25,54.67 137.25,55.36 137.86,55.97 137.86,58.82 137.15,59.53 137.15,60.06 137.59,60.51 137.59,67.6 137.19,68 137.19,73.12 136.97,73.33 136.68,73.33 136.46,73.55 136.46,73.98 136.97,74.49 136.97,79.83 132.8,84.01 132.8,100.84 132.45,101.19 132.45,105.13 132.17,105.41 132.17,108.33 129.92,110.58 v2(129.92,111.11)
  BOTTOM w0.165: JDIM2.115 137.84,54.22 138.48,53.59 138.48,53.25 138.99,52.74 138.99,52.35 138.58,51.94 138.01,51.94 137.4,52.55 v1(137.4,53.03) ; v2(129.92,111.11) U35.AU48
M_A_CKE0: length 69.3
  IN1 w0.216: v1(124.71,49.68) 124.37,49.68 122.91,51.13 122.91,54.44 122.25,55.1 122.25,71.9 121.13,73.02 121.13,98.39 123.31,100.57 v1(123.31,100.58)
  BOTTOM w0.076: 122.9,104.66 124.72,106.48 124.72,108.02 124.63,108.12 124.63,108.42 124.63,108.42 124.74,108.67 124.75,108.67 124.75,108.68 124.89,108.82 U35.BA56
  BOTTOM w0.102: 122.9,104.66 122.9,100.99 v1(123.31,100.58)
  BOTTOM w0.165: v1(124.71,49.68) 124.04,50.35 124.04,53.59 125.24,54.79 JDIM2.73

# Allegro board Quanta ZRW REV F - BoardView (.BRD).brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
+VCCDSW_1P0: length 5.6
  BOTTOM w0.076: U35.AL1 156.58,114.93 158.77,114.93 159.02,115.18 159.02,115.39 159.8,116.18 160.16,116.18 160.21,116.12 160.36,116.12
  BOTTOM w0.114: C712.1 161.02,116.28 160.87,116.12 160.36,116.12
+VCCEOPIO: length 17.4
  IN1 w3.048: 94.74,102.45 94.74,107.3 98.36,110.92 98.36,111.4 100.81,113.85
  BOTTOM w0.508: v1(112.27,118.71) 112.27,118.27 111.21,117.21 C709.1 C708.1
  vias: v1(122.11,117.48) v1(122.34,116.84) v1(122.69,117.75) v1(122.97,116.84) v3(87.74,102.05) v4(89.52,102.43) v4(90.26,102.43) v4(91,102.43) v4(91.73,102.43) v4(92.47,102.43)
+VCCGT: length 123.9
  IN2 w0.254: v1(122.77,158.36) 122.26,158.87 122.26,162.94 123.46,164.13 123.46,167.99 126.1,170.63 129.53,170.63 131.36,172.46 131.36,178.23 132.88,179.75 136.23,179.75 137.35,180.87 137.35,180.95 141.43,185.03 144.36,185.03 146.65,187.32 148.9,187.32 149.95,188.37 v1(149.95,190.83)
  BOTTOM w0.127: 123.06,126.31 U35.K60 ; U35.K60 122.74,125.99 ; U35.K60 123.38,125.99 ; U35.K60 123.06,125.67 ; U35.L62 121.85,124.94 ; U35.L62 121.85,125.57 ; U35.L62 121.53,125.25 ; U35.L62 122.17,125.25 ; 133.12,115.3 U35.AK42 132.8,115.62 ; U35.AK43 132.2,115.3 ; U35.AK43 132.52,115.62 ; U35.AK43 132.2,115.94 ; U35.AK53 126.72,115.3 ; U35.AK53 126.72,115.94 ; U35.AK53 126.4,115.62 ; U35.AK53 127.03,115.62 ; 123.97,126.31 U35.K58 ; U35.K58 124.29,125.99 ; U35.K58 123.97,125.67 ; U35.K58 123.66,125.99 ; 130.83,126.14 U35.J45 ; U35.AK52 127.63,115.94 ; U35.AK52 127.63,115.3 ; U35.AK52 127.31,115.62 ; U35.AK52 127.95,115.62 ; 130.06,115.62 U35.AK46 ; U35.AK46 130.37,115.94 ; U35.AK46 130.37,115.3 ; U35.AK46 130.69,115.62 ; U35.M62 121.53,124.34 ; U35.M62 121.85,123.95 ; U35.M62 121.85,124.66 ; U35.M62 122.24,124.34 ; U35.J58 123.2,126.46 ; U35.J58 123.52,126.14 ; U35.J58 123.83,126.46 ; U35.AK50 128.55,115.94 ; U35.AK50 128.55,115.3 ; U35.AK50 128.86,115.62 ; U35.AK50 128.23,115.62 ; 132.66,115.47 U35.AL43 ; U35.AL43 132.66,114.84 ; U35.AL43 132.98,115.16 ; U35.AL43 132.34,115.16 ; U35.K48 129.14,125.99 ; U35.K48 129.78,125.99 ; U35.K48 129.46,125.67 ; 124.29,115.62 U35.AK58 ; U35.AK58 123.66,115.62 ; U35.AK58 123.97,115.3 ; U35.K56 124.89,125.67 ; U35.K56 124.57,125.99 ; U35.K56 124.89,126.31 ; U35.K56 125.21,125.99 ; 125.94,126.46 U35.J53 126.26,126.14 ; 121.07,122.97 U35.R63 ; U35.R63 121.38,123.29 ; U35.R63 121.38,122.65 ; U35.AK56 124.89,115.3 ; U35.AK56 125.21,115.62 ; U35.AK56 124.57,115.62 ; 121.07,121.14 U35.W63 121.38,120.82 ; U35.J60 122.6,126.77 ; U35.J60 122.6,126.14 ; U35.J60 122.28,126.46 ; U35.J60 122.92,126.46 ; U35.AK45 130.97,115.62 ; U35.AK45 131.29,115.3 ; U35.AK45 131.29,115.94 ; U35.AL60 123.2,115.16 ; U35.AL60 123.52,114.84 ; U35.AL60 123.52,115.47 ; U35.AL60 123.83,115.16 ; U35.N63 121.38,124.28 ; U35.N63 121.78,123.88 ; U35.N63 121.02,123.88 ; U35.N63 121.38,123.49 ; 128.41,126.46 U35.J50 ; U35.J50 127.77,126.46 ; U35.J50 128.09,126.77 ; U35.J50 128.09,126.14 ; U35.L63 121.07,124.8 ; U35.L63 121.7,124.8 ; U35.L63 121.38,124.48 ; U35.L63 121.38,125.12 ; 123.06,115.3 U35.AK60 123.38,115.62 ; 127.17,126.14 U35.J52 127.49,126.46 ; 124.75,126.46 U35.J56 ; U35.J56 124.11,126.46 ; U35.J56 124.43,126.14 ; U35.J56 124.43,126.77 ; U35.K50 128.23,125.99 ; U35.K50 128.86,125.99 ; U35.K50 128.55,125.67 ; U35.K50 128.55,126.31 ; U35.J55 125.35,126.14 ; U35.J55 125.66,126.46 ; U35.J55 125.03,126.46 ; U35.J55 125.35,126.77 ; U35.K55 125.49,125.99 ; U35.K55 126.12,125.99 ; U35.K55 125.8,126.31 ; U35.K55 125.8,125.67 ; 130.83,115.47 U35.AL46 ; U35.AL46 131.15,115.16 ; U35.AL46 130.83,114.84 ; U35.AL46 130.51,115.16 ; U35.K52 127.95,125.99 ; U35.K52 127.63,125.67 ; U35.K52 127.31,125.99 ; U35.K52 127.63,126.31 ; U35.AL53 126.86,115.16 ; U35.AL53 127.49,115.16 ; U35.AL53 127.17,114.84 ; U35.AL53 127.17,115.47 ; 129,114.84 U35.AL50 ; U35.AL50 129.32,115.16 ; U35.AL50 129,115.47 ; U35.AL50 128.69,115.16 ; 129.14,115.62 U35.AK48 ; U35.AK48 129.46,115.3 ; U35.AK48 129.46,115.94 ; U35.AK48 129.78,115.62 ; U35.AK55 126.12,115.62 ; U35.AK55 125.8,115.94 ; U35.AK55 125.49,115.62 ; U35.AK55 125.8,115.3 ; U35.K53 126.4,125.99 ; U35.K53 126.72,125.67 ; U35.K53 127.03,125.99 ; 125.66,115.16 U35.AL56 ; U35.AL56 125.35,115.47 ; U35.AL56 125.03,115.16 ; U35.J43 131.75,126.14 ; U35.AA63 121.38,120.54 ; U35.AA63 121.38,119.91 ; U35.AA63 121.07,120.23 ; U35.J46 129.92,126.14 ; 129,126.14 U35.J48 128.69,126.46
  BOTTOM w0.152: v1(124.18,106.89) 124.18,106.92 124.26,107 U35.BB57 ; v1(129.4,131.72) 129.18,131.5 U35.A48
  BOTTOM w0.178: v1(124.16,132.15) 124.16,131.51 124.23,131.44 U35.A58 ; U35.AK70 115.03,115.8 114.96,115.88 v1(114.86,115.88)
  BOTTOM w0.203: v1(119.18,131.65) 119.27,131.57 U35.A66 ; U35.BB66 119.21,108.58 119.21,108.3 117.84,106.93 117.18,106.93 v1(116.93,107.18) ; U35.A53 126.45,130.87 126.45,131.44 126.1,131.8 v1(126.1,132.13) ; v1(121.81,132.2) 121.75,132.17 U35.A62
  BOTTOM w0.254: v2(120.76,111.81) 120.76,111.81 121.14,111.43 U35.AU63 ; v1(122.77,158.36) 122.26,158.36 121.5,157.6 PC158.1 ; PR187.2 150.08,189.73 149.82,189.99 149.82,190.7 v1(149.95,190.83) ; v2(123.56,111.78) 123.91,111.43 U35.AU58 ; U35.J53 U35.J52 ; U35.Y62 121.53,120.68 ; U35.J48 U35.J46 U35.J45 U35.J43 ; U35.T62 121.53,122.51
  vias: v1(108.55,122.12) v1(108.93,124.2) v1(109.18,122.12) v1(109.56,124.2) v1(110.2,124.2) v1(110.32,122.12) v1(110.96,122.12) v1(111.21,124.2) v1(111.85,124.2) v1(111.85,122.12) v1(124.98,121.81) v1(124.96,121.15) v1(124.96,120.52) v1(125.44,116.61) v1(125.39,115.97) v1(125.62,121.79) v1(125.59,121.13) v1(125.59,120.49) v1(126.23,121.13) v1(126.23,120.47) v1(126.23,119.83) v1(126.25,121.79) v1(126.28,116.58) v1(126.28,115.95) v1(126.89,122.53) v1(126.89,121.81) v1(126.86,121.15) v1(126.89,120.49) v1(126.89,119.86) v1(127.19,116.58) v1(127.19,115.95) v1(128.1,115.95) v1(128.46,116.56) v1(128.99,115.92) v1(129.15,116.56) v1(129.91,116.56) v1(129.91,115.92) v1(131.43,116.56) v2(123.49,125.55) v2(123.63,123.26) v2(123.63,122.58) v2(123.63,121.84) v2(123.61,121.18) v2(124.32,121.15) v2(124.32,120.54) v2(124.41,125.55) v2(124.35,123.24) v2(124.35,122.5) v2(124.35,121.81) v2(124.98,123.24) v2(124.98,122.55) v2(125.32,125.55) v2(125.64,123.21) v2(125.64,122.53) v2(126.23,125.55) v2(126.25,123.24) v2(126.25,122.53) v2(126.89,123.24) v2(127.15,125.55) v3(110.81,123.14) v3(126.78,146.15) v3(129.73,152.9) v4(122.24,148.97) v4(122.24,148.2) v4(122.24,147.44) v4(122.24,145.16) v4(122.26,151.25) v4(122.26,150.49) v4(122.26,149.73) v4(122.26,146.68) v4(122.26,145.92) v4(123.02,147.32) v4(123.02,146.43) v4(123.05,148.92) v4(123.05,148.15) v4(123.05,145.13) v4(123.15,151.25) v4(123.15,150.49) v4(123.15,149.73) v4(123.41,145.79) v4(123.41,144.47) v4(123.84,148.69) v4(123.84,147.93) v4(123.79,147.19) v4(123.79,145.16) v4(123.89,146.4) v4(124.04,151.33) v4(124.04,150.52) v4(124.04,149.78) v4(124.22,144.47) v4(124.5,149.04) v4(124.5,148.28) v4(124.55,147.52) v4(124.55,146.76) v4(124.55,146) v4(124.57,145.18) v4(125.01,144.5) v4(125.13,148.66) v4(125.16,149.4) v4(125.21,147.85) v4(125.21,147.09) v4(125.21,146.33) v4(125.21,145.56) v4(125.84,148.36) v4(125.82,144.47) v4(125.87,149.12) v4(125.87,147.52) v4(125.87,146.76) v4(125.87,146) v4(125.9,145.23) v4(126.5,148.71) v4(126.48,147.98) v4(126.63,149.45) v4(127.24,148.71) v4(127.42,151.23) v4(127.42,150.36) v4(127.6,149.6) v4(128.16,151.23) v4(128.16,150.36)
+VCCHDA: length 30
  IN1 w0.508: 143.47,106.68 146.14,106.68 147.15,105.66 148.81,105.66 151.64,102.82 152.41,102.82 154.33,100.89 154.56,100.89 156.06,99.4 156.06,98.98 159.85,95.19 v1(164.1,95.19)
  BOTTOM w0.305: U35.AJ19 145.76,115.96 v2(145.76,115.87)
  BOTTOM w0.508: C748.2 162.57,97.13 R789.1 163.36,96.34 R683.1 163.97,95.25 v1(164.1,95.19)
+VCCIO: length 479.1
  TOP w0.508: v1(84.92,80.13) 84.92,79.06 83.75,77.89 56.95,77.89 55.96,78.87 PR138.1 ; v1(133.57,127.2) 134.61,127.2 134.97,127.56 R154.2 ; v4(103.21,121.15) 102.2,122.17 96.48,122.17 96.05,122.6 96.05,126.55 98.29,128.79 101.04,128.79 103.45,131.2 106.15,131.2 107.29,132.34 107.29,133.33 v1(108.01,134.06)
  TOP w1.016: 213.83,93.59 213.46,93.96 211.43,93.96 210.32,95.07 204.08,95.07 203.11,94.1 201.31,94.1 199.96,92.76 199.96,84.15 196.76,80.95 194.04,80.95 192.29,82.7 186.42,82.7 182.84,79.12 179.49,79.12 178.78,78.41 178.78,77.59
  IN1 w0.508: 137.53,126.41 134.35,126.41 v1(133.57,127.2) ; 212.71,191.38 212.71,194.66 211.16,196.21 v1(211.16,196.49)
  IN1 w1.016: 215.63,93.87 215.99,94.23 219.52,94.23 220.15,94.86 220.18,94.86 220.94,95.63 220.94,98.42 219.85,99.51 219.85,108.63 218.4,110.08 218.4,116.71 218.71,117.01 218.71,127.63 218.53,127.81 218.53,127.88 217.18,129.23 217.18,146.39 220.88,150.08 224.04,150.08 224.82,150.86 224.82,169.71 222.19,172.35 222.19,178.84 213.64,187.38 213.64,190.46 212.71,191.38 201.76,191.38 200.93,192.22 200.93,193.59 199.14,195.39 197.25,195.39 196.68,195.96 194.7,195.96 192.11,198.55 183.25,198.55 181.6,196.9 179.08,196.9 178.65,196.46 166.84,196.46 164.43,194.05 159.8,194.05 v1(158.38,192.63)
  IN1 w1.524: 147.13,133.73 147.1,133.75 143.52,133.75 140.25,130.48 140.25,128.44
  IN2 w0.508: v1(156.04,185.92) 157.25,187.13 157.25,191.5 v1(158.38,192.63)
  BOTTOM w0.305: U35.AM42 U35.AL42 133.58,115.81 v1(132.55,116.84)
  BOTTOM w0.508: PR200.1 R465.2 154.77,185.05 155.64,185.92 v1(156.04,185.92) ; PR174.2 210.93,195.96 211.16,196.19 v1(211.16,196.49) ; R544.1 110.14,131.93 v1(108.01,134.06)
  BOTTOM w1.016: 103.21,117.98 103.21,107.31 v3(95.11,99.21) 94.31,98.41 94.31,96.19 94,95.88 93.99,95.88 93.69,95.58 93.69,92.14 92.09,90.55 89.31,90.55 86.19,87.43 86.19,83.84 84.92,82.57 v1(84.92,80.13) 84.92,79.24 93.69,70.48 95.08,70.48 98.03,73.43 102.94,73.43 107.4,77.9 155.94,77.9 160.41,73.43 168.11,73.43 168.49,73.81 168.49,74.13 169.7,75.35 171.25,75.35 172.56,74.04 175.4,74.04 176.16,74.8 177.38,74.8 178.78,76.2 178.78,77.21
  vias: v1(139.98,115.88) v1(178.52,78.1) v1(179.16,78.1) v1(214.46,93.21) v1(215.1,93.21) v2(139.05,114.36) v2(139.98,114.36) v4(102.58,120.52) v4(102.58,119.63) v4(103.34,120.26) v4(103.87,121.92) v4(103.97,121.03) v4(149.59,133.9) v4(150.71,134.87)
+VCCOPC: length 31.2
  TOP w0.508: R172.2 v1(84.67,104.39)
  IN1 w3.048: 84.72,106.37 84.72,107.26 98.48,121.02 99.83,121.02 104.53,125.73 106.77,125.73
  vias: v1(107.18,128.14) v1(107.68,128.65) v1(122.52,122.58) v1(122.52,121.94) v1(122.54,121.31) v3(106.82,129.41) v4(67.32,96.64) v4(67.32,95.88) v4(67.96,97.02) v4(67.96,96.26) v4(67.96,95.5)
+VCCOPC_EN: length 4.3
  TOP w0.114: v1(57.9,85.46) 57.59,85.16 v3(57.21,85.16) 57.21,85.56 PR136.2 PR135.2
  BOTTOM w0.114: v1(57.9,85.46) 57.87,85.44 PU14.5
+VCCOPC_LP#: length 2.1
  BOTTOM w0.114: PR288.2 58.37,85.77 PU14.6
+VCCOPC_MODE: length 3.3
  BOTTOM w0.114: PR289.2 59.14,85.97 59.14,83.69 58.88,83.43 PU14.7
+VCCOPC_SRC: length 57.4
  IN1 w0.127: v1(63.21,78.74) 63.95,78.74 66.26,81.04 66.26,88.31 68.44,90.5 78.98,90.5 87.27,98.79 87.27,101.15 89.18,103.06 89.18,103.56 89.17,103.57 89.17,103.95 v1(88.73,104.39)
  IN2 w0.127: v1(57.26,80.66) 59.63,78.29 62.76,78.29 v1(63.21,78.74)
  BOTTOM w0.114: R634.1 v1(88.73,104.39) R633.1 ; v1(63.21,78.74) 64.38,77.57 v3(66.31,77.57) 66.81,78.08 PR344.2
  BOTTOM w0.203: v1(57.26,80.66) 57.37,80.76 PU14.12
+VCCOPC_SW:
  vias: v1(61.4,80.31)
+VCCOPC_VIN:
  vias: v3(53.66,79.19) v4(53.95,81.17) v4(54.98,81.17)
+VCCPDSW_3P3: length 23.9
  TOP w0.508: v2(147.06,118.38) 147.05,118.38 v1(147.05,117.57) v2(147.05,116.71) ; R210.1 171.67,110.66 171.62,110.61 R212.1 170.9,110.74 169.38,110.74 v1(168.74,110.1) 168.62,110.23 C314.1
  IN2 w0.508: 155.41,113.79 157.06,112.14 158.97,112.14 159.66,111.44 159.66,110.55 160.49,109.72 161.62,109.72 162.23,110.33 166.61,110.33 166.71,110.23 168.49,110.23 168.62,110.1 v1(168.74,110.1)
  BOTTOM w0.279: U35.AJ17 147.05,116.62 v2(147.05,116.71)
  BOTTOM w0.305: U35.AD18 146.73,118.71 v2(147.06,118.38) U35.AD17
+VCCPGPPA: length 24.4
  TOP w0.508: R198.1 169.46,114.4 168.74,115.12 C292.1 168.62,115.31 168.31,115.62 v1(168.31,116.02)
  IN1 w0.381: v2(149.24,116.04) 149.29,116.09 149.29,116.25 149.62,116.58 150.1,116.58 150.42,116.26 154.86,116.26 154.97,116.15 156.15,116.15 156.76,115.54 156.76,115.11 157.11,114.75 158.92,114.75 159.22,115.06 160.49,115.06 161.15,115.72 163.39,115.72 163.66,115.44 164.39,115.44 164.77,115.82 168.11,115.82 v1(168.31,116.02)
  BOTTOM w0.254: v2(149.24,116.04) 148.93,115.74 148.93,115.7 U35.AK15
+VCCPGPPB: length 25.9
  TOP w0.508: C268.1 170.18,117.73 v1(169.89,117.45) 169.71,117.62 R185.1
  IN1 w0.381: v2(148.36,116.71) 148.74,117.09 150.37,117.09 150.69,116.77 155.07,116.77 155.18,116.66 156.38,116.66 156.83,116.2 159.32,116.2 159.65,116.53 160.44,116.53 161.21,117.31 162.9,117.31 163.19,117.01 165.6,117.01 166.03,116.58 167.35,116.58 168.24,117.47 169.86,117.47 v1(169.89,117.45)
  BOTTOM w0.305: v2(148.36,116.71) U35.AG15
+VCCPGPPC: length 16
  TOP w0.381: v2(147.71,120.06) 147.71,120.18 v1(148.17,120.65) 150.05,120.65 150.89,119.81 154.6,119.81 155.03,119.38 155.74,119.38 156.76,120.4 159.1,120.4 159.42,120.72 R182.1 160.62,120.87 C230.1
  BOTTOM w0.305: U35.Y16 v2(147.71,120.06)
+VCCPGPPD: length 15.3
  TOP w0.381: R187.1 160.79,118.06 160.59,118.06 160.18,118.47 C265.1 159.64,118.47 158.61,117.45 158.05,117.45 156.83,118.66 150.91,118.66 v3(150.61,118.97) 150.61,119.35 149.9,120.06 v2(148.36,120.06)
  BOTTOM w0.305: v2(148.36,120.06) U35.Y15
+VCCPGPPE: length 23.8
  TOP w0.254: v1(165.82,120.44) 165.6,120.21 165.6,119.98 v1(165.82,119.76) 166.15,119.76 C256.1 166.86,120.47 167.08,120.47 167.64,121.03 R179.1
  IN1 w0.254: v1(165.82,120.44) 165.31,120.96 164.5,120.96 164.43,121.03 164.43,121.03 163.72,121.03 163,120.32 161.85,120.32 161.58,120.32 161.58,120.32 156.53,120.32 155.68,119.47 154.81,119.47 154.51,119.77 151.04,119.77 149.82,120.99 149.82,121.48 149.39,121.92 149.01,121.92 148.37,122.56 v2(148.37,122.58)
  BOTTOM w0.254: v2(148.37,122.58) 148.33,122.54 148.33,122.45 U35.T16
+VCCPGPPF: length 19.1
  TOP w0.381: v2(148.35,117.55) 154.6,117.55 v1(154.93,117.88) 155.77,117.88 157.34,116.3 158.66,116.3 159.42,115.54 159.42,115.54 159.75,115.21 160.26,115.21 160.97,115.92 161.57,115.92 161.83,116.18 163.16,116.18 164.16,117.18 R192.1
  BOTTOM w0.305: U35.AF16 148.35,117.65 v2(148.35,117.55)
+VCCPGPPG: length 19.6
  IN1 w0.381: 149.82,117.62 150.57,117.62 150.9,117.28 154.46,117.28 154.49,117.32 155.3,118.12 155.68,118.12 157.09,116.71 159.09,116.71 159.42,117.04 160.21,117.04 161,117.83 163.11,117.83 163.36,117.57 166.9,117.57 v1(167.21,117.66)
  BOTTOM w0.305: U35.AD15 v2(148.36,118.38)
+VCCPLL: length 11.6
  IN1 w0.762: v4(143.19,124.91) 143.19,125.12 142.88,125.43 142.88,127.04 142.89,127.05 ; v4(150.48,133.9) 150.48,133.14 149.97,132.63 149.12,132.63 147.44,130.96 146.29,130.96 145.71,130.37 144.03,130.37 143.32,129.66
+VCCPRIM_3P3: length 21.8
  TOP w0.508: v2(145.1,116.71) 145.1,117.53 144.49,118.14 144.49,118.64 145.12,119.27 v3(145.12,121.28) 145.58,121.73 v2(145.76,121.73) ; R186.1 178.04,119.2 176.53,119.2 C261.2 176.03,119.4 v1(175.11,119.4)
  IN1 w0.508: 156.74,119.81 155.88,118.94 154.85,118.94 154.65,118.74 ; v1(175.11,119.4) 172.2,119.4 171.95,119.66 170.75,119.66 169.99,118.89 166.71,118.89
  BOTTOM w0.254: U35.AJ21 145.1,116.6 v2(145.1,116.71)
  BOTTOM w0.305: U35.V19 v2(145.76,121.73)
+VCCPRTC: length 43.7
  TOP w0.508: C322.1 148.79,107.57 v1(148.81,107.57) v3(147.92,106.68) 147.92,98.6 152.31,94.2 157.28,94.2 157.32,94.24 158.6,94.24 158.8,94.44 161.04,94.44 161.51,93.98 R252.1 162.74,93.44 C352.2
  IN1 w0.457: v2(145.45,114.93) 145.23,114.93 144.56,114.26 144.3,114.26 143.85,113.81 143.85,113.15
  IN1 w0.508: v1(148.81,107.57) 148.17,106.93 146.9,106.93 145.25,108.58 144.36,108.58 143.34,109.6 143.34,110.74 143.85,111.25 143.85,113.15
  BOTTOM w0.178: v1(148.81,107.57) 148.81,107.7 148.83,107.71 U35.BB14
  BOTTOM w0.305: v2(145.45,114.93) 145.57,114.93 U35.AK19
+VCCPRTCPRIM_3P3: length 22.2
  TOP w0.508: C349.1 169.18,95.93 170.47,97.23 R240.1
  IN2 w0.508: v1(167.18,95.14) 166.08,96.24 161.61,96.24 158.53,99.32 158.53,102.55 158.67,102.69 158.67,105.06 157.06,106.68
  BOTTOM w0.114: U35.AK17 147.71,115.77 147.71,116.7 v2(147.71,116.71)
  vias: v3(168.64,93.98)
+VCCPSPI: length 20.8
  TOP w0.356: v2(148.39,115.86) 148.38,115.96 v1(149.2,116.78) 149.49,117.06 154.41,117.06 154.7,116.78 155.72,116.78 156.78,115.72 156.78,115.43 156.78,115.43 156.78,115.12 157.11,114.79 158.84,114.79 158.88,114.83 159.45,114.83 159.56,114.73 160.55,114.73 161.26,115.44 161.77,115.44 162.03,115.69 163.26,115.69 163.45,115.5 164.39,115.5 164.74,115.86 165.38,115.86 165.55,115.69 R193.1
  BOTTOM w0.305: U35.AJ16 148.39,115.93 v2(148.39,115.86)
+VCCSA: length 55.3
  TOP w0.114: R122.1 155.05,139.95 v1(155.11,139.89)
  TOP w0.254: PR51.2 153.63,170.95 153.63,171.32 154.65,172.33 v1(154.65,173.1)
  TOP w0.508: v1(154.52,155.56) C114.1
  IN2 w0.254: v4(153.1,148.26) 152.36,148.99 152.36,152.01 154,153.65 160.38,153.65 161.76,155.03 161.76,159.98 162.75,160.98 162.75,165.63 161.89,166.49 161.89,167.67 159.26,170.29 157.15,170.29 154.65,172.79 v1(154.65,173.1)
  BOTTOM w0.127: 141.35,127.24 U35.G27 ; U35.G27 141.66,126.92 ; U35.G27 141.03,126.92 ; U35.G27 141.35,126.6 ; 141.35,126.31 U35.K27 ; U35.K27 141.03,125.99 ; U35.K27 141.35,125.67 ; 140.43,126.6 U35.G28 140.75,126.92 ; U35.K25 142.26,125.67 ; U35.K25 142.26,126.31 ; U35.K25 142.58,125.99 ; 142.58,126.92 U35.G25 ; U35.G25 142.26,126.6 ; U35.G25 142.26,127.24 ; U35.G25 141.94,126.92 ; U35.J23 142.72,126.77 ; U35.J23 142.72,126.14 ; U35.J23 143.04,126.46 ; U35.J23 142.4,126.46 ; 143.18,126.31 U35.K23 ; U35.K23 143.18,125.67 ; U35.K23 142.86,125.99 ; 143.18,115.94 U35.AK23 142.86,115.62 ; U35.AK25 142.26,115.3 ; U35.AK25 142.26,115.94 ; U35.AK25 142.58,115.62 ; U35.K28 140.43,126.31 ; U35.K28 140.75,125.99 ; U35.K28 140.12,125.99 ; U35.K30 139.84,125.99 ; 143.32,126.46 U35.J22 143.63,126.77 ; 141.21,126.46 U35.J27 ; U35.J27 140.89,126.14 ; U35.J27 140.57,126.46 ; U35.J27 140.89,126.77 ; U35.G23 142.86,126.92 ; U35.G23 143.18,126.6 ; U35.G23 143.18,127.24
  vias: v1(142.33,119.76) v1(142.33,119.12) v1(142.33,118.49) v1(142.33,116.86) v1(142.33,116.2) v2(140.88,127.25) v2(141.06,125.47) v2(141.57,125.09) v2(141.81,115.85) v2(142.18,125.09) v3(144.92,134.9) v4(153.1,151.71) v4(153.1,150.95) v4(153.1,150.19) v4(153.12,149.35) v4(154.11,151.71) v4(154.11,150.95) v4(154.11,150.19) v4(154.9,151)
+VCCSTG: length 1.9
  BOTTOM w0.203: v1(143.76,131.85) 144.05,131.57 U35.A22
  BOTTOM w0.305: U35.G20 145.63,126.64 v2(145.46,126.64)
  vias: v3(145.58,130.4)
+VDDQ:
  vias: v3(181.72,69.34)
+VDDQ_VTT: length 11.2
  TOP w1.27: 174.08,71.24 169.38,66.54 167.98,66.54
  IN2 w0.203: v1(178.54,71.74) 178.02,71.22 v1(178.02,69.69)
  BOTTOM w0.203: PU15.1 178.54,69.43 178.27,69.69 v1(178.02,69.69)
  vias: v1(163.64,62.61) v1(164.99,48.42) v1(165.62,48.42) v1(166.08,57.4) v1(166.08,56.76) v1(166.2,66.8) v1(166.2,66.16) v1(166.84,66.29) v1(178.55,72.39) v3(168.03,63.57)
+VDDQC: length 11.8
  IN2 w0.381: v2(143.62,114.45) 143.5,114.45 142.89,115.06 142.58,115.06 142.46,114.94 134.08,114.94 133.6,114.46 v2(133.6,114.4)
  BOTTOM w0.254: v2(133.6,114.4) 133.89,114.68 U35.AM40 ; v2(143.62,114.45) 143.63,114.46 U35.AL23
AGND_DDR: length 13.8
  TOP w0.508: 182.84,68.32 182.84,66.98 182.44,66.57 v1(182.44,65.78)
  BOTTOM w0.203: v1(181.79,68.12) 181.71,68.04 PU15.7
  BOTTOM w0.508: v1(182.44,65.78) 182.44,66.08 182.77,66.41 PC239.2 PR300.2 184.1,66.41 184.54,66.85 184.54,69.16 184.19,69.52 PC238.2 PC237.2 ; v1(176.36,67.05) 175.22,67.05 174.91,67.37 PR299.1 PR296.1
  vias: v3(177.56,67.69)
DVDD_IO: length 10.3
  TOP w0.203: U23.9 31.6,38.13 31.09,38.65 C492.1
  TOP w0.508: v1(31.08,39.49) 31.09,39.48 C492.1 ; R366.1 R365.1 C489.1 26.39,40.13 v1(27.11,40.13) v1(27.77,40.13)
  IN1 w0.508: v1(27.77,40.13) 27.9,40.25 30.44,40.25 31.08,39.62 v1(31.08,39.49)
GND: length 2066.3
  TOP w0.114: R41.1 201.59,182.67 v1(202.02,182.24)
  TOP w0.178: U18.35 23.89,64.84 v1(23.96,64.77) ; U18.15 v1(24.29,71.77)
  TOP w0.203: v1(135.41,115.9) 135.73,115.58 C246.1 ; C269.1 137.02,115.67 v1(137.23,115.88) ; C299.1 133.87,114.96 134.06,114.77 134.06,114 133.81,113.75 v2(133.6,113.75) ; v2(141.48,110.01) 141.85,110.01 142.48,110.64 C308.1 ; 16.16,31.58 U24.9 ; C312.1 134.71,110.95 v2(134.53,111.12) ; U13.15 21.73,105.28 21.83,105.18 21.83,104.42 v1(21.81,104.39) ; U21.9 v1(19.36,48.09) ; C313.1 135.85,110.01 v2(136.5,110.01) ; C311.1 138.14,110.99 138.11,111.02 v2(138.11,111.09)
  TOP w0.254: v1(171.11,176.73) 171.54,176.3 U2.B9 ; U5.B3 217.14,161.43 v1(217.54,161.83) ; v1(202.65,61.72) 203.06,61.31 U19.15 ; v1(207.58,56.8) U19.10 ; C808.1 194.16,90.21 194.39,90.43 194.82,90.43 195.38,91 C164.1 v1(194.42,91.54) ; v1(148.55,172.84) 148.42,172.72 PR49.2 ; U4.G1 206.87,165.4 v1(206.5,165.03) ; C297.1 140.73,115.69 140.89,115.85 v1(140.89,115.88) ; Q3.4 111.58,175.42 111.13,175.87 v1(111.11,175.87) ; U8.3 161.01,135.01 161.32,135.31 161.57,135.31 162.01,135.75 R130.1 ; U48.3 222.17,23.38 222.09,23.46 222.09,23.82 222.26,24 v1(222.6,24) ; U14.3 171.73,106.07 171.96,106.29 v1(172.3,106.29) ; v1(112.56,178) 112.88,177.68 Q3.1 ; U19.13 207.44,58.3 v1(207.58,58.44) ; v1(202.02,61.72) 202.02,61.59 202.56,61.05 U19.16 ; U19.5 198.94,56.3 v1(198.65,56.59) ; v1(207.58,57.8) U19.12 ; v1(140.42,180.08) PR39.2 ; v2(141.83,114.38) 142.05,114.59 C298.1
  TOP w0.279: U6.3 197.45,87.45 197.62,87.27 v1(198.01,87.27) ; v1(175.6,135.33) 175.2,134.92 U9.3
  TOP w0.305: v1(193.99,84.37) 193.99,84.88 194.51,85.39 194.71,85.39 194.87,85.55 U47.3 ; U3.D8 184.21,177.94 v1(184.6,178.32) ; v1(205.66,167.45) 206.07,167.04 U4.J2 ; U7.3 193.37,139.15 193.37,139.15 193.37,139.91 v1(193.77,140.3) ; U3.G9 183.36,180.3 v1(182.93,179.87) ; v1(174.71,107.82) 174.27,107.82 R214.2 ; CN2.14 178.61,85.71 v1(179.03,85.29) ; v1(159.35,122.25) 159.14,122.04 R174.1 R178.2 ; U49.3 v1(49.81,8.74) ; U22.14 20.41,40.53 v1(20.1,40.84) ; v1(178.78,82.67) 178.74,82.71 CN2.8 ; v1(173.95,130.22) 173.61,130.56 U10.3 ; U50.3 v1(49.71,12.6) ; CN2.10 178.76,83.71 v1(178.78,83.69) 178.78,84.32 178.39,84.71 CN2.12
  TOP w0.33: v1(182.79,187.02) 182.79,187.02 183.27,187.5 U3.T9 ; U3.E2 v1(189.41,178.3) U3.D1 ; v1(190.26,188.9) 190.26,187.95 U3.T1 ; v1(183.02,175.87) 183,175.88 183,175.89 U3.B9 ; v1(176.7,175.9) 176.71,175.9 176.72,175.9 176.73,175.91 176.34,176.3 U2.B3 ; v1(188.58,175.91) 188.21,176.28 U3.B3 ; v1(172.73,181.48) 172.73,181.5 U2.J8 ; U3.M1 v1(190.21,184.7) ; v1(176.75,181.48) 176.77,181.5 176.77,181.53 U2.J2 ; U2.D8 v1(171.94,178.3) U2.E8 ; U2.T9 v1(171.14,187.9) ; U2.B1 v1(178.34,175.9) ; v1(177.51,186.3) 177.53,186.3 U2.P1 ; U3.G1 189.81,180.3 v1(190.21,179.9) ; v1(183.8,186.29) U3.P9 ; U2.M1 177.96,184.32 v1(178.55,184.32) ; U2.F9 171.51,179.5 171.08,179.92 v1(171.03,179.92) 171.21,180.1 171.34,180.1 U2.G9 ; U2.E2 v1(177.54,179.1) U2.E1 ; v1(184.59,182.31) 184.59,182.29 184.21,181.9 U3.J8 ; v1(178.33,187.1) U2.T1 ; U3.F9 183.41,179.52 183.78,179.89 v1(183.79,179.89) 184.2,180.3 U3.G8 ; U2.P9 v1(171.14,186.3) ; v1(177.54,177.5) 177.94,177.9 U2.D1 ; U2.A9 171.5,175.5 171.1,175.9 v1(171.08,175.9) ; U3.P1 v1(190.21,186.3) ; v1(171.96,179.88) 171.96,179.92 U2.G8 ; v1(182.87,184.86) 183.41,184.31 U3.M9 ; v1(189.42,179.12) 189.42,179.11 189.81,178.72 U3.E1 ; v1(184.6,178.32) 184.22,178.7 U3.E8 ; U2.G1 v1(177.53,179.88) ; U3.A9 v1(183.01,175.1) ; U3.B1 v1(190.21,176.7)
  TOP w0.356: U5.P1 218.74,171.02 v1(219.14,171.42) ; v1(219.34,172.92) 219.04,172.92 U5.T1 ; U5.E8 213.16,163.82 v1(213.56,163.42) 213.16,163.02 U5.D8 ; U4.E8 201.32,163.82 201.45,163.68 201.45,163.64 201.67,163.42 ; v1(211.89,165.03) 211.95,165.03 U5.G9 ; R30.1 195.29,185.16 v1(194.78,185.67) 195.41,186.3 R27.1 ; v1(211.64,172.83) 211.85,172.62 212.34,172.62 U5.T9 ; R54.1 192.62,179.07 v1(192.37,179.32) ; U4.E1 206.87,163.79 v1(206.5,163.42) ; v1(211.65,170.13) 211.9,169.87 211.9,169.64 212.12,169.42 U5.M9 ; v1(200.85,160.15) 200.85,160.24 U4.A9 ; v1(200.87,166.58) 200.87,166.58 200.88,166.57 200.89,166.57 200.89,166.57 201.13,166.82 201.13,166.88 U4.J8 ; v1(201.68,163.42) 201.67,163.42 ; 201.67,163.42 U4.D8 ; v1(206.5,163.42) 206.87,163.05 U4.D1 ; v1(206.5,163.42) 206.1,163.82 U4.E2 ; v1(200.04,164.25) 200.42,164.62 U4.F9 ; U5.D1 v1(218.34,162.62) ; U5.B9 212.34,161.42 211.94,161.02 ; U5.B1 218.79,161.42 v1(219.19,161.02) ; U5.G8 v1(212.74,165.82) ; U4.P9 200.39,170.94 v1(199.26,170.94) ; R64.1 195.66,175.65 v1(195.03,176.27) 195.54,176.78 R62.1 ; v1(204.02,160.91) 204.76,160.91 U4.B3 ; U5.P9 211.61,171.02 211.57,171.06 v1(211.51,171.06) ; U4.G9 200.5,165.42 v1(200.87,165.06) 201.23,165.42 U4.G8 ; v1(188.61,181.5) U3.J2 ; U5.M1 218.74,169.42 v1(219.14,169.82) ; v1(170.95,184.73) 170.95,184.64 171.3,184.3 U2.M9 ; v1(200.07,161.82) 200.47,161.42 U4.B9 ; U5.J2 217.94,167.02 v1(218.34,166.62) ; U4.B1 v1(207.27,161.02) ; 211.94,161.02 212.34,160.62 U5.A9 ; 211.94,161.02 v1(211.89,161.02) ; U4.T9 199.93,172.62 v1(199.62,172.31) ; v1(211.89,164.22) 211.94,164.22 212.34,164.62 U5.F9 ; U5.G1 v1(218.34,165.02) ; R21.1 195.16,187.83 v1(194.65,188.34) 195.29,188.97 R18.1 ; U5.E2 217.96,163.82 v1(218.35,164.21) U5.E1 ; v1(208.14,172.56) 208.14,172.67 207.7,173.1 207.3,173.1 206.87,172.68 U4.T1 ; R47.2 194.25,181.38 v1(194.78,180.84) 195.41,180.22 R49.1 ; U5.J8 v1(212.74,166.62) ; v1(199.07,169.14) 199.12,169.19 199.34,169.19 199.5,169.03 200.08,169.03 U4.M9 ; U4.P1 207.47,171.02 208.19,170.3 v1(208.19,169.88) 208.19,169.77 207.73,169.31 206.98,169.31 206.87,169.42 U4.M1
  TOP w0.381: v1(111.24,49.22) 111.21,49.24 110.9,49.24 109.93,48.27 C465.1 ; C192.1 154.13,129.15 v2(153.58,128.59) 153.12,129.05 R145.1 ; v1(154.65,141.09) 155.28,141.09 155.79,141.6 C165.2 ; C173.1 C179.1 157,129.63 v1(157.37,129.99) ; R114.1 191.94,139.11 v1(192.04,139.21) ; C320.1 R213.2 16.95,109.56 17.39,109.11 v1(17.39,108.96) ; R22.1 201.39,187.44 201.76,187.07 v1(202.02,187.07) 201.51,186.56 R24.1 ; R121.1 177.36,137.56 177.25,137.67 v1(177.25,138.02) ; v1(162.62,135.17) 162.29,135.5 R130.1 ; R196.2 162.8,114.91 163.03,115.14 v1(163.03,115.15) ; C161.2 127.35,141.55 R768.2 ; C415.1 110.23,61.46 111.26,62.5 v1(111.45,62.5) ; v1(126.02,44.83) C471.1 ; v1(162.65,116.73) 161.46,116.73 R764.1 ; R782.2 196.35,49.87 v1(195.94,50.29) ; v1(168.62,107.49) 168.62,107.46 168.23,107.07 C332.1 ; R219.2 C334.1 15.28,106.73 14.87,106.32 v1(14.87,106.12) ; v1(127.09,58.8) 127.09,59.13 126.48,59.74 C418.1 ; R778.2 163.59,112.34 v1(163.08,111.83) ; C432.1 138.34,58.44 138.77,58.87 C419.1 ; C139.2 166.21,149.36 v1(166.64,149.78) 166.66,149.81 167.22,149.81 C134.2 ; v1(178.19,130.42) 178.02,130.42 177.77,130.67 C180.1 ; v1(118.14,131.63) 117.82,131.31 C186.2 ; R88.1 161.84,147.82 v1(162.78,147.82) 162.83,147.82 163.17,147.48 C147.2 ; R222.2 16.29,104.34 v1(15.86,103.91) 15.28,104.49 C337.1 ; C288.2 143.85,115.1 143.92,115.03 v2(144.46,115.03) ; C276.1 130.58,114.36 v2(129.92,114.36) ; v2(157.29,117.42) 157.9,116.81 159.03,116.81 C265.2 ; v1(177.76,50.06) 177.76,47.14 177.36,46.73 176.39,46.73 175.6,45.94 PQ6059.1 ; C250.2 158.64,119.7 158.64,118.31 158.43,118.11 v1(158.43,118.08) ; v1(163.03,114.07) 163.13,114.17 163.43,114.17 R199.1 ; C402.1 140.04,69.8 140.04,70.38 140.78,71.12 v1(140.8,71.12)
  TOP w0.406: C403.2 127.7,71.27 126.83,72.13 125.56,72.13 v1(125.22,71.79) ; C217.1 161.36,124.8 v1(161.81,125.24)
  TOP w0.457: C59.2 196.04,169.83 C60.1 196.04,168.72 v1(195.77,168.45) ; R59.2 R60.1 201.77,177.8 v1(202.27,178.3) 202.65,177.92 C44.1 ; R364.2 24,42.02 23.61,42.41 v1(23.41,42.41) ; C49.2 194.18,172.58 C51.2 193.13,171.95 v1(193,171.83) ; C31.1 166.56,188.03 v1(166.51,187.98) ; v1(44.16,88.01) 44.42,88.27 C370.2 ; R44.2 168.34,181.6 168.86,181.6 v1(168.87,181.61) ; R43.1 194.68,182.52 v1(194.91,182.75) 195.04,182.61 R40.1 ; v1(192.8,167.71) 192.11,168.4 C62.1 C61.1 ; v1(34.51,91.41) 34.37,91.55 C358.2 ; v1(22.85,48.94) 22.16,48.94 21.7,49.4 C460.2 ; v1(168.87,184.65) 168.86,184.66 R34.1 C37.1 ; C94.2 195.57,157.85 196.2,157.22 v1(196.2,156.94) ; v1(199.07,169.14) 198.86,168.93 198.11,168.93 197.07,167.9 R70.2 ; v1(197.65,163.95) 197.07,164.54 C70.1 ; v1(17.11,36.83) 17.29,36.64 C496.1 ; R45.1 201.39,181.61 v1(202.02,182.24) ; R261.2 v1(42.2,87.24) ; v1(182.61,170.81) 182.84,171.04 R69.2 C57.1 C58.1 ; C505.2 17.55,35.61 v1(18.55,35.61) ; v1(174.63,173.24) 174.77,173.09 C53.2 ; v1(36,29.74) 35.53,29.27 C530.1 ; R31.1 201.39,185.15 v1(202.02,184.53) 201.51,184.02 R35.1 ; v1(182.4,167.89) 182.52,167.77 C68.2 ; v1(19.27,35.99) 19.27,36.26 C497.1 ; C81.1 195.3,160.84 195.67,160.47 v1(195.67,160.27) ; R354.1 36.92,45.72 37.35,45.28 v1(37.35,44.98) ; R55.1 201.51,179.07 v1(202.02,179.57) 201.39,180.2 R50.1 ; v1(190.21,166.76) 189.55,166.76 C67.2 C66.1 ; v1(199.62,172.31) 199.57,172.36 C50.2
  TOP w0.508: 202.53,114.86 v4(202.53,114.93) 202.53,115.06 201.88,115.7 PC66.2 ; C433.2 113.7,57.53 v1(112.98,57.53) ; C441.2 104.9,59.35 v1(105.48,58.76) ; C350.1 29.68,93.98 v1(29.68,95.25) ; PR158.2 v1(80.71,8.52) ; v1(196.05,97.28) 195.9,97.13 PQ2.1 ; v1(35.9,25.52) C543.2 ; R389.2 208.47,30.38 209.13,31.03 v1(209.13,31.29) ; v1(202.4,76.27) 202.4,75.57 PC101.1 ; C268.2 169.95,116.12 v1(169.58,116.12) 169.58,115.38 C292.2 ; CN3.6 155.7,77.38 154.57,78.51 v1(154.57,80.16) ; PQ10.1 52.92,70.1 v1(52.67,69.85) ; C390.2 162.35,71.74 v1(162.06,71.45) ; C806.2 167.35,96.46 v1(167.35,96.97) ; v1(167.36,141.6) 166.48,140.73 R105.1 ; R398.2 61.29,28.45 v1(61.43,28.32) ; v1(208.62,127.66) v3(210.07,127.66) 210.55,128.14 Q19.1 210.96,129.56 C187.1 ; 115.33,180.87 115.56,181.1 C41.2 ; 115.33,180.87 114.99,180.87 C801.2 ; 115.33,180.87 v1(115.33,180.84) ; PQ40.1 200.75,143.96 v1(201.13,144.34) ; C481.2 36.92,41.65 v1(37.3,42.03) ; R126.1 172.74,137.09 172.17,136.52 v1(172.17,136.27) ; PQ3.1 45.3,74.16 v1(45.17,74.04) ; C815.1 153.62,190.12 v1(153.5,190.24) ; C551.2 68.28,15.16 v1(68.75,15.62) ; v1(175.26,155.16) 175.53,155.16 175.86,154.83 C121.2 175.86,154.69 C119.2 ; v1(134.22,61.95) 133.64,61.37 C420.1 ; v1(167.6,135.28) 167.62,135.3 167.62,136.26 R127.1 ; v1(153.89,156.97) C114.2 ; v1(211.2,193.16) 210.79,193.16 210.54,193.42 PR13.1 ; PC22.2 154.65,187.71 154.65,188.28 v1(154.52,188.41) ; C364.1 28.66,90.68 v1(28.66,90.67) ; v1(166.46,71.62) 166.1,71.98 C388.2 ; v1(136.2,48.59) 136.28,48.5 C470.1 ; C410.2 28.04,64 27.67,64.36 v1(27.67,65.05) ; v1(226.9,52.18) C453.2 ; C28.2 166.46,189.51 v1(166.43,189.53) ; C399.2 131.53,67.59 v1(132.28,66.84) ; PR147.2 56.5,71.93 56.6,71.83 PQ11.1 56.6,70.63 56.22,70.25 55.59,70.25 v1(55.18,69.85) ; v1(10.88,104.77) 10.94,104.71 C336.1 ; C493.1 v1(33.12,39.48) ; C394.1 167.65,70.43 v1(167.22,70.86) ; C525.2 49.75,30.54 48.98,29.76 48.98,28.34 47.46,26.82 v3(46.91,26.82) 46.39,26.82 v1(45.71,26.13) ; Y1.2 37.18,93.07 C359.2 37.18,91.7 v1(36.79,91.31) ; R71.1 193.14,165.14 v1(193.44,164.84) 193.52,164.76 R73.1 ; v1(46.85,90.22) 46.71,90.07 C368.1 ; C426.2 v1(169.89,59.33) ; C527.2 36.95,29.21 v1(36.41,29.21) ; v1(161.38,53.08) 161.63,53.08 162.01,53.46 R332.2 ; PC8.2 158.58,195.07 v1(158.71,194.94) ; PC23.2 144.1,184.26 v1(143.6,183.76) 144.1,183.27 PC24.1 ; R369.2 40.86,39.39 41.21,39.75 41.21,40.15 41.49,40.43 41.49,41.5 v1(41.49,41.5) ; v1(121.04,133.5) 120.61,133.07 C178.1 ; C416.2 136.23,61.74 v1(136.17,61.81) ; v1(79.22,78.98) D4.2 C378.2 ; PC15.2 151.47,189.91 v1(151.9,190.34) ; PU4.4 68.54,70.15 68.77,69.92 v1(69.05,69.92) ; v1(43.14,26.28) 43.14,26.03 42.76,25.65 C541.1 ; C401.1 125.82,69.97 126.2,70.35 126.2,71.07 125.49,71.79 v1(125.22,71.79) ; v1(140.03,62.32) 141.22,62.32 141.69,61.84 C423.2 ; C809.2 v1(226.53,27.3) ; v1(197.57,69.59) 196.74,69.59 196.41,69.92 PQ7.1 ; v1(134.69,67.02) 134.71,67.03 C404.1 ; v1(139.95,48.49) 139.84,48.37 C472.1 ; v1(201,92.2) 201,92.4 201.54,92.93 C353.2 ; PR145.2 v1(68.34,73.78) ; v1(15.33,27.69) 15.07,27.44 R399.2 ; v1(63.21,109.22) 63.31,109.11 C723.1 ; C162.2 164.69,143.13 Q8.1 165.19,143.63 165.19,144.45 v1(164.96,144.67) ; v1(141.32,178.3) PC33.2 ; C492.2 30.31,39.37 v1(30.19,39.49) ; v1(41.96,37.22) C501.2 C500.2 ; v1(150.25,141.12) 150.25,140.56 150.61,140.2 R109.2 ; C261.1 176.58,118.25 176.8,118.46 v1(177.14,118.46) ; R323.2 162.63,60.46 161.87,61.23 v1(161.87,61.68) ; C437.2 226.02,56.92 225.79,57.15 v1(224.88,57.15) C436.2 ; C322.2 147.17,109.48 v2(146.66,109.98) ; v1(44.08,33.4) v3(44.82,34.13) C515.1 ; v1(168.74,48.31) 168.95,48.51 168.95,49.04 C463.1 ; C443.2 101.46,59.66 v1(102.36,58.76) ; C376.2 89.5,84.83 v1(89.88,85.21) ; v1(115.4,182.95) 115.02,183.33 R38.1 ; C86.1 v1(183.86,160.8) ; C52.2 192.47,171.83 v1(193,171.83) ; C475.1 27.28,45.72 v1(27.85,45.72) ; v1(153.2,70.68) 153.45,70.68 154.01,71.24 154.01,72.26 153.38,72.89 v3(153.38,73.25) CN3.8 ; v1(41.24,91.31) 42,90.55 C366.2 ; v1(137.25,58.03) 137.48,57.81 C432.1 ; C540.2 54.18,26.02 v1(53.94,25.78) ; Q7.1 167.09,145.87 v1(166.84,146.12) ; PC25.1 139.02,182.12 v1(139.41,181.73) 139.02,181.34 PC29.1 ; R256.2 164.8,90.03 v1(164.58,89.81) ; v1(226.4,108.72) C330.2 ; C383.2 14.05,75.1 13.22,75.1 v1(13.02,75.31) ; C351.1 157.88,93.6 v1(157.37,93.09) ; C502.1 16.48,36.18 16.6,36.06 v1(16.98,36.06) ; v1(154.14,173.99) PC43.2 ; v1(48.98,76.32) 49.11,76.2 PQ4.1 ; 82,11.55 v1(82,12.98) ; PQ5.1 52.92,75.48 v1(51.96,76.45) ; C537.2 41.74,26.92 v1(42.38,26.28) ; CN3.7 151.39,84.53 v1(150.96,84.96) ; R156.1 115.1,130.29 v1(115.47,130.66) ; v1(136.16,66.67) 136.23,66.74 C400.2 ; PC21.1 153.5,187.61 v1(153.97,188.08) ; C430.1 126.05,57.96 125.39,58.62 v1(125.13,58.62) ; v1(40.12,89.91) 39.97,89.76 C367.1 ; v1(159.35,150.24) 159.35,149.74 C136.1 ; v1(205.56,83.45) U17.3 ; v1(42.56,34.16) 40.93,34.16 40.54,33.77 C510.2 C509.2 ; v1(148.55,175.26) PC37.1 ; v1(160.77,131.64) 160.39,131.64 159.87,131.13 C182.1 ; v1(131.08,195.4) 130.9,195.58 C7.2 ; PC102.1 v1(75.96,73.78) ; C494.2 v1(39.59,37.2) ; C333.1 11.52,106.68 v1(11.06,106.22) ; v1(17.23,102.76) 17.44,102.97 C342.2 ; v1(16.6,27.55) 16.59,27.55 R400.2 ; v4(79.18,123.29) 80.45,122.02 PC62.2 ; v1(142.99,40.38) 142.99,40.92 142.86,41.04 C479.1 ; C482.2 208.88,41.78 v1(209.13,41.52) ; PC32.2 155.67,179.19 v1(156.3,179.19) ; v1(62.54,10.28) C556.2 ; v1(43.9,26.41) 43.9,26.67 43.53,27.04 C538.2 ; PD2.2 v1(160.36,200.02) ; PQ6.1 199.38,70.71 v1(200.49,69.59) ; v1(137.36,53.69) 136.71,54.34 C447.2 ; v1(29.17,89.3) 29.58,89.71 C365.1 ; v1(73.37,10.77) 74.16,10.77 74.38,10.99 PQ17.1 ; R393.2 22.06,29.93 v1(22.06,29.97) ; v1(14.44,48.51) 14.96,48.51 C462.1 ; PC9.2 160.62,194.95 v1(160.63,194.94) ; v1(205.19,78.35) R287.2 ; v2(121.8,110.06) 122,109.86 C316.2 ; C546.2 63.54,17.01 63.49,17.06 v1(63.49,17.52) ; C454.2 202.39,51.3 203.17,51.3 R337.1 204.27,51.68 v1(204.28,51.68) ; v1(204.19,92.06) C356.2 ; C384.2 v1(20.79,74.93) ; PR157.2 v1(82.13,16.79) ; C32.2 v1(165.62,186.3) ; PC109.1 v1(81.85,8.52) ; C469.1 27.75,47.11 v1(27.8,47.16) ; U12.6 45.81,110.23 45.05,110.99 v1(45.05,111.5) ; v1(13.35,21.74) 13.43,21.65 D21.2 ; C355.2 32.35,93.26 32.68,93.59 v1(32.68,93.7) ; v1(136.36,44.73) 136.35,44.72 R357.1 ; C177.1 170.39,133.23 v1(170.52,133.09) ; v1(55.08,9.27) 55.07,9.26 C812.1 ; PR150.2 v1(56.1,66.04) ; v1(162.56,130.52) 162.56,129.92 162.91,129.56 C191.1 ; v1(62.9,5.53) MR1.3 ; C225.1 161.25,122.54 161.06,122.74 C230.2 160.26,122.74 159.98,122.46 v1(159.98,122.25) ; PQ14.1 v1(77.81,63.32) ; PU4.5 v1(68.54,67.33) ; v1(157.37,91.05) 157.5,91.05 157.76,90.79 C362.1 ; v1(159.37,183.99) 158.93,183.99 PC6228.2 ; v1(223.74,57.15) C435.2 ; v1(169,179.45) 168.46,179.45 C42.1 ; C270.2 165.98,118.33 165.98,118.85 v1(165.93,118.9) 165.94,118.92 166.03,118.92 166.6,119.49 C256.2 ; CN4.13 20.24,21.9 20.24,20.36 v1(20.66,19.93) ; v1(212.05,86.71) 212.03,86.74 C374.2 ; C325.2 126.73,108.93 v2(126.73,110.06) ; v1(196.1,133.73) 196.05,133.73 196.02,133.69 C175.1 ; C327.2 142.08,108.33 v1(142.71,107.71) ; C802.2 227.29,105.53 226.66,106.17 v1(226.66,106.68) ; R350.1 31.58,46.49 v1(31.58,46.48) ; C531.2 56.88,27.77 C539.1 57.23,26.83 v1(57.09,26.69) ; v1(61.04,6.97) D27.2 D26.2 ; C477.2 37.04,43.8 v1(37.25,44.01) ; v1(169.89,57.05) 168.98,57.05 C434.2 ; R296.2 v1(23.84,75.05) ; v1(165.7,46.1) 165.47,46.33 165.47,46.83 ; v1(62.55,26.06) 62.15,25.66 C544.1 ; C363.1 40.74,90.46 v1(41.24,89.96) ; PC96.2 201.82,98.2 v1(201.92,98.29) PC92.1 ; C489.2 v1(25.62,39.48) ; R161.2 108.92,129.7 v1(108.95,129.67) ; v1(147.54,175.26) PC36.2 ; PU4.6 v1(69.81,67.33) ; R142.1 193.29,133.69 v1(193,133.98) ; D5.2 C379.2 v1(83.65,78.98) ; PR342.1 PC7.1 209.38,196.97 209.13,197.23 209.13,197.48 v1(209,197.61) ; v1(209.18,39.32) 208.75,39.75 C490.1 ; v1(47.97,89.53) 47.96,89.52 C369.1 ; PC95.2 v1(194.3,96.8) ; C317.2 124.42,109.99 124.42,111.09 v2(124.43,111.1) ; R331.1 v1(95.34,56.94) ; C319.1 12.11,109.56 v1(12.15,109.6) ; C680.2 156.1,134.23 v1(156.45,134.59) ; v1(25.62,61.21) 25.74,61.34 C413.2 ; PC93.1 v1(203.03,98.29) ; PC41.2 149.07,173.6 148.42,173.6 v1(148.17,173.86) ; v1(34.76,25.52) 35.31,26.07 R401.1 ; v1(144.06,40.38) C480.2 ; C323.2 144.11,109.86 v2(143.96,110.01) ; C282.1 133.11,126.73 v2(132.66,127.17) ; v1(205.68,39.32) 205.75,39.32 206.09,38.98 C491.2 ; C455.1 169.3,53.34 169.37,53.34 169.96,53.93 v1(169.96,53.97) ; PR140.2 198.23,76.04 v1(198.97,75.31) ; C382.2 v1(85.31,76.45) ; v1(54.32,29.46) 54.47,29.46 55.08,28.85 C533.1 R396.2 ; C309.1 v1(28.31,110.61) ; v1(169.89,55.16) 169.89,55.14 C449.1 ; C176.1 153,132.58 153.3,132.28 v1(153.3,131.56) 152.64,131.56 C174.1 ; C414.1 v1(169.91,61.92) ; v1(135.57,53.74) 134.97,54.34 C446.2 ; C371.2 v1(89.88,86.86) ; C466.2 138.72,48.42 v1(138.76,48.46) ; v1(170.65,144.65) 169.53,143.53 Q12.1 ; PR69.2 220.26,117.93 220.26,117.32 v1(220.74,116.84) ; PD1.2 v1(158.2,199.89) ; C548.2 65.8,15.08 v3(65.8,14.21) 65.8,13.56 v1(65.75,13.51) ; R206.1 16.51,111.76 v1(16.14,111.4) ; v1(23.2,30.09) 23.18,30.07 R394.2 ; v1(78.37,87.07) U16.3 U16.2 ; v1(66.13,10.41) D23.1 ; C171.1 119.93,136.42 v1(119.85,136.34) ; v1(21.04,33.4) 21.04,33.28 C517.1 ; C385.2 v1(26.89,74.93) ; C425.1 209.77,57.02 210.15,56.64 v1(210.68,56.64) ; R463.2 196.63,35.82 197.22,35.82 197.23,35.84 v1(198.01,35.84) ; C166.2 207.29,140.08 v1(206.59,140.08) ; R284.1 201.77,78.98 201.41,79.35 v1(201.41,80.16) ; R325.1 93.68,59.81 v1(93.43,59.81) ; v1(27.65,74.93) 27.9,74.67 C386.2 ; C328.2 138.91,109.94 v1(138.98,110.01) ; D3.2 212.03,87.75 v1(212.05,87.73) ; C428.2 196.2,58.29 195.8,57.88 v1(195.8,57.78) ; v1(141.57,181.73) 142.07,181.23 PC28.2 ; v1(131.53,48.64) 132.03,48.14 C464.2 ; C373.2 v1(89.88,85.85) ; C354.2 29.17,93.33 v1(29.17,93.47) ; v1(165.82,52.95) 165.82,53.59 165.05,54.37 C448.2 ; v1(205.63,200.4) 205.17,199.94 PC2.2 ; v1(129.12,189.48) 128.99,189.62 C27.1 C16.1 ; v1(39.39,51.3) C456.2 ; Q27.1 31.48,50.57 v1(31.97,51.05) ; v1(211.98,35.15) v3(210.76,35.15) C508.2 ; PC64.2 191.73,114.91 v4(191.98,114.66) ; C377.1 v1(34.37,81.28) ; v1(15.46,76.45) 16.09,76.45 Q26.2 ; PC35.2 155.67,177.92 v1(156.3,177.92) ; R202.1 v1(25.73,114.18) ; C439.2 165.39,55.32 v1(165.72,54.99) ; R320.2 23.84,61.71 v1(23.84,61.08) ; v2(126.26,114.34) 126.78,114.34 127.43,114.99 C290.2 ; Q17.1 208.9,132.13 v1(208.67,132.13) ; R176.2 v1(84.67,103.37) ; C9.1 128.49,193.65 128.08,193.24 127.85,193.24 127.55,192.93 v1(127.55,192.81) ; PC11.2 151.47,193.16 150.96,193.67 v1(150.2,193.67) 150.2,193.17 PC10.2 ; C344.1 180.52,101.94 180.52,101.89 v1(180.82,101.6) ; v1(142.2,40.38) 141.85,40.03 C486.2 139.25,40.03 v1(138.9,40.38) ; R294.1 v1(21.81,75.05) ; C306.1 v1(28.41,111.63) ; v1(180.78,102.64) 181.16,102.64 C345.1 ; v1(19.27,64.64) 19.27,64.5 C409.2 ; v1(172.3,48.51) 171.95,48.51 170.78,47.34 PQ6060.1 172.19,43.9 R786.2 ; v1(64.07,5.69) D28.1 ; v1(181.57,70.1) 181.22,69.74 PR149.1 ; R313.1 94.69,67.07 95.21,66.54 v1(95.34,66.54) ; C514.2 210.28,34.06 211.77,34.06 v1(212,33.83) ; C442.2 169.16,56 v1(169.91,56) ; D25.2 v1(68.54,6.47) ; v1(66.64,112.77) 66.65,112.78 C719.1 ; v2(128.09,114.33) 128.68,114.93 C291.2 ; v1(163.41,150.11) 163.31,150.21 Q6.1 ; R124.2 PR63.1 v1(191.3,135.76) ; v1(206.97,100.45) 207.43,100.91 PR122.2 ; C811.1 220.04,22.86 v1(220.18,22.72) ; CN4.3 v1(35.76,22.44) ; C381.2 C380.2 v1(82.26,75.82) ; v1(150.46,190.24) PC14.2 ; C511.2 17.37,33.14 v1(17.31,33.08) ; C458.2 v1(22.36,50.67) ; v1(167.35,97.92) 167.35,97.91 167.81,97.91 168.41,97.3 168.41,96.57 168.2,96.35 C349.2 C348.1 ; C440.1 v1(94.32,56.92) ; PR134.2 197.76,95.21 197.21,95.76 v1(197.21,96.13) ; v1(179.72,171.83) 179.67,171.83 179.25,172.24 C56.1 ; C810.2 72.22,19.84 v1(74.01,18.06) ; U1.5 117.34,184.3 v1(117.44,184.4) 117.44,185.03 117.34,185.14 U1.2 ; C321.1 v1(56.45,109.85) ; C555.2 v1(57.49,10.92) ; C318.2 133.57,109.56 v2(134.02,110.01) ; C361.1 29.58,91.79 v1(29.04,92.32) ; U12.7 v1(45.81,108.96) ; v1(24.73,41.27) 25.12,40.88 C483.2 ; C54.2 177.58,173.32 v1(177.51,173.39) ; v1(25.11,36.95) 25.49,37.33 R375.2 ; v1(132.25,61.94) 132.55,61.64 C421.2 ; v1(67.78,6.47) 67.4,6.85 D24.2 ; 165.47,46.83 165.49,46.85 C468.2 ; 165.47,46.83 C467.2 ; v1(60.15,14.28) 60.14,14.29 C545.2 ; v1(206.72,93.47) C357.2 ; R65.1 v1(111.09,171.8) ; v1(142.57,62.42) 143.02,62.42 143.22,62.23 C422.2 ; PR135.1 56.86,87.24 56.48,87.63 v1(56.35,87.63) ; C185.2 116.19,131.07 v1(116.05,131.21) ; PQ6058.1 v1(90.94,36.17) ; v1(144.87,143.38) 145.12,143.12 R98.2 145.62,142.36 C157.2 ; C813.1 v1(54.19,11.04) ; C728.1 66.26,109.72 v1(66.38,109.6) ; v1(125.6,107.62) 125.69,107.72 C324.2 ; v1(77.43,71.01) 77.08,71.37 PQ9.1 ; C48.1 v1(166.46,173.2) ; v1(80.84,68.12) 80.81,68.09 PQ13.1 ; C396.2 C395.2 v1(165.95,70.48) ; v1(195.8,57.15) C431.2 ; CN4.6 v1(28.26,22.53) ; v1(39.84,24.63) 40.32,25.12 C542.1 ; PQ16.1 v1(78.19,10.28) ; v1(209.74,20.49) 209.74,19.99 v3(209.36,19.6) 208.04,18.28 207.99,18.28 C796.2 ; PR10.1 164.3,196.82 v1(164.15,196.97) ; D6.2 15.35,75.39 v1(15.35,75.79) ; v1(180.38,118.49) 179.65,119.21 C797.2 ; C473.2 143.62,47.3 R346.1 143.18,48.38 v1(143.26,48.46) ; C360.2 201.12,91.41 v1(201,91.41) ; PC113.1 79.62,15.77 v1(80,16.15) ; v1(117.94,173.25) 117.74,173.25 v3(117.31,173.68) 117.21,173.68 116.6,173.07 Q4.1 ; PQ6057.1 90.18,30.63 v1(90.18,30.32) ; C43.2 v1(166.46,178.18) ; v1(163.64,51.3) 163.54,51.41 R335.2 ; v1(203.54,64.31) C412.2 ; v1(17.12,52.84) 17.12,52.87 17.03,52.96 C451.1 ; v1(209,198.74) 209.39,199.13 PC3.1 PC6.1 ; C450.1 v1(14.44,52.96) ; C326.2 135.59,107.97 v1(135.32,107.71) ; v1(162.77,92.07) 162.77,92.69 C352.1 ; C424.2 v1(22.95,60.57) ; C485.2 C484.2 v1(37.81,41.52) ; R295.2 v1(22.82,75.05) ; v1(45.19,19.95) 45.19,20.7 45.19,20.7 CN4.12 ; PC79.2 v1(201.58,107.63) ; C518.1 v1(23.41,32.77) ; PC46.1 150.47,171.06 v1(150.08,171.45) 149.69,171.06 PC45.1 ; R301.1 v1(80.61,73.92) ; PC104.1 v1(70.85,63.06) ; v1(47.54,9.7) 47.54,7.3 ; C417.1 v1(169.91,60.6) ; C168.1 v1(158.46,141.12) ; PR120.2 v1(196.13,102.61) ; U12.5 v1(45.81,111.5) ; v1(20.03,35.81) 19.9,35.94 R376.1 ; v1(167.22,110.88) 167.19,110.85 C314.2 ; C444.2 132.55,53.08 v1(132.3,52.83) ; v1(222.47,57.4) C438.2 ; D22.2 19.31,10.19 19.39,10.11 v1(19.39,9.52) ; v1(45.71,29.08) U25.2 ; R377.2 v1(20.92,35.81) ; C429.2 v1(169.91,58.21) ; v1(45.81,108.2) 45.81,107.95 46.06,107.69 U12.8 ; C474.2 v1(42.88,45.98) ; v1(203.03,69.72) 203.06,69.74 PQ8.1 ; v1(225.39,111.25) 225.25,111.38 C799.2 ; PC103.1 v1(46.32,69.97) ; C488.2 v1(36.04,40.63) ; v1(205.7,93.47) D2.2 ; C445.1 133.69,53.5 v1(133.55,53.36)
  IN2 w0.127: 135.65,136.67 135.14,137.18 135.14,138.6 135.37,138.83 135.72,138.83 v1(135.75,138.86) 137.3,137.31 137.3,135.48 135.8,133.98 135.8,130.34 v2(136.69,129.46) 136.82,129.33 136.82,128.47 v2(136.29,127.91) 136.12,128.09 135.17,128.09 134.96,128.29 134.96,134.69 v1(135.75,135.48) 136.08,135.81 v1(136.08,136.67) 135.65,136.67
  IN2 w0.254: v1(145.5,147.32) 145.5,148.08 146.52,149.09 147.82,149.09 152.62,153.89 152.62,163.37 149.72,166.27 149.72,167.13 140.05,176.8 139.47,176.8 138.58,177.68 138.58,179.35 139.31,180.08 v1(140.42,180.08) ; v1(122.77,159.25) 122.66,159.37 122.66,162.79 123.84,163.97 123.84,167.83 126.26,170.25 129.69,170.25 131.74,172.3 131.74,178.07 133.03,179.37 136.39,179.37 137.73,180.71 137.73,180.79 141.59,184.65 144.52,184.65 146.8,186.94 149.06,186.94 150.96,188.84 150.96,190.62 149.47,192.12 v1(149.47,193.67) ; v1(148.55,172.84) 148.81,172.59 154.31,172.59 156.99,169.91 159.11,169.91 161.51,167.51 161.51,166.33 162.37,165.47 162.37,161.13 161.38,160.14 161.38,155.19 160.22,154.03 153.84,154.03 151.96,152.15 151.96,147.6 v1(152.29,147.27)
  BOTTOM w0.089: U35.AP70 v2(117.85,113.3)
  BOTTOM w0.102: U35.L18 147.05,124.35 147.05,123.32 U35.P17
  BOTTOM w0.114: v1(149.82,194.99) 149.82,194.05 v1(150.2,193.67)
  BOTTOM w0.152: U35.BB60 122.94,108.63 122.94,107.75 v1(122.91,107.73)
  BOTTOM w0.157: v1(140.44,107.48) 140.32,107.6 140.32,108.63 U35.BB30
  BOTTOM w0.178: v1(115.36,117.37) 115.38,117.37 115.41,117.35 115.6,117.35 115.82,117.13 116.15,117.13 U35.AG71 ; v1(135.32,107.71) 135.32,107.71 U35.BB38 ; U35.AT68 118.46,112.03 118.45,112.03 118.45,111.65 118.5,111.6 118.5,111.34 118.47,111.3 U35.AV68 ; U35.H71 116.5,126.73 115.58,126.73 v1(115.42,126.57) ; v1(137.7,106.87) 137.68,106.89 137.68,108.64 U35.BB34 ; 154.63,126.79 154.5,126.92 154.5,127.61 154.86,127.97 U35.F4 U35.F2 155.98,128.25 156.33,128.25 U35.F1 ; U35.BB55 125.56,107.66 v1(125.6,107.62) ; v1(115.41,114.31) 115.57,114.47 116.22,114.47 U35.AM71 ; U35.BB43 132.72,107.71 v1(132.7,107.69) ; v1(203.42,194.03) 203.45,194.06 PU5.22 ; U35.AT71 116.46,112.17 115.46,112.17 115.46,112.17 v1(115.43,112.17) ; U35.BB26 142.66,107.76 v1(142.71,107.71)
  BOTTOM w0.203: U35.E18 146.6,128.22 146.2,128.62 ; v1(149.59,131.49) 149.34,131.21 149.34,130.3 U35.B14 ; 119.47,110.66 119.72,110.66 119.76,110.63 120.46,110.63 U35.AW64 120.99,110.59 121.02,110.62 121.31,110.62 121.34,110.59 U35.AW62 122.21,110.59 122.24,110.62 122.54,110.62 122.57,110.59 U35.AW60 123.44,110.59 123.47,110.62 123.77,110.62 123.8,110.59 U35.AW57 ; 119.47,110.66 119.47,110.14 U35.AY66 U35.BA66 ; 119.47,110.66 U35.AW66 119.01,111.12 v2(118.96,111.12) 118.76,110.92 U35.AV68 ; U35.D22 143.78,129.23 143.78,129.7 U35.B22 143.71,130.31 143.71,131.22 143.46,131.47 v1(143.25,131.47) ; PU15.10 181.23,66.84 181.39,66.67 ; U35.AW51 127.52,110.59 127.49,110.62 127.2,110.62 127.17,110.59 U35.AW53 126.3,110.59 126.27,110.62 125.97,110.62 125.94,110.59 U35.AW55 125.07,110.59 125.04,110.62 124.75,110.62 124.72,110.59 U35.AW57 ; U35.AW49 129.59,110.59 129.62,110.62 129.92,110.62 129.95,110.59 U35.AW47 130.76,110.59 130.79,110.62 131.08,110.62 131.11,110.59 U35.AW45 131.98,110.59 132.01,110.62 132.31,110.62 132.34,110.59 U35.AW43 133.21,110.59 133.25,110.63 133.52,110.63 133.56,110.59 U35.AW41 134.07,110.64 135.17,110.64 U35.AW38 135.71,110.59 135.74,110.62 136.04,110.62 136.07,110.59 U35.AW36 136.94,110.59 136.97,110.62 137.26,110.62 137.29,110.59 U35.AW34 138.17,110.59 138.23,110.64 138.93,110.64 U35.AW32 139.46,110.59 139.5,110.62 139.79,110.62 139.82,110.59 U35.AW30 140.59,110.59 140.62,110.62 141.07,110.62 141.1,110.59 U35.AW28 141.86,110.59 141.89,110.62 142.34,110.62 142.37,110.59 U35.AW26 143.15,110.59 143.18,110.62 143.47,110.62 143.5,110.59 U35.AW23 144.47,110.59 144.5,110.62 144.8,110.62 144.83,110.59 U35.AW21 145.54,110.59 145.57,110.62 146.05,110.62 146.08,110.59 U35.AW18 146.89,110.59 146.92,110.62 147.22,110.62 147.25,110.59 U35.AW16 ; v1(158.76,111.31) 158.76,111.29 158.1,110.63 157.23,110.63 157.06,110.8 U35.AV1 ; v2(124.43,111.1) 124.26,110.92 U35.AW57 ; 146.2,128.62 U35.D18 ; 146.2,128.62 145.49,128.62 v2(145.46,128.65) ; U35.BA2 156.51,108.95 156.68,108.78 U35.BA1 ; U35.K70 118.04,125.37 U35.K68 ; U35.AT68 118.46,112.26 118.45,112.26 118.45,112.51 118.5,112.56 118.5,112.84 118.45,112.89 118.45,113.25 118.46,113.26 U35.AP68 118.46,113.76 118.5,113.8 118.5,114.05 118.46,114.09 U35.AM68 ; U35.AW6 153.57,110.64 152.53,110.64 U35.AW8 ; v2(150.95,111.03) 150.75,111.03 150.31,110.59 U35.AW12 149.67,110.59 149.64,110.62 149.34,110.62 149.31,110.59 U35.AW14 ; v1(179.84,167.74) 179.85,167.73 U34.U26 ; v1(191.02,154.33) 191.03,154.34 191.03,154.97 191.22,155.16 191.59,155.16 192,154.74 U34.B11 ; U35.D48 U35.D47 129.86,128.99 130.25,128.99 130.27,128.96 130.57,128.96 130.59,128.99 130.98,128.99 U35.D45 ; U34.B8 192.07,152.26 191.62,152.71 191.04,152.71 v1(191.03,152.72)
  BOTTOM w0.229: PU8.21 143.51,165.6 PC149.1 ; PU7.21 v1(132.56,165.72) 132.04,166.24 PC147.1 ; v1(211.65,170.13) 211.65,170.07 212.3,169.42 U5.M9 ; PU6.21 123.69,166.99 123.53,167.15 PC146.1 ; PU9.21 154.77,165.6 154.5,165.32 154.5,165.2 v1(154.39,165.1)
  BOTTOM w0.254: U35.AM21 144.81,114.68 v2(144.46,115.03) ; v1(118.14,131.63) 118.14,131.4 U35.A67 ; v2(123.52,128.48) 123.63,128.48 124.1,128.95 U35.D58 U35.B58 ; U35.AT2 155.65,112.37 v2(155.34,112.37) 155.11,112.37 154.92,112.19 U35.AT4 154.31,112.73 U35.AR5 ; U35.AW32 v1(138.98,110.01) U35.BA32 ; U35.AW23 v2(143.96,110.01) U35.BA23 ; v1(115.19,125.25) 115.31,125.37 U35.K71 ; CN5.3 143.73,195.51 v1(143.73,195.09) ; v2(121.8,110.06) 121.79,110.06 ; 121.79,110.06 121.78,110.05 U35.BA62 ; 121.79,110.06 121.78,110.07 U35.AW62 ; U35.AW18 146.41,110.24 v2(146.66,109.98) 146.41,109.73 U35.BA18 U35.BB18 ; 147.14,125.91 147.14,125.97 U35.H18 ; 147.14,125.91 147.55,125.91 147.7,125.76 147.78,125.76 U35.K16 147.75,125.22 v2(147.75,125.09) ; 147.14,125.91 U35.K18 ; U35.AL45 132.2,114.7 U35.AM43 ; U35.D30 v2(139.09,129.46) U35.B30 ; v1(171.96,179.88) 171.54,180.3 U2.G9 ; U35.F68 117.99,127.95 v2(118.31,128.28) 117.99,128.6 U35.D69 ; v1(190.72,87.37) 190.72,86.28 191.89,85.1 U43.3 ; U34.E8 189.83,152.29 v1(189.45,152.68) ; U35.AR52 127.85,112.52 128.33,112.52 U35.AR50 ; U35.T2 155.52,122.79 v2(155.35,122.61) 155.17,122.79 U35.T4 ; U35.AA65 119.76,119.9 v2(119.76,119.78) ; v1(198.02,145.79) 198.02,145.73 198.34,145.41 201.13,145.41 v1(201.38,145.66) 202.4,145.66 202.91,146.17 202.91,149.47 202.65,149.73 198.84,149.73 198.53,150.05 v1(198.02,150.05) 197.19,150.87 197.19,151.16 v1(195.75,152.6) ; CN10.18 186.31,104.48 185.82,104.97 v1(185.83,105.66) ; v1(174.66,168.55) 174.79,168.42 174.79,167.22 U34.AC26 ; U35.AW10 151.25,110.73 v2(150.95,111.03) 151.35,111.43 U35.AU10 ; U35.AW10 151.6,110.59 151.75,110.74 152.33,110.74 U35.AW8 ; U35.AW10 U35.BA10 ; U35.AD62 121.01,118.85 v2(120.99,118.87) ; v2(132.73,128.67) 132.66,128.61 132,128.61 U35.D44 U35.B44 ; CN10.7 181.05,107.23 181.58,107.76 v1(181.58,108.08) ; v2(126.26,127.17) U35.G55 ; U35.BA36 v2(136.5,110.01) U35.AW36 ; U35.U70 116.83,122.24 117.16,122.56 ; U35.U64 120.73,121.89 121.07,121.55 ; U34.P26 182.33,167.82 v1(182.4,167.89) ; v1(164.54,129.92) 164.53,129.93 R569.2 ; U35.BA1 157.39,108.78 v1(157.45,108.71) ; C787.1 204.24,22.35 205.11,22.35 205.17,22.41 C788.1 v1(206.08,22.41) ; v2(120.76,112.42) 120.9,112.42 U35.AT63 ; U35.N68 v2(118.46,123.43) ; U35.K66 v2(119.74,125.28) U35.K65 U35.K64 ; U34.U10 179.4,153.22 v1(179.84,152.78) ; U35.B39 134.14,129.62 v2(134.33,129.43) 134.33,129.14 U35.D39 ; U35.G63 120.74,127.43 120.74,127.71 U35.E65 ; U35.AW45 U35.BA45 ; CN10.1 v1(181.6,108.72) ; v2(153.47,109.91) 153.47,109.57 U35.BA6 153.66,109.37 153.66,108.65 U35.BB6 ; U35.AM45 131.49,114.68 v2(131.77,114.4) 131.83,114.4 U35.AN43 ; v2(144.46,115.03) 144.32,115.18 144.32,115.39 U35.AK22 ; v2(144.46,115.03) 144.78,115.35 U35.AK21 ; v2(135.47,113.71) 135.27,113.71 U35.AP38 U35.AN38 ; v2(140.9,114.37) 141.22,114.68 U35.AM27 ; U35.L16 147.92,124.78 147.92,124.92 v2(147.75,125.09) ; U35.AF2 155.52,117.49 v2(155.35,117.31) 155.17,117.49 U35.AF4 154.08,116.71 U35.AH6 ; v1(217.94,75.43) 217.8,75.58 Q56.1 ; v2(129.92,128.48) v1(129.92,127.19) 129.9,127.16 129.7,127.16 U35.G48 ; U35.AW28 v2(141.48,110.01) U35.BA28 ; U35.AR8 152.18,112.73 v2(151.83,113.09) 151.7,113.09 U35.AP10 ; v1(115.63,128.72) 115.83,128.53 U35.E71 ; U35.U10 151.48,121.72 v2(151.78,121.42) 152.13,121.07 U35.W9 ; Q56.4 213.89,74.28 v1(213.65,74.04) ; U35.F13 149.33,127.82 v2(149.11,127.82) 149.06,127.82 U35.E15 ; U35.U69 117.48,122.24 117.16,122.56 ; v2(121.07,121.6) 121.07,121.55 ; 121.07,121.55 121.38,121.86 U35.U63 ; v1(205.67,165.03) 206.06,165.42 U31.G8 ; v1(171.11,176.73) 171.54,176.3 U2.B9 ; U35.C1 157.3,129.98 v1(157.37,129.99) ; v1(139.28,191.26) 139.53,191.26 140.51,192.24 140.51,192.64 141.19,193.32 141.19,193.87 CN5.9 ; v2(145.11,125.06) 145.11,124.99 U35.L20 ; v2(117.85,113.3) U35.AP68 ; U35.BA14 v2(148.83,109.96) U35.AW14 ; v1(135.34,188.59) 134.96,188.97 134.96,189.65 CN5.24 ; U35.AG18 146.41,116.8 146.41,116.61 U35.AJ18 U35.AK18 ; PC158.2 121.5,159.76 122.01,159.25 v1(122.77,159.25) ; U33.3 164.7,166.25 165.52,167.08 v1(166.31,167.08) ; U35.BA53 v2(126.73,110.06) U35.AW53 ; U35.BA41 v2(134.02,110.01) U35.AW41 ; U35.BA49 129.26,109.41 v2(129.26,109.85) 129.14,109.97 U35.AW49 128.84,110.59 U35.AW50 ; U35.B18 U35.D18 ; U35.B71 115.64,130.48 v1(115.47,130.66) ; U35.AV70 U35.AV71 115.52,110.73 v1(114.77,109.98) ; v1(138.26,191.38) 138.37,191.38 138.67,191.69 138.67,192.21 138.23,192.65 ; U35.AP23 143.18,113.38 v2(142.72,113.84) 142.98,113.84 U35.AN23 ; v1(194.49,152.62) 194.49,152.43 195.16,151.76 195.16,150.62 196.82,148.96 196.82,147.7 196.82,147.7 C644.1 ; v2(152.49,115.2) 152.49,115.33 U35.AK8 ; U35.N65 119.74,123.55 v2(119.74,123.44) ; U35.B34 136.69,129.9 v2(136.69,129.46) 136.62,129.38 U35.D34 ; PR180.2 150.58,192.56 v1(149.47,193.67) ; U35.W6 154.77,120.14 U35.AA4 155.17,120.14 v2(155.35,119.96) 155.52,120.14 U35.AA2 ; U35.L17 147.75,125.03 v2(147.75,125.09) ; CN10.69 181.06,91.72 181.32,91.98 v1(181.32,92.83) 180.93,93.23 CN10.63 ; U35.B53 126.7,129.63 v2(126.46,129.39) 126.7,129.15 U35.D53 ; v1(132.68,136.29) 129.83,136.29 129.54,136.58 Y4.4 128.8,137.32 128.59,137.54 128.59,140.1 129.07,140.58 133.57,140.58 ; U35.L2 155.45,125.44 v2(155.35,125.34) 155.25,125.44 U35.L4 ; U35.AG20 145.43,117.06 v2(145.76,116.73) 145.76,116.61 U35.AJ20 ; U35.AV68 118.13,110.92 v2(117.98,110.77) 117.94,110.73 U35.AV69 ; CN5.28 132.42,189.41 132.42,190.11 v1(133.11,190.8) ; 138.15,127.17 U35.F32 ; 138.15,127.17 v2(138.15,127.12) U35.J32 ; 138.15,127.17 U35.F33 ; U35.F23 142.84,127.91 v2(142.71,127.91) ; U35.G60 v2(123.52,127.17) U35.G58 ; U35.D66 119.21,129.01 119.21,129.35 v2(119.1,129.47) 119.1,129.8 U35.B66 ; v1(189.4,159.27) 189.83,159.7 U34.E17 ; U35.G52 127.68,126.92 v2(128.01,127.25) ; v1(117.16,122.56) 117.16,122.56 ; U35.K63 121.37,125.7 121.37,125.85 v2(121.65,126.13) 121.79,125.99 U35.K61 ; v2(126.26,112.39) 125.92,112.73 U35.AR55 ; v1(120.64,107.67) 120.64,108.6 U35.BB64 ; U35.K68 U35.K67 v2(119.09,125.28) ; U4.T1 206.87,172.69 207.2,173.02 207.81,173.02 208.14,172.69 v1(208.14,172.56) ; CN10.33 180.9,100.72 181.08,100.9 181.08,101.33 v1(180.82,101.6) ; v2(157.29,117.42) 157.22,117.49 U35.AF1 ; U35.BA57 U35.AW57 ; U35.A5 154.54,131.4 155.38,132.23 v1(157.06,132.23) 157.85,132.23 159.49,133.87 159.49,133.88 159.85,134.24 R555.2 ; v1(117.22,118.85) 117.24,118.82 117.25,118.82 117.48,118.59 U35.AE69 U35.AE68 118.18,118.45 118.73,118.45 U35.AE67 118.81,118.42 119.41,118.42 U35.AE66 119.46,118.42 120.06,118.42 U35.AE65 120.11,118.42 120.71,118.42 U35.AE64 ; v1(117.46,107.51) 117.94,107.51 118.59,108.16 U35.BB67 ; U35.D14 148.72,129.24 148.72,129.68 U35.B14 ; U34.AF5 172.35,149.77 172.09,149.52 v1(171.83,149.52) ; v1(137.3,190.65) 137.3,191.49 CN5.18 ; v1(139.18,192.07) 139.71,192.07 140.02,192.38 140.02,192.95 CN5.12 ; U35.B48 U35.D48 ; v1(136.36,189.48) 136.36,190.34 CN5.21 ; U35.AT58 123.64,112.42 v2(123.55,112.42) ; U35.AN33 137.38,113.72 v2(137.25,113.72) ; U35.K22 U35.G22 143.94,126.92 v1(143.63,127.23) 143.97,127.57 U35.F22 ; U34.P23 v1(181.92,164.31) ; v1(181.44,97.53) 181.25,97.72 CN10.45 ; CN10.51 v1(181.32,96.23) ; v2(118.46,119.77) U35.AA68 ; U35.U67 118.78,121.98 v2(119.11,121.65) 119.43,121.98 U35.U66 ; v1(181.4,99.43) 181.39,99.43 181.19,99.23 CN10.39 ; v2(130.83,127.17) U35.G45 ; U34.U23 v1(179.44,164.31)
  BOTTOM w0.279: Q37.4 216.99,91.67 v1(216.75,91.44) ; v1(221.07,93.21) 220.83,92.97 Q37.1
  BOTTOM w0.305: U35.C25 142.23,129.66 141.95,129.66 v2(141.76,129.47) ; U35.AG19 146.08,117.06 v2(145.76,116.73) ; JDIM2.189 160.04,53.53 159.37,52.85 v1(159,52.85) ; U35.AK16 148.2,115.28 v2(148.2,114.94) ; v2(152.49,120.38) 152.49,120.14 152.78,119.85 U35.AB8 ; U35.T18 147.03,121.86 v2(147.03,121.74) 147.03,121.61 U35.V18 ; v1(190.16,164.26) 189.83,163.94 U34.E22 ; U35.AN35 v2(136.32,113.71) ; v2(136.32,113.71) 136.19,113.71 U35.AN37 v2(135.47,113.71) ; v2(136.32,113.71) v2(136.32,113.06) U35.AP35 ; v1(156.97,45.62) 156.74,45.84 JDIM2.178 ; v1(182.93,179.87) 183.36,180.3 U3.G9 ; v2(144.49,123.41) 144.49,123.29 U35.P21 U35.T21 ; v1(189.4,162.58) 189.4,162.57 189.78,162.18 U34.E20 ; JDIM1.172 154.94,58.77 154.72,58.54 v1(154.71,58.54) 154.34,58.91 JDIM1.170 ; U35.AF10 151.22,117.89 v2(151.22,118.11) ; JDIM1.48 115.34,59.1 v1(115.08,58.84) 114.74,59.18 JDIM1.46 ; v2(146.39,112.4) U35.AR20 ; JDIM1.9 103.64,70.13 v1(104.21,70.7) ; JDIM1.187 159.44,70.08 158.74,70.78 v1(158.16,70.78) 157.74,70.78 157.04,70.08 JDIM1.179 ; v1(147.11,70.73) 147.54,70.73 148.64,69.63 JDIM1.151 ; v1(193.44,164.84) 193.4,164.84 193.36,164.79 192.35,164.79 U34.B23 ; U35.AH63 121.38,116.62 v2(121.06,117.08) 121.35,117.48 U35.AF63 ; U35.AT35 v2(136.32,111.76) ; U35.AM46 v2(129.92,114.36) U35.AL48 ; v1(192.61,156.8) 192.23,157.17 U34.B14 ; U35.E21 145.01,128.39 145.26,128.65 v2(145.46,128.65) ; JDIM1.150 148.34,58.95 v1(148.03,58.64) ; U35.AF15 148.83,118.11 v2(149.19,118.11) ; v1(161.38,53.08) 161.76,53.08 162.01,53.34 162.01,54.06 161.84,54.22 JDIM2.195 ; v2(152.49,115.2) 152.49,115.1 152.32,114.93 U35.AM8 ; v1(106.93,56.92) 106.64,56.63 JDIM2.19 ; U35.AB21 144.39,119.25 v2(144.23,119.25) 144.23,119.03 144.46,118.8 U35.AD21 ; v1(105.48,58.76) 105.14,59.1 JDIM1.14 ; v2(152.9,119.22) 152.9,118.82 U35.AD8 ; U34.H23 187.69,164.33 v1(187.72,164.33) ; JDIM1.49 115.64,69.55 114.88,70.32 v1(113.69,70.32) 113.84,70.16 JDIM1.43 ; 119.15,71.01 v1(118.99,71.01) ; 119.15,71.01 120.98,71.01 122.24,69.74 JDIM1.71 ; 119.15,71.01 120.44,69.71 JDIM1.65 ; JDIM2.144 v1(146.54,48.78) ; U35.AR63 v2(120.76,112.42) ; v1(161.81,125.24) 161.73,125.32 160.35,125.32 C695.1 ; v1(112.52,45.62) 112.34,45.79 JDIM2.38 ; v1(105.37,57.22) 105.32,57.22 104.84,56.75 JDIM2.13 ; JDIM1.28 109.34,59.09 108.39,58.13 v1(107.64,58.13) ; v2(132.66,127.17) U35.F42 ; v2(132.66,127.17) U35.G43 ; v2(132.66,127.17) U35.J42 ; U35.E56 125.06,128.39 125.06,128.44 v2(125.27,128.65) ; U35.AL4 155.14,114.84 v2(155.33,115.03) ; JDIM1.32 110.54,58.7 111.07,58.18 v1(111.37,58.18) ; JDIM2.134 143.54,48.17 v1(143.26,48.46) ; JDIM2.55 117.44,57.9 v1(117.91,58.36) ; v1(153.21,70.05) 153.44,69.82 JDIM1.167 ; U34.AB14 v1(175.25,157.64) ; U35.AR23 v2(142.72,112.41) U35.AT23 ; JDIM1.38 112.34,59.17 111.98,58.81 v1(111.37,58.81) ; JDIM1.196 162.14,61.41 v1(161.87,61.68) ; U35.P19 v2(145.76,123.41) U35.N19 ; JDIM1.138 144.74,59 144.98,58.76 v1(146.25,58.76) 146.54,59.06 JDIM1.144 ; U35.AG16 147.71,117.44 v2(147.71,117.52) 147.38,117.19 U35.AG17 ; U35.E65 119.95,128.28 v2(119.71,128.04) 119.71,127.55 U35.G66 ; U35.AP32 v2(138.11,113.04) ; U35.AL58 v2(124.45,114.35) ; v2(147.29,113.71) U35.AP18 U35.AN20 ; v1(100.71,70.7) 101.84,69.56 JDIM1.3 ; U35.B62 v2(121.75,129.46) U35.D62 ; v1(141.16,45.31) 141.74,45.89 JDIM2.128 ; 134.49,127.17 134.55,127.17 U35.F38 134.96,127.57 v2(135.4,127.12) 135.85,127.57 U35.F37 ; 134.49,127.17 U35.F40 ; 134.49,127.17 U35.J38 ; v1(103.34,52.7) 103.85,52.7 104.24,53.1 JDIM2.11 ; U35.AR48 v2(129.92,112.41) ; U35.P17 147.69,122.69 v2(147.69,122.58) 147.69,122.46 U35.T17 ; U35.AP58 v2(123.55,113.07) ; v2(152.73,127.24) 152.92,127.24 U35.G6 153.44,127.12 153.95,127.12 U35.G5 154.28,126.79 v2(154.65,126.79) ; U35.AU32 v2(138.11,111.09) ; v1(109.37,45.64) 109.34,45.67 JDIM2.28 ; JDIM2.155 149.84,56.9 150.39,57.45 v1(150.83,57.45) 151.11,57.45 151.94,58.29 JDIM1.162 ; U35.C5 153.94,129.04 U35.D6 153.85,128.95 153.58,128.69 v2(153.58,128.59) 153.23,128.25 U35.E6 152.78,127.92 U35.F8 152.16,127.57 151.86,127.27 U35.G10 ; v1(185.23,164.33) 184.88,164.68 184.86,164.68 U34.L23 ; U34.E25 190.21,166.75 v1(190.21,166.76) ; JDIM2.136 144.14,49.36 143.78,49.73 v1(143.26,49.73) ; v1(119.14,56.79) 119.24,56.68 JDIM2.61 ; v2(154.39,122.55) 154.39,122.65 U35.R6 154.39,123.28 154.39,123.72 U35.N6 ; U35.N21 144.81,123.83 145.09,123.54 v2(145.09,123.43) 145.11,123.41 U35.P20 ; v1(6.67,113.2) 6.72,113.15 7.15,113.15 7.23,113.08 U36.3 ; JDIM2.46 114.74,45.55 v1(114.81,45.49) ; v1(177.77,166.72) 177.37,167.11 U34.Y26 ; v1(152.76,49.17) 152.4,49.17 151.94,48.72 JDIM2.162 ; 147.76,121.73 U35.V17 ; 147.76,121.73 v2(147.73,121.73) ; 147.76,121.73 U35.V16 ; U35.AR58 v2(123.55,112.42) ; JDIM2.9 103.64,53.77 v1(103.34,53.46) ; U35.AM55 v2(125.35,114.36) ; v1(148.84,52.6) 148.97,52.6 149.48,53.11 149.48,53.87 149.24,54.11 JDIM2.153 ; JDIM2.3 101.84,53.7 101.85,53.69 v1(101.85,53.57) ; JDIM1.161 151.64,69.59 151.28,69.95 151.28,70.67 150.58,71.37 v1(149.95,71.37) ; U35.AL66 119.43,114.73 v2(119.84,114.33) 120.08,114.57 U35.AL65 U35.AL64 ; v1(139.06,115.9) 139.06,115.85 139.06,115.85 U35.AL32 ; U35.F37 136.32,127.11 U35.J35 ; U35.F37 136.2,127.91 v2(136.29,127.91) 136.44,127.91 U35.F35 ; U35.AL45 131.75,115.9 v1(131.75,115.9) ; v1(109.69,57.86) 108.44,56.61 JDIM2.25 ; v2(155.33,115.03) 155.53,114.84 U35.AL2 ; v2(155.33,115.03) 154.87,115.5 U35.AJ4 ; U35.AU20 145.95,111.43 v2(146.39,111.75) 145.92,112.08 U35.AT20 ; U40.3 12.45,106.64 v1(12.36,106.55) ; v1(187.72,165.92) 187.7,165.92 187.52,166.1 U34.H25 ; U35.Y17 v2(147.06,120.06) U35.AB18 ; JDIM2.66 120.74,48.88 121.06,49.2 v1(121.41,49.2) ; U34.B27 192.46,167.7 192.78,167.7 v1(192.8,167.71) 192.81,167.7 192.81,167.34 U34.A26 ; v2(141.76,129.47) 141.57,129.28 U35.D26 ; v2(141.76,129.47) 142.23,128.99 U35.D25 ; U35.AR11 150.24,112.99 v2(150.03,112.99) ; v2(132.68,112.38) 132.68,112.41 ; 132.68,112.41 133.11,112.73 U35.AR42 ; 132.68,112.41 133.11,112.08 U35.AT42 ; JDIM1.26 108.74,59.23 108.28,58.76 v1(107.64,58.76) 107.36,58.76 106.94,59.18 JDIM1.20 ; v1(161.6,49.3) 161.9,49.3 162.14,49.05 JDIM2.196 ; v1(142.49,56.79) 142.88,56.79 143.24,56.42 JDIM2.133 ; JDIM1.134 143.54,58.42 144.66,57.3 v1(145.38,57.3) 145.87,57.3 146.84,56.33 JDIM2.145 ; U35.AD13 149.08,119.14 149.08,119.24 U35.AB15 148.42,119.38 148.3,119.38 U35.AB16 v2(147.71,119.22) ; JDIM1.127 141.44,70.6 140.93,71.12 v1(140.8,71.12) ; JDIM1.11 104.24,69.91 ; 104.24,69.91 v1(104.24,69.93) ; 104.24,69.91 104.59,69.91 104.84,69.65 JDIM1.13 ; U35.AF17 v2(147.71,118.38) U35.AD16 ; JDIM1.153 149.24,70.01 149.75,70.52 v1(149.95,70.52) 149.84,70.42 JDIM1.155 ; JDIM1.133 143.24,66.68 142.85,66.28 v1(142.57,66.28) ; U35.AR46 v2(130.84,112.41) ; JDIM2.127 141.44,56.7 140.64,57.5 v1(140.34,57.5) ; v2(150.95,126.04) 150.53,125.62 U35.J11 U35.L11 U35.N10 ; U35.AK11 150.83,115.65 150.41,116.07 149.91,116.07 v2(149.85,116.02) 149.85,116.24 U35.AH13 149.5,116.59 148.99,116.59 U35.AJ15 ; JDIM2.8 v1(103.34,45.62) ; JDIM1.44 114.14,58.69 v1(112.98,57.53) ; U40.1 14.23,106.35 14.45,106.12 v1(14.87,106.12) ; JDIM1.37 112.04,69.6 111.1,70.55 v1(110.42,70.55) ; JDIM1.184 158.54,59.14 v1(157.7,58.29) ; U35.E46 130.12,128.48 v2(129.92,128.48) 129.86,128.54 U35.D47 ; U35.AP20 v2(146.39,113.05) ; v1(192.62,161.74) 192.23,162.13 U34.B20 ; U28.G8 177.14,180.27 v1(177.53,179.88) U2.G1 ; JDIM2.43 113.84,56.42 113.37,56.89 v1(112.98,56.89) ; U35.AK69 117.26,115.7 v2(117.64,115.7) 117.65,115.69 118.02,115.69 U35.AK68 ; CN10.57 180.95,94.72 181.44,94.23 v1(181.44,94.18) ; JDIM1.173 155.24,69.58 154.47,70.35 153.76,70.35 153.56,70.56 153.33,70.56 v1(153.2,70.68) ; JDIM2.60 118.94,48.48 v1(119,48.54) ; U35.AU15 148.99,111.76 v2(149.09,111.76) ; v1(190.23,157.63) 190.23,157.62 U34.E14 ; v1(119.14,58.21) 119.74,58.21 120.44,57.51 JDIM2.65 ; v1(102.37,62.4) 101.94,62.4 101.54,62 JDIM1.2 ; JDIM1.61 119.24,70.12 v1(118.99,70.37) 118.34,70.37 117.44,69.47 JDIM1.55 ; U37.3 15.57,109.66 16.52,108.71 17.13,108.71 v1(17.39,108.96) 16.87,109.48 U37.1 ; v1(205.66,167.45) 206.07,167.04 U4.J2 ; U35.AD20 v2(145.76,118.38) U35.AD19 ; U3.T9 183.27,187.5 182.79,187.02 v1(182.79,187.02) ; v1(140.89,115.88) 140.89,115.85 ; 140.89,115.85 U35.AK27 ; 140.89,115.85 140.89,115.85 U35.AL28 ; v1(106.94,45.59) JDIM2.20 ; U35.J28 139.98,127.08 140.43,127.54 U35.F28 140.72,127.86 141.06,127.86 U35.F27 141.66,127.88 141.8,127.88 141.82,127.91 v1(141.82,127.94) ; v1(150.83,56.82) 151.36,56.82 151.64,56.53 JDIM2.161 ; JDIM2.168 153.74,48.23 v1(154.05,48.54) 154.34,48.24 JDIM2.170 ; v1(110.42,71.18) 110.03,71.18 108.44,69.6 JDIM1.25 ; v1(145.36,49.68) 145.16,49.68 144.74,49.26 JDIM2.138 ; U34.AG2 171.54,147.42 v1(170.88,147.42) ; U35.B10 U35.D10 151.44,128.99 U35.D11 150.5,128.99 v2(150.11,128.6) 150.49,128.23 U35.E11 ; v1(114.05,45.49) 114.14,45.59 JDIM2.44 ; JDIM1.54 117.14,59.25 116.71,58.82 v1(116.3,58.82) ; v1(102.58,45.59) 102.04,45.59 101.54,46.09 JDIM2.2 ; JDIM2.72 122.54,45.63 v1(122.56,45.62) ; U35.AM13 149.76,114.5 149.97,114.5 v2(150.03,114.43) ; U35.A70 116.38,131.21 v1(116.05,131.21) ; v1(108.55,45.59) 108.74,45.79 JDIM2.26 ; U35.E53 126.87,128.38 126.87,128.79 U35.D53 ; v2(120.41,117.03) U35.AH64 120.73,116.3 U35.AK63 ; JDIM2.179 157.04,56.48 157.48,56.92 v1(157.7,56.92) 158.37,56.92 158.84,56.44 JDIM2.185 ; JDIM1.195 161.84,67.25 161.99,67.11 v1(161.99,66.92) ; U35.Y20 v2(145.76,120.06) U35.Y19 ; JDIM1.72 122.54,59.08 122.31,58.84 v1(121.28,58.84) 120.99,58.84 120.74,59.09 JDIM1.66 ; v1(119.14,57.5) 119.43,57.5 119.84,57.09 JDIM2.63 ; v1(155.58,49.17) 155.18,49.17 154.94,48.93 JDIM2.172 ; v1(181.92,149.34) 182.3,149.72 U34.P5 ; v1(105.89,45.6) 105.49,45.6 105.14,45.94 JDIM2.14 ; JDIM2.139 145.04,56.29 v1(145.42,56.66) ; JDIM1.60 118.94,61.66 v1(119.1,61.81) ; v1(111.34,57.4) 112.04,56.7 JDIM2.37 ; JDIM2.156 150.14,48.28 v1(149.89,48.54) ; v1(175.25,151.84) 174.83,152.25 U34.AC8 ; U35.AN30 v2(139.05,113.71) ; JDIM1.178 156.74,61.89 157.22,62.37 v1(157.53,62.37) ; JDIM2.150 v1(148.34,45.64) ; v1(160.98,66.13) 160.78,66.13 160.04,66.86 JDIM1.189 ; v1(160.4,48.69) 160.34,48.63 JDIM2.190 ; v1(121.63,52.83) 121.88,52.83 122.24,53.19 JDIM2.71 ; v1(116.3,58.16) 115.64,57.5 JDIM2.49 ; U35.AL38 135.41,115.16 v1(135.41,115.9) ; v2(144.23,116.84) 144.49,116.84 U35.AG21 ; JDIM1.128 141.74,61.9 142.27,62.42 v1(142.57,62.42) ; v1(121.29,66.13) 121.15,66.13 119.84,67.44 JDIM1.63 ; U35.AR53 v2(126.26,112.39) ; v1(111.1,45.62) 110.87,45.62 110.54,45.94 JDIM2.32 ; U35.T15 149.2,121.64 v2(149.2,121.44) 149.2,121.41 149.53,121.08 U35.W13 ; JDIM2.151 148.64,56.67 v1(148.04,57.27) ; CN10.75 179.1,90.23 v1(178.91,90.04) ; U35.AR16 v2(148.21,112.41) ; U35.AM61 v2(122.62,114.36) 122.94,114.68 U35.AM60 ; U35.AK18 146.73,115.35 v2(146.39,115.01) ; U35.AL55 v2(126.26,114.34) ; U35.AH67 v2(118.46,117.03) ; U35.AT56 v2(124.45,111.75) ; JDIM2.187 159.44,57.24 159.11,57.58 v1(157.7,57.58) ; U35.J25 v2(141.8,125.77) ; v1(191.81,145.74) 192.19,146.12 192.19,146.48 U34.B1 ; U35.AR45 131.76,113.07 v2(131.77,113.08) U35.AR43 ; v1(146.25,58.13) 144.72,58.13 144.14,58.71 JDIM1.136 ; JDIM1.31 110.24,69.69 v1(110.45,69.9) ; v2(150.04,126.01) U35.J13 149.31,125.62 U35.H15 ; v1(159.91,61.86) 160.34,61.43 JDIM1.190 ; v1(102.36,58.76) 103.2,58.76 103.34,58.91 JDIM1.8 ; v1(189.78,145.61) 189.71,145.68 189.71,147.25 U34.E2 ; v1(115.53,45.59) 115.34,45.77 JDIM2.48 ; v1(158.16,70.14) 158.36,70.14 158.84,69.66 JDIM1.185 ; JDIM1.19 106.64,70.3 105.61,71.34 v1(104.21,71.34) ; U35.E50 128.31,127.99 v2(128.08,127.99) ; U35.AM25 v2(141.83,114.38) ; U34.B17 192.23,159.7 v1(191.83,159.3) ; JDIM1.156 150.14,59.11 v1(150.84,58.42) ; U34.AB17 v1(175.25,160.12) ; v2(128.09,114.33) U35.AL52 ; JDIM2.173 155.24,56.61 154.81,57.05 v1(154.7,57.05) 153.67,57.05 153.44,56.82 JDIM2.167 ; U35.AU38 v2(134.53,111.12) ; U35.AN63 v2(120.76,113.72) ; U35.J8 152.32,125.43 U35.L8 153.11,124.64 v2(153.11,124.58) ; JDIM1.168 153.74,58.05 154.09,57.7 v1(154.7,57.7) ; U35.AP63 121.23,113.38 v2(120.76,113.07) ; U35.R13 149.26,123.24 v2(149.26,123.57) 149.26,123.76 U35.N13 ; JDIM1.139 145.04,69.75 145.39,70.1 v1(147.11,70.1) 146.84,69.84 JDIM1.145 ; U35.AN58 v2(123.55,113.72) ; v1(175.25,161.76) U34.AB20 ; U35.AR35 v2(136.32,112.41) ; v1(189.41,155.16) U34.E11 ; U35.AL35 137.23,115.85 137.23,115.85 v1(137.23,115.88) ; JDIM2.31 110.24,56.46 v1(109.69,57.02) ; v1(157.86,49.17) 158.24,49.17 158.54,48.87 JDIM2.184 ; U35.AN32 v2(138.11,113.69) ; U35.Y21 v2(144.46,120.06) ; U35.AP28 v2(139.98,113.06) U35.AR28 ; U35.AN28 v2(139.98,113.71) ; JDIM2.54 v1(117.14,45.62) ; v2(127.17,112.41) U35.AR52 ; U35.AT28 v2(139.98,112.41) ; v2(149.12,112.41) U35.AR15
  BOTTOM w0.33: U2.M9 171.54,184.3 171.39,184.3 v1(170.95,184.73) ; U28.D8 v1(177.54,177.5) ; U29.A9 v1(190.21,175.9) ; v1(183.8,186.29) U3.P9 ; U28.A9 v1(178.34,175.1) ; U3.G1 189.81,180.33 v1(189.41,180.73) 189.01,180.33 U29.G8 ; U29.E1 183.41,178.67 183.11,178.37 v1(182.83,178.37) 183.29,177.9 U29.D1 ; v1(189.41,178.3) 189.37,178.25 U29.D8 ; v1(171.94,178.3) U2.E8 ; v1(171.94,178.3) U28.E1 ; v1(171.94,178.3) U28.D1 ; v1(178.55,184.32) 177.96,184.32 U2.M1 ; U2.J8 172.73,181.5 v1(172.73,181.48) ; U2.T9 v1(171.14,187.9) ; U2.J2 176.77,181.53 176.77,181.5 v1(176.75,181.48) ; U3.M1 v1(190.21,184.7) ; U3.B9 183,175.89 183,175.88 v1(183.02,175.87) ; U28.F9 177.94,179.5 v1(177.54,179.1) U2.E2 ; v1(190.26,188.9) 190.28,188.87 190.28,188.11 189.81,187.64 U3.T1 ; v1(189.42,179.12) 189.41,179.12 189.01,178.72 U3.E2 ; v1(184.59,182.31) 184.59,182.28 U3.J8 ; v1(184.6,178.32) 184.58,178.32 U3.E8 ; U3.P1 v1(190.21,186.3) ; v1(178.33,187.1) U2.T1 ; U29.F9 v1(190.21,179.9) ; U29.B3 v1(184.62,175.91) ; U3.B1 v1(190.21,176.7) ; U28.B3 v1(173.54,175.9) ; U2.P1 177.53,186.3 v1(177.51,186.3) ; U3.M9 183.41,184.31 v1(182.87,184.86) ; U2.P9 v1(171.14,186.3) ; v1(188.61,181.5) U3.J2 ; U2.B1 v1(178.34,175.9)
  BOTTOM w0.356: U5.B1 218.79,161.42 v1(219.19,161.02) 218.92,160.75 218.92,160.75 218.79,160.62 U32.A9 ; 206.5,165.03 206.87,165.4 U4.G1 ; 206.5,165.03 v1(206.5,165.03) ; 206.5,165.03 206.87,164.66 U31.F9 ; 211.94,163.42 212.34,163.02 U32.D1 ; 211.94,163.42 212.34,163.82 U32.E1 ; 211.94,163.42 v1(211.89,163.42) ; U5.G9 211.95,165.03 v1(211.89,165.03) ; U4.P9 200.39,170.94 v1(199.26,170.94) ; v1(211.64,172.83) 212.13,172.83 U5.T9 ; v1(201.68,163.42) 201.67,163.42 201.45,163.64 201.45,163.68 201.32,163.82 U4.E8 ; v1(200.07,161.82) 200.47,161.42 U4.B9 ; U5.G1 v1(218.34,165.02) 217.94,165.42 U32.G8 ; U31.D1 200.47,163.02 v1(200.07,163.42) ; v1(219.19,164.12) 218.74,164.57 U32.F9 ; U31.E1 v1(200.04,164.25) ; U5.T1 219.04,172.92 v1(219.34,172.92) ; v1(211.51,171.06) 211.56,171.02 U5.P9 ; v1(202.53,161.02) 202.47,161.02 U31.B3 ; U5.E2 217.96,163.82 v1(218.35,164.21) ; U4.E2 206.09,163.82 ; 206.1,163.82 v1(206.5,163.42) 206.09,163.02 U31.D8 ; 206.09,163.82 v1(206.5,164.22) ; U4.P1 208.14,172.29 v1(208.14,172.56) ; U5.E8 213.16,163.82 v1(213.56,163.42) ; U31.A9 v1(207.27,161.02) U4.B1 ; U4.G9 200.5,165.42 v1(200.87,165.06) ; U4.J8 200.87,166.62 v1(200.87,166.58) ; U32.D8 v1(218.34,162.62) ; U4.M1 206.94,169.35 207.16,169.35 207.17,169.35 207.65,169.35 v1(208.19,169.88) ; v1(219.14,169.82) 218.74,169.42 U5.M1 ; v1(215.38,160.81) 214.99,160.81 214.82,160.99 214.37,160.99 U32.B3 ; v1(211.89,161.02) 211.94,161.02 212.34,161.42 U5.B9 ; v1(218.34,166.62) 217.94,167.02 U5.J2 ; v1(219.14,171.42) 218.74,171.02 U5.P1 ; v1(199.07,169.14) 199.16,169.06 200.11,169.06 U4.M9 ; U5.J8 v1(212.74,166.62)
  BOTTOM w0.381: v1(175.09,102.03) 174.85,102.03 C741.2 ; R784.2 209.14,46.19 208.93,46.4 v1(207.84,46.4) ; U34.AB7 175.66,151.42 v1(175.25,151.84) ; U34.AD21 U34.AD22 ; U34.AD22 174.03,163.83 173.63,164.23 v1(173.63,164.24) ; U34.AD22 174.13,163.73 174.74,163.73 U34.AC22 ; CP2.8 171.62,26.11 v1(171.92,26.54) 172.4,25.93 CP2.6 ; CP1.8 167.93,26.11 168.24,26.41 ; v1(186.86,157.76) 186.39,158.22 U34.K15 v1(185.84,158.72) U34.L16 ; U34.Y2 177.37,146.04 v1(177.15,145.82) ; CP1.6 168.72,25.93 168.24,26.41 ; v1(186.86,150.16) 187.29,149.72 U34.H5 ; CP5.8 182.79,25.85 v1(183.1,26.16) 183.58,25.68 CP5.6 ; CP5.4 184.39,25.93 184.62,26.16 v1(184.87,26.16) 185.18,25.85 CP5.2 ; U34.M15 184.33,158.24 ; 184.33,158.24 v1(184.9,157.68) 184.9,157.66 U34.L14 U34.K13 ; 184.33,158.24 v1(183.78,158.8) 183.35,159.22 U34.N16 ; R497.2 166.62,146.34 v1(166.84,146.12) ; CP2.4 173.22,26.18 v1(173.44,26.54) 174,25.85 CP2.2 ; U34.AC2 174.91,147.32 175.28,146.95 v1(175.28,146.9) ; v1(191.83,150.2) 192.23,149.8 U34.B5 ; U34.AF17 172.83,160.1 v1(172.83,160.12) ; R648.2 151.32,104.29 v1(151.32,104.62) ; CP3.8 175.3,25.98 v1(175.6,26.54) 176.09,25.8 CP3.6 ; v1(172.83,161.77) 172.83,161.78 U34.AF20 ; U34.AE20 173.23,162.16 v1(173.63,161.76) 174.03,161.36 U34.AD19 ; U34.V11 177.89,154.67 v1(177.89,154.78) ; CP6.4 188.2,25.93 v1(188.56,26.28) 188.99,25.85 CP6.2 ; v1(184.39,149.32) 184.79,149.72 U34.L5 ; CP3.2 177.69,25.73 v1(177.13,26.54) 176.9,26.06 CP3.4 ; U34.AA7 177.02,151.91 177.46,151.91 v1(177.51,151.96) ; CP1.4 169.53,26.06 v1(169.89,26.54) 170.32,25.98 CP1.2 ; CP4.6 179.9,26.03 v1(179.72,26.21) 179.11,25.6 CP4.8 ; U4.T9 199.93,172.62 v1(199.62,172.31) ; R532.2 115.18,138.41 v1(115.18,139.59) ; v1(182.33,146.66) U34.P2 ; v1(175.29,165.11) 175.7,165.52 U34.AB24 ; U34.AE17 173.24,159.71 173.63,160.1 v1(173.63,160.13) 173.67,160.17 173.67,160.2 174.02,160.54 U34.AD18 ; v1(195.41,140.2) 195.54,140.33 195.54,140.85 R504.2 R505.1 ; v1(172,152.65) 172.38,152.26 U34.AF8 ; v1(184.4,165.95) 184.78,166.32 U34.L25 ; v1(165.39,116.4) 165.47,116.33 166.32,116.33 R606.1 ; v1(171.23,167.52) U34.AG26 ; R522.2 R521.2 193.24,138.73 ; U34.U2 179.87,147.32 v1(180.26,147.71) ; R492.2 204.38,147.77 v1(204.91,147.24) 205.45,147.77 R493.2 ; v1(209,147.24) 208.47,147.78 R491.2 ; v1(175.26,155.16) U34.AB11 ; U34.AF23 172.15,164.96 172.13,164.96 v1(172.01,165.09) ; v1(161.81,125.24) 161.99,125.42 161.99,125.79 C793.1 ; CP4.2 181.5,25.85 v1(181.06,26.28) 180.71,25.93 CP4.4 ; U34.M11 183.86,154.7 v1(183.86,154.73) 183.37,155.22 U34.N12 U34.P13 U34.R14 ; v1(171.59,146.43) 171.69,146.52 U34.AF1 ; v1(165.93,118.9) 165.93,118.82 165.6,118.49 C794.1 ; 168.24,26.41 v1(168.24,26.54) ; v1(146.02,105.64) 146.02,104.78 C739.1 ; v1(163.03,115.15) 162.99,115.19 R592.1 ; v1(192.95,146.12) 193.03,146.21 U34.A2 ; v1(9.36,109.34) 9.28,109.42 U38.3 ; v1(176.96,164.33) 177.35,164.72 U34.Y23 ; U34.U5 180.25,150.12 v1(180.25,150.14) ; CP6.8 186.6,25.98 v1(186.91,26.28) 187.39,25.8 CP6.6 ; U34.AD15 v1(173.64,158.46) 174.03,158.86 U34.AD16 ; R502.2 193.27,140.8 v1(193.77,140.3) 194.33,140.87 R503.2 ; R490.2 166.26,148.49 v1(166.67,148.89) ; R523.1 v1(195.55,138.1) ; v1(153.56,103.37) 153.56,103.92 R642.2 ; v1(177.79,150.11) 177.76,150.11 U34.Y5 ; C712.2 162.19,116.28 v1(162.65,116.73) 163.04,116.34 R587.2 ; U34.V17 U34.U16 U34.T15 ; v1(175.3,149.35) 174.88,149.76 U34.AC5 ; U34.H2 187.29,146.08 v1(186.98,145.77) ; v1(163.03,114.07) R598.1 ; U34.E5 189.84,149.77 v1(190.25,150.18) ; U34.P15 182.33,158.23 v1(181.81,158.75) 181.34,159.22 U34.R16 U34.T17 ; v1(212,33.83) 211.67,33.5 R785.2 ; v1(184.81,146.55) U34.L2
  BOTTOM w0.406: U44.25 213.46,50.04 v1(213.96,50.54) ; U44.11 218.01,56.5 v1(218.02,56.51) ; v1(213.7,54.05) 213.46,54.29 U44.4 ; v1(218.01,48.15) U44.18
  BOTTOM w0.432: v1(181.57,65.65) v1(181.57,66.29) 181.57,66.49 181.39,66.67
  BOTTOM w0.457: R455.1 200.25,188.22 v1(200.88,188.84) 200.37,189.35 R451.1 ; v1(194.65,188.34) 195.41,188.34 R453.2 ; 201.89,186.94 R458.1 ; 201.89,186.94 v1(202.02,187.07) ; 201.89,186.94 201.89,186.3 201.38,185.8 R461.1 ; R701.1 34.64,88.4 v1(34.84,88.21) ; C761.2 37.05,86.1 v1(36.97,86.03) ; v1(37,88.21) 37.07,88.13 C757.2 ; v1(202.02,184.53) 202.17,184.37 C584.2 202.17,182.39 v1(202.02,182.24) ; R469.1 202.4,178.43 v1(202.27,178.3) ; C604.2 197.02,163.33 v1(197.65,163.95) 196.99,164.61 C603.2 ; C606.2 195.93,161.17 195.67,160.9 v1(195.67,160.27) ; C575.1 194.4,186.42 C576.1 194.42,186.03 v1(194.78,185.67) 194.08,184.97 R464.2 ; C601.2 v1(195.77,168.45) ; v1(199.62,172.31) 198.43,172.31 C600.1 ; v1(177.51,173.39) 177.5,173.38 R471.2 ; v1(196.2,156.94) 196.2,158.13 C608.1 ; v1(202.53,151.38) C636.1 ; v1(36.92,87.12) C758.2 ; v1(202.02,179.57) 202.1,179.65 C590.1 ; C598.2 174.71,173.14 174.63,173.22 v1(174.63,173.24) ; PC240.1 193.91,63.72 v1(193.93,63.72) 193.33,63.12 PR309.2 ; v1(179.72,171.83) 180.02,171.83 180.41,171.44 C599.1 ; v1(203.67,151.38) C637.1 ; v1(34.81,86.05) 34.25,86.61 C760.2 ; v1(201.38,151.38) C635.1
  BOTTOM w0.508: PC222.2 v1(59.78,92.07) ; CN18.6 65.4,20.49 v1(64.4,20.49) ; PC247.1 194.37,60.07 v1(194.75,60.45) ; R735.2 194.91,49.78 194.77,49.92 v1(194.77,50.33) ; v1(130.77,191.08) 129.16,191.08 CN5.44 ; v1(221.48,45.28) 221.48,45.28 220.94,45.82 C807.1 ; v1(32.09,83.82) 31.58,84.33 C762.2 ; C785.1 193.65,21.88 v1(193.94,21.59) ; v1(59.78,91.18) 60.16,90.8 PC225.2 ; v1(160.77,131.64) 161.11,132.08 R566.2 ; v1(161.1,110.87) 161.15,110.82 R614.1 ; v1(169,182.75) 168.99,182.76 168.26,182.76 C586.2 ; v1(175.53,113.08) 175.68,112.92 175.91,112.92 176.11,112.72 U39.4 ; v1(199.4,199.08) 199.66,199.34 PC116.1 ; C731.2 C735.2 191.82,106.98 v1(192.52,107.67) ; v1(78.8,21.48) 78.8,21.08 78.35,20.62 PU19.2 ; v1(201.28,16.96) 201.2,17.05 CN17.10 ; R685.1 166.98,96.13 166.72,96.39 R681.1 167.27,97 167.3,96.97 v1(167.35,96.97) ; C732.2 162.85,107.69 v1(163.03,107.87) ; v1(141.57,182.75) 141.57,182.76 PC135.2 ; C818.1 139.92,199.65 v1(139.92,199.26) 139.2,199.26 CN5.43 ; R678.1 167.25,98.01 v1(167.35,97.92) ; CN6.5 210.74,143.99 211.04,144.28 211.81,144.28 v1(212.05,144.52) ; C45.2 166.48,176.93 v1(166.46,176.91) ; v1(113.68,130.68) 113.29,130.68 R554.2 ; v1(154.01,99.69) 153.89,99.69 152.87,98.67 R675.2 ; v1(207.48,102.13) 207.25,102.36 PC214.2 ; v1(13.14,110.87) 13.31,110.69 C720.1 ; v1(134.33,185.29) C578.1 ; v1(180.76,139.42) 180.98,139.64 180.98,140.16 R510.1 ; v1(200.67,28.49) 200.67,27.8 C780.2 ; v1(216.88,59.43) R729.1 ; v1(69.81,115.31) v3(69.81,114.42) 69.81,114.04 68.87,113.1 CN8.3 ; v1(169,179.45) 168.87,179.57 168.49,179.57 168.25,179.82 C42.1 ; PC126.2 165.4,190.67 v1(165.19,190.88) ; PR331.1 82.65,18.83 v1(82.44,18.61) ; U46.2 210.63,25.42 v1(210.4,25.65) ; v1(199.1,18.46) 199.25,18.61 C790.2 ; v1(132.68,136.29) 133.16,136.77 133.43,136.77 C665.1 ; SW1.6 v1(212.4,78.9) ; PQ39.1 55.41,25.83 v1(55.36,25.78) ; v1(99.66,116.33) 100.03,116.7 C710.1 C711.1 ; v1(217.01,46.22) C774.2 ; Y4.4 130.18,137.32 130.64,137.79 v1(130.64,138.17) 130.64,138.54 131.13,139.02 Y4.2 ; R750.2 33.23,32.25 v1(33.74,32.25) ; C756.1 176.62,89.41 v1(176.62,89.45) ; C742.1 148.78,101.09 v1(149.44,101.75) ; Q36.1 221.83,95.25 v1(221.07,94.48) ; v1(196.81,102.61) 197.27,102.15 PR267.1 ; C752.2 215.51,94.2 v1(216.37,93.34) ; v1(217.94,77.85) 218.14,78.04 C764.2 ; SW2.6 197.15,17.18 196.56,17.78 v1(196.3,17.78) ; R692.2 v1(215.47,91.57) ; R553.1 127.54,135.43 v1(126.78,135.43) ; v1(213.96,84.45) 214.49,83.91 SW1.1 ; v1(210.68,57.27) C767.2 ; v1(81.51,114.84) 80.97,114.3 PC194.1 ; v1(212.94,17.13) 213.88,17.13 R787.2 ; R621.1 114.19,108.4 114.31,108.28 115.48,108.28 v1(115.66,108.45) ; R473.1 v1(168.11,168.52) ; v1(140.05,153.67) PC160.2 ; Y3.4 201.51,148.71 v1(200.65,147.85) 199.81,147.01 Y3.2 ; C715.2 23.25,113.41 23.25,114.22 v1(23.58,114.55) ; v1(55.82,30.35) 56.4,30.35 PQ35.1 ; C644.1 v1(198.02,145.79) ; PC173.2 104.99,140.33 v1(105.75,141.09) ; v1(197.09,50.41) 197.19,50.31 C769.2 ; CN18.5 61.09,21 61.56,21.46 v3(61.56,21.79) v1(61.56,22.6) ; R558.1 120.74,135.3 120.28,135.76 120.28,135.91 v1(119.85,136.34) ; v1(220.18,22.72) 220.05,22.6 CN22.11 ; PC149.1 142.56,165.73 v1(142.2,165.73) ; R646.1 167.88,104.92 168.12,105.16 R635.1 168.12,106.13 v1(168.29,106.29) ; v1(172.81,99.11) 173.27,99.11 173.57,99.41 U41.4 ; C680.2 156.1,134.23 v1(156.45,134.59) ; v1(149.79,18.41) CN20.28 ; v1(148.42,196.72) 147.67,197.47 C803.1 ; C573.1 166.56,188.03 v1(166.51,187.98) ; C579.1 v1(165.62,186.3) ; v1(194.91,82.55) 195.57,82.55 196.05,83.03 C763.2 ; v1(140.04,154.43) 140.55,154.43 141.3,153.67 PC161.2 ; v1(168.62,159.89) 168.62,160.02 167.96,160.68 C80.2 ; PR248.1 106.26,135.5 v1(106.51,135.25) ; C783.2 205.78,23.54 v1(205.96,23.36) ; v1(196.5,15.31) SW2.4 ; CN22.12 219.02,14.8 219.02,15.73 v1(219.48,16.19) ; v1(13.07,111.96) 12.89,112.14 C716.1 11.4,112.37 C714.1 ; PC282.1 v1(52.66,33.37) ; R759.2 158.79,111.28 v1(158.76,111.31) ; 108.91,129.67 v1(108.95,129.67) 108.68,129.93 C682.2 ; PC130.1 203.79,188.73 v1(203.42,189.1) ; v1(132.17,184.3) C581.2 ; PC219.1 v1(202.53,97.63) ; v1(171.16,189.99) 171.16,190.88 PC127.2 170.4,190.62 v1(170.4,189.99) ; v1(147.54,175.26) PC139.2 ; R706.1 v1(55.84,89.78) ; v1(115.63,128.72) 114.26,128.72 113.08,129.9 R548.2 ; v1(154.39,165.1) 153.89,165.6 PC151.1 ; C772.2 206.59,50.16 207.35,50.92 v1(207.76,50.92) ; C776.2 214.36,44.32 v1(214.97,44.32) ; PC132.1 209.41,188.46 v1(209.54,188.34) ; PC235.1 v1(177.76,73.02) ; v1(112.1,142.54) 112.1,143.28 PC6230.1 ; v1(210.84,41.02) C778.2 ; C698.1 160.29,122.55 v1(159.98,122.25) v1(159.35,122.25) ; v1(131.53,157.22) PC159.2 ; v1(203.16,201.42) 202.53,200.78 PC115.1 ; v1(166.97,168.78) C602.1 ; R537.1 123.53,138.88 123.56,138.91 123.58,138.91 v1(123.61,138.93) ; v1(180.43,62.48) 180.71,62.76 PC242.1 ; C786.2 209.27,22.09 209.89,21.46 v1(210.15,21.46) ; R605.1 R595.1 167.07,114.04 167.09,114.02 v1(167.09,113.99) ; v1(204.05,50.16) C771.2 ; C814.1 110.29,139.07 v1(109.77,139.59) ; v1(162.9,112.92) 162.85,112.98 R766.1 ; C46.2 167.14,175.76 166.84,176.07 v1(166.46,176.07) ; C718.1 11.65,110.74 v1(12.41,110.74) ; C574.2 v1(162.19,189.15) ; v1(195.94,50.29) 195.94,49.65 R736.2 ; C798.1 191.22,95.37 190.46,95.37 v1(190.08,94.99) ; v1(209.26,119.63) 209.26,120.26 209.64,120.65 PC193.1 ; v1(177.76,50.06) PC268.1 ; R563.1 162.63,130.44 v1(162.56,130.52) 162.56,131.3 163.6,132.34 R564.1 ; v1(215.73,59.43) R728.1 ; C770.2 200.62,50.26 v1(200.49,50.39) ; D33.2 14.06,21.54 13.86,21.74 v1(13.35,21.74) 13.35,23.06 13.11,23.3 CN16.11 ; v1(208.37,25.14) C781.2 ; C747.2 177.77,97.52 v1(177.63,97.66) 177.77,97.79 C745.1 ; R783.2 188.93,42.73 189.35,42.3 v1(189.35,42.09) 189.93,42.67 C777.2 ; C48.1 v1(166.46,173.2) ; C819.1 112.86,146.05 112.86,146.05 112.86,146.05 v1(112.86,146.05) ; R707.1 56.86,89.91 v3(56.53,90.24) 56.22,90.55 v1(55.84,90.55) ; PR337.2 53.2,30.02 v1(52.97,29.79) ; v1(166.43,189.53) 166.46,189.51 C28.2 ; v1(172.81,90.29) 172.3,89.78 C754.1 ; PC174.1 103.59,134.49 103.29,134.79 v1(103.29,135.12) 103.47,135.12 103.85,135.5 PU10.2 ; PC278.2 84.77,22.63 84.8,22.65 v1(84.8,22.68) ; v1(66.51,91.31) 66.51,91.66 PC223.2 ; v1(209.77,77.93) 210.7,77.93 211.06,77.57 C765.2 ; v1(172.53,87.09) 173.08,87.09 C759.1 ; v1(111.47,180.46) 111.48,180.46 111.71,180.69 C817.1 ; v1(142.97,171.44) PR224.2 ; v1(23.46,94.53) 23.21,94.28 U42.25 ; v1(166.43,175.26) 166.59,175.1 C47.2 ; CN5.42 124.39,186.79 123.58,187.6 v1(123.56,187.6) ; v1(192.15,17.9) SW2.5 ; v1(214.97,44.95) C775.2 ; R720.2 13.65,75.69 v1(13.2,76.15) ; PQ36.1 71.46,28.37 71.64,28.55 v1(71.95,28.55) ; v1(58.99,75.31) 58.99,75.51 58.53,75.97 PR294.2 ; PC93.1 v1(203.03,98.29) ; v1(192.37,179.32) 192.73,179.68 C592.1 ; PC122.2 199.2,195.45 198.72,195.93 v1(198.72,196.95) ; v1(199.99,191.36) 200.25,191.1 R445.1 ; C805.2 v1(142.63,14.35) ; PQ33.1 60.92,30.15 v1(60.52,30.15) ; C753.2 C755.2 v1(192.25,88.27) ; C768.2 218.92,57.35 v1(218.79,57.22) ; v1(135.6,186.94) 135.59,186.93 C804.1 ; HOLE7.1 160.74,99.87 160.74,97.28 C748.1 ; PR225.2 120.99,169.59 v1(120.89,169.49) ; v1(214.72,28.95) 214.59,29.08 v1(214.03,29.08) C779.2 ; SW1.2 206.79,83.25 v1(206.59,83.05) ; C677.1 v1(148.58,134.62) C172.1 ; PC252.1 194.45,59.22 v1(194.77,59.22) ; v1(153.5,190.24) PC129.2 ; PJ1.9 v1(151.14,200.4) ; CN17.9 211.19,18.14 v1(211.39,18.33) ; v1(163.08,111.83) R610.1 ; v1(207.89,143.12) 208.67,142.34 208.67,141.58 208.35,141.25 CN6.1 ; v1(79.22,78.98) v1(79.87,78.33) 80.48,77.72 J1.2 ; C628.2 162.28,153.8 161.89,153.41 v1(161.76,153.41) 161.38,153.03 C816.1 ; v1(120.26,139.04) 120.26,138.81 120.74,138.32 R534.1 R535.1 ; v1(152.67,95.75) 153.5,95.75 153.77,96.02 C750.2 ; v1(144.74,14.35) D34.2 ; R447.2 R450.2 139.53,189.35 v1(139.94,189.76) v1(140.42,190.24) ; PJ1.10 171.34,200.09 v1(170.78,200.66) ; C724.2 10,108.83 v1(9.87,108.96) ; C713.1 16.19,113.68 v1(16.19,112.95) ; PC123.1 203.41,192.41 203.09,192.73 203.09,193.7 v1(203.42,194.03) ; R739.2 202.92,49.53 v1(203.42,50.03) ; BT1.2 v1(64.1,65.66) ; v1(74.71,18.06) 75,17.77 PC271.1 ; SW1.5 v1(212.31,83.9) ; v1(167.22,110.88) 167.08,110.74 R616.1 166.57,110.77 R612.1 ; v1(131.15,184.35) C580.1 ; 145.13,200.07 145.46,200.4 v1(147.66,200.4) ; PC226.2 66,90.8 v1(66.13,90.67) ; C800.2 143.73,191.65 143.92,191.84 144.49,191.84 144.81,192.16 v1(144.81,192.22) ; v1(213.32,59.43) C766.2 ; CN17.5 205.04,19.2 205.45,18.79 v1(205.45,18.41) ; C639.1 v1(198.02,150.05) ; C699.1 155.97,139.29 155.76,139.5 v1(155.76,139.89) ; C43.2 v1(166.46,178.18) ; v1(167.29,190.55) PC125.1 ; v1(133.31,185.26) C577.1 ; R760.2 v1(110.54,108.27) ; C773.2 v1(74.01,18.06) ; SW2.3 196.5,18.74 v1(196.3,18.54) ; v1(209.64,73.66) Q40.1 ; PR289.1 v1(58.89,87.63) ; PC146.1 122.9,167.03 v1(122.9,166.11) ; v1(147.32,13.42) CN20.30 ; v1(179.27,13.22) CN20.29 ; v1(165.06,108.71) R624.2
  vias: v1(0.9,21.87) v1(1.18,37.31) v1(1.28,56.49) v1(1.28,40.08) v1(1.64,21.89) v1(2.4,99.64) v1(4.1,40.03) v1(4.13,22.09) v1(4.25,121.89) v1(4.51,58.85) v1(4.58,76.27) v1(4.81,37.36) v1(4.94,55.32) v1(7.28,111.4) v1(7.53,114.98) v1(7.71,40.05) v1(7.91,22.04) v1(8.09,37.33) v1(8.52,110.97) v1(8.57,58.97) v1(8.72,76.5) v1(9.84,114.47) v1(9.99,57.35) v1(10.12,106.93) v1(10.12,105.53) v1(11.01,39.87) v1(11.01,21.97) v1(11.14,55.37) v1(11.14,37.31) v1(11.9,104.01) v1(13.07,72.56) v1(13.17,114.3) v1(13.68,104.26) v1(14.11,70.76) v1(14.21,29.08) v1(14.29,30.76) v1(14.39,46.73) v1(14.9,42.87) v1(14.9,42.19) v1(14.9,41.52) v1(14.9,40.84) v1(15.96,31.75) v1(15.96,30.98) v1(16.73,49.91) v1(17.41,123.77) v1(17.61,110.36) v1(17.74,48.27) v1(17.74,47.51) v1(17.68,42.46) v1(17.77,40.41) v1(18.15,31.16) v1(18.15,29.08) v1(18.55,33.52) v1(18.76,49.91) v1(20.1,41.96) v1(20.49,109.98) v1(20.49,108.53) v1(20.66,41.4) v1(20.94,107.11) v1(20.87,31.14) v1(20.97,46.73) v1(20.97,44.75) v1(21.22,41.96) v1(21.42,38.73) v1(21.6,7.18) v1(21.68,64) v1(21.81,107.08) v1(21.91,109.9) v1(21.93,108.58) v1(21.96,123.82) v1(23.36,110.03) v1(23.36,108.56) v1(23.43,107.11) v1(23.43,63.6) v1(23.38,38.73) v1(23.58,35.81) v1(23.71,21.2) v1(23.96,51.3) v1(24.73,51.3) v1(24.85,47.81) v1(25.77,123.9) v1(25.97,7.26) v1(27.77,10.05) v1(28.41,20.57) v1(29.55,102.99) v1(29.68,110) v1(29.68,107.92) v1(29.81,98.04) v1(29.81,97.28) v1(29.81,96.52) v1(29.81,20.57) v1(29.93,123.95) v1(29.93,51.3) v1(30.31,53.16) v1(30.49,10.05) v1(30.82,35.81) v1(30.82,34.03) v1(30.82,32.13) v1(31.1,86.74) v1(31.08,67.69) v1(31.33,20.57) v1(31.46,65.27) v1(31.46,63.39) v1(31.58,69.85) v1(31.97,32.13) v1(32.14,88.13) v1(32.22,10.23) v1(32.35,85.47) v1(32.6,89.68) v1(32.6,34.03) v1(32.6,20.57) v1(32.73,109.72) v1(32.73,83.56) v1(32.7,35.81) v1(33.26,60.96) v1(33.36,94.36) v1(33.36,92.71) v1(33.49,67.59) v1(33.49,65.5) v1(34.28,62.43) v1(34.38,34.03) v1(34.51,35.81) v1(34.66,124) v1(34.68,96.26) v1(34.76,73.2) v1(34.76,71.07) v1(34.89,87.12) v1(35.75,10.28) v1(35.9,96.26) v1(35.9,88.13) v1(35.9,87.12) v1(35.9,86.1) v1(36.97,10.05) v1(37.05,54.86) v1(37.68,20.39) v1(37.81,96.26) v1(38.06,94.74) v1(38.65,124.02) v1(38.82,55.49) v1(39.87,9.85) v1(41.01,20.04) v1(41.72,7.26) v1(42.25,83.56) v1(42.71,124.02) v1(42.89,70.35) v1(43.14,77.19) v1(43.57,84.76) v1(44.28,78.86) v1(45.96,7.21) v1(47.71,124) v1(49.03,6.22) v1(49.36,123.82) v1(50.74,6.19) v1(53.86,5.69) v1(54.06,22.35) v1(54.19,56.38) v1(54.32,24.25) v1(54.83,20.8) v1(54.88,62.1) v1(55.74,0.83) v1(55.82,60.3) v1(56.12,122.12) v1(56.6,62.86) v1(56.6,62.23) v1(56.98,23.87) v1(56.98,22.22) v1(57.24,62.23) v1(57.87,22.98) v1(58.43,22.22) v1(58.64,23.87) v1(58.76,2.33) v1(59.5,20.06) v1(59.55,26.06) v1(61.15,121.92) v1(62.95,118.51) v1(66,2.28) v1(68.26,117.37) v1(69.99,0.81) v1(71.67,23.31) v1(71.92,120.95) v1(72.3,23.31) v1(75.02,124.33) v1(79.59,126.87) v1(80.43,80.72) v1(80.48,0.83) v1(81.95,5.71) v1(82.44,80.72) v1(84.06,46.27) v1(84.42,129.92) v1(87.19,6.24) v1(88.07,15.39) v1(88.1,10.61) v1(88.23,19.73) v1(89.85,132.79) v1(91.02,23.03) v1(93.03,77.49) v1(93.33,76.04) v1(93.43,133.6) v1(94.22,77.62) v1(94.53,80.46) v1(94.6,78.91) v1(95.08,74.04) v1(95.08,73.27) v1(95.34,67.31) v1(95.54,76.78) v1(95.72,74.04) v1(95.72,73.27) v1(95.87,77.34) v1(95.87,76.22) v1(96.35,135.12) v1(97.5,23.39) v1(97.93,139.67) v1(98.56,46.15) v1(100.67,19.17) v1(100.67,13.84) v1(101.82,52.27) v1(101.87,49.53) v1(102.45,65.65) v1(102.55,143.63) v1(102.96,10.41) v1(103.31,49.53) v1(104.36,62.6) v1(104.53,40.38) v1(105.22,40.38) v1(105.37,65.02) v1(105.52,62.33) v1(105.75,52.95) v1(105.88,49.4) v1(105.85,40.38) v1(106.31,147.54) v1(107.45,65.62) v1(107.51,62.48) v1(107.57,53.11) v1(107.81,10.41) v1(108.06,49.32) v1(108.72,174.19) v1(108.8,169.01) v1(108.8,162.99) v1(108.83,157.32) v1(108.75,151.91) v1(108.85,179.29) v1(109,64.71) v1(109.44,50.29) v1(109.47,51.94) v1(109.68,118.71) v1(109.94,53.13) v1(110.31,118.71) v1(110.95,118.71) v1(111.34,179.19) v1(111.32,65.77) v1(111.37,115.62) v1(111.49,185.57) v1(111.58,118.71) v1(111.7,52.83) v1(112.08,112.14) v1(112.79,10.41) v1(112.93,49.2) v1(112.99,110.1) v1(113.25,66.12) v1(113.25,62.45) v1(113.45,114.3) v1(114.08,121.66) v1(114.13,51.3) v1(114.72,121.66) v1(114.77,136.77) v1(114.77,103.96) v1(115.23,66.86) v1(115.15,62.73) v1(115.35,121.66) v1(115.65,52.6) v1(115.66,49.53) v1(116.17,189.66) v1(116.29,107.18) v1(116.65,66.13) v1(117.6,52.98) v1(117.73,49.3) v1(117.92,62.48) v1(118.71,66.04) v1(119.52,10.44) v1(120.22,153.34) v1(120.48,189.99) v1(121.07,193.44) v1(121.12,189.99) v1(121.12,183.69) v1(121.29,62.45) v1(121.37,190.62) v1(121.67,50.7) v1(121.75,183.69) v1(122.39,183.69) v1(123.41,162.56) v1(123.41,161.92) v1(123.41,161.29) v1(123.41,160.65) v1(124.55,10.44) v1(124.7,52.83) v1(124.71,49.04) v1(125.26,66.76) v1(125.26,63.97) v1(125.26,62.45) v1(125.44,197.48) v1(125.41,102.31) v1(126.62,102.31) v1(126.71,134.26) v1(127.18,66.87) v1(127.18,65.55) v1(127.7,118.66) v1(127.65,63.59) v1(127.67,62.3) v1(127.95,134.36) v1(128.02,49.73) v1(128.02,48.46) v1(128.33,118.66) v1(128.69,103.45) v1(128.87,133.55) v1(128.97,118.66) v1(129.12,52.95) v1(129.2,194.59) v1(129.32,174.62) v1(129.35,193.43) v1(129.6,118.66) v1(129.67,66.1) v1(129.83,10.46) v1(129.88,49.27) v1(130.24,118.66) v1(130.32,63.28) v1(130.32,61.96) v1(130.26,52.32) v1(130.87,118.66) v1(131.03,202.18) v1(131.03,15.87) v1(131.03,14.6) v1(131.34,103.5) v1(131.53,50.03) v1(131.71,123.24) v1(131.76,197.07) v1(132.04,195.7) v1(132.17,197.58) v1(132.32,118.69) v1(132.28,65.57) v1(132.4,133.85) v1(132.35,123.24) v1(132.92,104.16) v1(133.18,57.3) v1(134.19,51.97) v1(134.32,200.05) v1(134.53,10.46) v1(134.58,25.01) v1(134.65,50.57) v1(135.39,104.4) v1(135.37,102.48) v1(135.75,139.52) v1(136.14,49.88) v1(136.17,63.08) v1(136.33,200.39) v1(136.49,193.95) v1(136.87,203.58) v1(137.12,103.12) v1(137.41,51.05) v1(137.48,195.35) v1(138.18,66.05) v1(138.44,133.17) v1(138.63,49.73) v1(138.9,102.54) v1(139.4,53.72) v1(139.46,125.42) v1(139.64,65.98) v1(139.87,197.02) v1(140.09,125.42) v1(140.17,123.57) v1(140.17,118.87) v1(140.17,117.78) v1(140.17,10.41) v1(140.3,124.25) v1(140.3,122.04) v1(140.27,120.9) v1(140.55,178.56) v1(140.68,8.76) v1(140.8,104.42) v1(140.8,102.48) v1(140.93,117.72) v1(141.1,53.74) v1(142.41,103.12) v1(142.62,53.11) v1(142.86,203.55) v1(144.23,117.47) v1(144.23,51.56) v1(144.36,102.48) v1(144.49,186.3) v1(144.47,66.01) v1(144.79,6.22) v1(146.31,66.03) v1(146.26,62.7) v1(146.65,140.97) v1(146.81,53.11) v1(147,138.17) v1(147.83,49.55) v1(148.02,62.52) v1(148.17,65.37) v1(148.91,188.06) v1(149.19,144.14) v1(149.31,182.49) v1(149.31,181.73) v1(149.31,181.1) v1(150.02,61.98) v1(150.08,182.49) v1(150.08,181.73) v1(150.08,181.1) v1(150.46,66.26) v1(150.84,182.49) v1(150.84,181.73) v1(150.84,181.1) v1(151.07,203.58) v1(151.25,62.38) v1(151.28,49.17) v1(151.51,53.11) v1(151.98,6.17) v1(153,141.09) v1(153.42,53.11) v1(153.5,197.86) v1(153.5,197.23) v1(153.5,196.59) v1(153.69,63.59) v1(153.69,62.32) v1(154.11,197.56) v1(154.55,65.29) v1(154.77,197.86) v1(154.77,197.23) v1(154.77,196.59) v1(154.77,195.07) v1(154.77,53.34) v1(154.96,63.21) v1(155.89,6.17) v1(156.04,197.86) v1(156.04,197.23) v1(156.04,196.59) v1(156.04,195.07) v1(157.53,65.37) v1(157.73,52.58) v1(157.73,50.44) v1(158.2,203.58) v1(158.62,115.34) v1(158.91,66.19) v1(159.35,92.32) v1(160.24,92.32) v1(161.66,6.19) v1(162.01,63.7) v1(162.75,75.94) v1(162.75,75.31) v1(162.75,74.67) v1(164.88,139.62) v1(164.99,138.25) v1(164.99,43.54) v1(165.95,203.6) v1(166.1,49.91) v1(166.15,154.4) v1(166.66,171.29) v1(166.97,138.73) v1(167.2,6.17) v1(168.03,150.9) v1(168.82,47.67) v1(168.9,155.55) v1(168.95,157.73) v1(169.15,150.08) v1(169.25,159.89) v1(169.33,154.12) v1(169.38,163.8) v1(169.56,168.96) v1(169.63,157.3) v1(169.68,160.78) v1(169.68,78.25) v1(169.84,80.06) v1(170.09,151) v1(170.45,203.58) v1(170.45,77.01) v1(170.45,74.47) v1(171.62,157.12) v1(171.62,129.43) v1(171.97,155.11) v1(172.83,155.14) v1(173.47,6.17) v1(173.57,106.65) v1(173.65,156.79) v1(173.77,79.8) v1(174.31,178.81) v1(174.82,175.56) v1(175.2,203.58) v1(175.3,180.67) v1(175.25,159.24) v1(176.29,195.02) v1(176.49,145.36) v1(176.54,143.68) v1(176.54,141.7) v1(176.92,195.02) v1(177.23,192.22) v1(177.36,161.57) v1(177.84,158.64) v1(177.89,156.84) v1(178.4,41.02) v1(178.4,40.38) v1(178.4,39.75) v1(178.52,161.92) v1(178.63,192.2) v1(179.16,6.17) v1(179.54,131.72) v1(179.67,156.74) v1(179.67,154.68) v1(179.87,160.57) v1(180.53,179.02) v1(180.56,203.58) v1(180.81,155.72) v1(180.86,153.74) v1(180.96,145.59) v1(180.99,144.32) v1(180.99,143.38) v1(181.7,72.13) v1(181.7,71.5) v1(181.78,160.73) v1(181.88,152.78) v1(181.98,121.92) v1(182.71,98.55) v1(183.02,192.17) v1(183.65,192.2) v1(183.86,156.69) v1(183.91,152.52) v1(184.01,138.04) v1(185,101.16) v1(185,100.53) v1(185.28,138.04) v1(185.81,203.55) v1(185.81,154.68) v1(185.84,152.73) v1(185.77,106.29) v1(185.92,160.78) v1(185.97,179.98) v1(186.17,178.35) v1(186.4,138.04) v1(186.4,60.78) v1(186.4,60.14) v1(186.4,59.46) v1(186.37,6.17) v1(186.47,47.87) v1(186.68,175.43) v1(186.93,155.77) v1(187.34,143.94) v1(187.49,161.57) v1(188.96,138.04) v1(189.57,47.24) v1(190.69,193.59) v1(191.33,203.58) v1(191.33,193.59) v1(192.44,150.06) v1(192.72,6.17) v1(193.51,78.61) v1(194.02,78.1) v1(194.4,56.33) v1(194.91,192.88) v1(195.54,192.88) v1(196.02,192.3) v1(196.23,138.1) v1(196.28,192.88) v1(196.71,203.53) v1(196.94,192.88) v1(197.37,10.64) v1(197.9,192.88) v1(198.21,134.49) v1(198.84,134.49) v1(199.73,155.57) v1(199.73,151.38) v1(200.49,151.38) v1(200.62,40.86) v1(200.65,155.32) v1(201.33,155.55) v1(202,103.69) v1(202,102.93) v1(202.02,11.2) v1(202.07,155.57) v1(202.83,203.5) v1(202.78,155.57) v1(202.76,103.69) v1(202.76,102.93) v1(202.78,18.54) v1(203.54,155.57) v1(203.92,142.49) v1(204.15,165.71) v1(204.21,164.36) v1(204.43,162.4) v1(205.02,33.17) v1(205.96,155.59) v1(206.46,68.45) v1(206.49,35.2) v1(206.84,155.57) v1(206.97,22.09) v1(207.61,155.57) v1(207.68,203.58) v1(208.62,127) v1(208.67,131.47) v1(208.95,11.22) v1(209.05,183.74) v1(209.18,184.73) v1(209.72,182.47) v1(209.84,184.78) v1(209.77,183.69) v1(209.81,164.34) v1(210.42,166.04) v1(210.45,182.49) v1(211.21,140.76) v1(211.21,140.1) v1(211.65,188.79) v1(211.8,187.32) v1(211.87,18.97) v1(212.36,19.4) v1(212.69,155.57) v1(212.81,21.2) v1(212.81,20.57) v1(212.76,19.93) v1(212.99,203.58) v1(213.75,9.6) v1(214.59,154.81) v1(214.64,28.24) v1(214.64,27.61) v1(214.64,26.97) v1(214.64,26.34) v1(215.02,164.17) v1(215.23,155.55) v1(216.32,167.85) v1(216.32,44.6) v1(216.45,47.49) v1(217,154.94) v1(217.39,18.45) v1(217.39,17.78) v1(217.39,17.14) v1(217.39,16.45) v1(217.51,155.57) v1(218.02,18.45) v1(218.02,17.78) v1(218.02,17.14) v1(218.91,155.32) v1(219.11,133.09) v1(219.14,130.86) v1(219.24,130.22) v1(219.37,203.55) v1(220.15,144.34) v1(220.18,140) v1(220.18,136.72) v1(220.69,35.94) v1(221.32,126.49) v1(221.32,125.85) v1(221.83,121.51) v1(221.88,74.6) v1(222.01,12.59) v1(222.01,9.17) v1(222.06,79.52) v1(222.34,32.89) v1(222.34,16.33) v1(222.87,69.13) v1(223.1,169.54) v1(223.1,168.91) v1(223.41,146.25) v1(223.74,169.54) v1(223.74,168.91) v1(223.86,108.45) v1(223.86,107.69) v1(223.86,106.93) v1(223.86,48.26) v1(224.52,116.99) v1(224.5,48.26) v1(224.55,95.3) v1(225.39,107.31) v1(225.39,106.68) v1(225.44,96.85) v1(225.77,105.51) v1(226.02,107.31) v1(226.02,106.68) v1(226.15,203.55) v1(226.33,124.76) v1(226.28,21.2) v1(226.66,107.31) v1(227.14,171.19) v1(227.22,182.57) v1(227.19,179.19) v1(227.19,174.75) v1(227.22,167.74) v1(227.19,163.5) v1(227.22,159.48) v1(227.19,155.7) v1(227.19,151.94) v1(227.16,147.85) v1(227.75,185.97) v1(228.36,119.35) v1(229.04,40.64) v1(229.07,68.58) v1(229.07,64.51) v1(229.1,44.62) v1(229.07,30.53) v1(229.07,27.3) v1(231.74,203.4) v1(233.21,199.23) v1(233.21,196.87) v1(233.69,118.97) v1(233.72,117.75) v1(233.74,113.48) v1(233.74,109.32) v1(233.74,105.28) v1(233.74,96.29) v1(233.72,93.39) v1(233.72,89.51) v1(233.77,100.1) v1(233.79,87.17) v2(144.23,120.65) v3(5.35,105.05) v3(8.47,57.12) v3(8.65,77.92) v3(8.85,21.79) v3(10.58,113.81) v3(11.26,38.32) v3(11.62,38.86) v3(11.95,21.76) v3(16.75,122.02) v3(18.83,123.24) v3(20.76,110.99) v3(28.49,10.92) v3(30.52,96.59) v3(33.97,87.85) v3(35.75,94.28) v3(47.66,8.02) v3(53.61,85.82) v3(53.61,85.29) v3(56.83,55.98) v3(62.73,50.16) v3(68.59,22.68) v3(70.22,49.83) v3(71.13,44.09) v3(73.11,123.64) v3(74.43,123.06) v3(76.11,114.35) v3(77.48,125.09) v3(82.31,7.16) v3(83.17,7.03) v3(96.89,72.64) v3(97.12,128.37) v3(97.12,24.18) v3(103.8,125.78) v3(106.95,116.66) v3(120.31,183.79) v3(122.14,190.55) v3(127.75,164.87) v3(129.76,138.04) v3(129.93,146.05) v3(133.21,142.19) v3(133.69,163.88) v3(139.71,128.95) v3(141.47,11.1) v3(145.45,148.33) v3(146.32,163.14) v3(147.49,158.19) v3(148.35,146.1) v3(149.64,183.41) v3(151.8,163.6) v3(154.11,195.86) v3(155.97,164.44) v3(161.3,162.53) v3(167.68,155.01) v3(168.06,169.72) v3(176.64,193.75) v3(180.91,191.44) v3(181.55,146.25) v3(182.44,71.98) v3(183.17,60.93) v3(184.24,127.33) v3(186.98,61.95) v3(187.06,146.63) v3(187.59,192.83) v3(191.25,133.78) v3(192.11,158.52) v3(192.93,192.86) v3(193.26,114.8) v3(193.81,77.06) v3(196.33,198.7) v3(196.33,196.26) v3(197.02,134.01) v3(200.67,202.23) v3(202.22,146.68) v3(207.33,194.48) v3(210.5,183.26) v3(210.6,184.22) v3(211.72,20.72) v3(212,154.91) v3(212.71,140.58) v3(213.09,11.45) v3(213.4,192.2) v3(213.65,116.58) v3(214.11,191) v3(215.51,110.66) v3(215.73,14.09) v3(216.12,154.43) v3(218.78,15.03) v3(218.94,154.12) v3(220.28,125.98) v3(222.24,169.24) v3(222.8,124.99) v3(223.56,124.63) v3(224.12,24.66) v3(225.49,24.53) v3(225.97,48.87) v3(226.94,183.92) v3(226.96,184.63) v3(227.06,114.42) v3(227.57,114.37) v3(231.28,197.48) v3(231.91,197.53) v4(54.78,84.72) v4(54.81,83.97) v4(55.51,84.73) v4(55.55,83.96) v4(56.88,54.96) v4(57.51,56.47) v4(57.52,55.55) v4(60.08,41.63) v4(60.11,40.74) v4(60.11,39.85) v4(60.11,38.96) v4(60.92,39.39) v4(61.18,49.81) v4(61.44,50.58) v4(61.97,50.03) v4(61.97,49.27) v4(61.98,48.47) v4(61.99,47.7) v4(61.99,46.85) v4(61.99,46.07) v4(63.65,49.73) v4(63.65,48.95) v4(63.66,48.14) v4(63.66,47.37) v4(64.43,48.95) v4(64.44,48.14) v4(64.44,47.37) v4(66.11,47.54) v4(67.47,55.95) v4(68.58,47.69) v4(69.29,48.1) v4(69.3,47.32) v4(69.98,48.48) v4(69.99,47.71) v4(70.24,40.76) v4(70.61,46.09) v4(70.76,48.48) v4(70.77,47.71) v4(70.77,46.9) v4(71.29,40.71) v4(71.44,51.21) v4(71.52,46.09) v4(71.55,48.48) v4(71.55,47.7) v4(71.55,46.9) v4(72.24,51.16) v4(72.42,46.61) v4(72.42,45.81) v4(73.06,52.75) v4(73.83,52.75) v4(74.21,122.07) v4(74.21,121.31) v4(75.07,122.07) v4(75.07,121.31) v4(75.83,122.42) v4(75.83,121.51) v4(76.64,122.78) v4(76.64,121.97) v4(76.64,121.15) v4(77.36,123.14) v4(77.81,122.53) v4(78.17,123.59) v4(78.47,122.88) v4(78.88,124.05) v4(79.59,124.46) v4(80.93,44.83) v4(80.93,44.06) v4(80.94,43.25) v4(82.38,112.77) v4(82.89,113.38) v4(83.99,45.41) v4(83.99,44.4) v4(83.99,43.25) v4(96.96,126.46) v4(97.52,127.02) v4(98.03,127.58) v4(98.59,128.11) v4(98.67,123.31) v4(99.17,123.85) v4(99.71,124.35) v4(100.22,124.89) v4(100.75,125.4) v4(101.26,125.93) v4(101.79,126.44) v4(102.32,126.97) v4(102.86,127.5) v4(109.41,127.3) v4(110.15,127.3) v4(110.88,127.3) v4(118.2,148.97) v4(118.2,148.21) v4(118.18,147.48) v4(118.2,146.74) v4(118.18,146) v4(118.18,145.26) v4(125.95,165.35) v4(126.2,166.11) v4(126.83,165.35) v4(127.09,166.11) v4(127.95,145.11) v4(128.1,148.76) v4(128.1,148.03) v4(128.1,147.29) v4(128.1,146.55) v4(128.16,145.82) v4(128.46,164.19) v4(129.15,165.21) v4(129.15,164.45) v4(129.15,163.68) v4(129.93,165.19) v4(129.93,164.43) v4(129.93,163.66) v4(130.01,162.81) v4(129.98,161.96) v4(129.98,161.2) v4(129.98,160.44) v4(130.7,165.19) v4(130.7,164.43) v4(130.7,163.66) v4(130.74,161.96) v4(130.74,161.2) v4(130.74,160.44) v4(130.77,162.81) v4(132.24,161.92) v4(132.24,161.16) v4(132.24,160.4) v4(132.54,164.97) v4(132.54,164.21) v4(132.55,163.44) v4(132.55,162.68) v4(132.68,181.78) v4(132.68,180.97) v4(133,161.92) v4(133,161.16) v4(133,160.4) v4(133.69,181.78) v4(133.69,180.97) v4(134.71,181.78) v4(134.71,180.97) v4(135.09,164.08) v4(135.47,164.97) v4(135.72,181.78) v4(135.72,180.97) v4(135.98,164.08) v4(136.36,164.97) v4(138.77,163.77) v4(138.77,163.01) v4(138.77,162.25) v4(139.53,163.77) v4(139.53,163.01) v4(139.53,162.25) v4(140.29,163.77) v4(140.29,163.01) v4(140.29,162.25) v4(140.68,164.46) v4(141.05,163.77) v4(141.05,163.01) v4(145.22,146.68) v4(145.22,145.66) v4(145.98,164.86) v4(145.96,163.89) v4(145.99,146.68) v4(145.96,145.56) v4(147.23,164.86) v4(147.26,163.88) v4(148.78,163.08) v4(148.84,162.34) v4(148.83,161.59) v4(148.8,160.84) v4(148.8,160.05) v4(148.77,159.31) v4(148.77,158.56) v4(148.93,152.4) v4(148.93,151.63) v4(149.19,163.7) v4(149.62,163.09) v4(149.62,162.36) v4(149.62,161.6) v4(149.62,160.83) v4(149.62,160.07) v4(149.62,159.31) v4(149.62,158.55) v4(149.69,152.4) v4(150.38,163.12) v4(150.38,162.36) v4(150.38,161.6) v4(150.38,160.83) v4(150.38,160.07) v4(150.38,159.31) v4(150.38,158.55) v4(151.14,163.12) v4(151.14,162.36) v4(151.14,161.6) v4(151.14,160.83) v4(151.14,160.07) v4(151.14,159.31) v4(151.14,158.55) v4(156.83,163.84) v4(157.01,164.73) v4(157.99,164.73) v4(157.95,163.83) v4(159.98,163.44) v4(160.36,162.78) v4(160.36,162.05) v4(160.74,163.44) v4(161.48,163.44) v4(180.73,59.08) v4(180.85,61.59) v4(180.85,60.7) v4(180.85,59.81) v4(181.64,61.59) v4(181.64,60.7) v4(181.64,59.81) v4(181.71,59.08) v4(182.85,126.91) v4(182.85,126.17) v4(182.85,125.43) v4(183.71,124.86) v4(184.06,124.18) v4(184.47,124.86) v4(184.8,124.18) v4(185.23,124.86) v4(190.15,63.74) v4(190.97,63.75) v4(191.83,63.76) v4(192.04,112.24) v4(192.19,113.58) v4(192.52,112.87) v4(192.71,111.75) v4(192.9,113.79) v4(193.13,112.44) v4(193.43,113.25) v4(193.43,110.92) v4(193.66,111.77) v4(193.86,112.57) v4(194.3,114.78) v4(194.32,110.92) v4(194.59,111.77) v4(194.98,114.03) v4(195.1,114.78) v4(195.2,110.92) v4(195.57,113.43) v4(195.8,197.7) v4(195.94,196.97) v4(195.88,115.9) v4(195.94,114.1) v4(196.18,115.18) v4(196.34,112.61) v4(196.41,113.43) v4(196.56,197.73) v4(196.68,196.97) v4(197.22,113.46) v4(197.23,112.61) v4(197.15,111.78) v4(197.3,197.4) v4(197.35,196.66) v4(197.94,110.92) v4(198.04,111.78) v4(198.11,112.61) v4(198.83,110.92) v4(198.93,111.78) v4(199.29,113.85) v4(199.72,110.92) v4(200.13,113.1) v4(200.15,113.86) v4(200.82,112.31) v4(200.99,113.84) v4(200.97,113.1) v4(204.81,126.36) v4(204.81,125.6) v4(205.57,126.36) v4(205.57,125.6) v4(213.42,198.27) v4(213.42,197.25) v4(213.42,196.24) v4(213.63,113.24) v4(213.63,111.71) v4(213.63,110.98) v4(213.65,115.49) v4(213.65,114.75) v4(213.65,114.02) v4(213.65,112.49) v4(213.65,110.21) v4(213.65,109.39) v4(214.18,198.27) v4(214.18,197.25) v4(214.18,196.24) v4(215.2,198.27) v4(215.2,197.25) v4(215.2,196.24)

# Allegro board Quanta ZRW REV F - BoardView (.BRD).brd (continued)
## Copper pours and planes (outline as drawn) (continued)
+3V on SVCC (solid shape): 210.91,93 210.91,49.62 212.79,47.74 212.79,43.51 212.5,43.23 210,43.23 209.26,43.97 209.26,45.57 208.43,46.4 206.96,46.4 206.03,45.47 206.03,38.46 204.17,36.6 201.26,36.6 200.44,37.42 200.44,46.64 197.25,49.83 195.64,49.83 188.51,42.7 188.51,40.36 187.85,39.71 182.89,39.71 182.89,33.27 113.08,33.27 105.96,40.38 82.43,40.38 78.62,36.57 69.39,36.57 61.56,44.4 61.56,45.51 61.77,45.72 121.04,45.72 122.73,44.02 122.81,43.94 165.91,43.94 171.54,49.57 171.54,52.49 172.26,53.21 207.23,53.21 207.23,61.34 198.97,61.34 198.97,53.21 172.26,53.21 172.38,53.34 187.24,53.34 188.81,54.9 188.81,69.38 192.87,73.45 192.87,83.82 206.46,83.82 206.46,87.88 201.26,87.88 201.26,83.82 192.87,83.82 192.87,93.58 193.62,94.1 209.81,94.1
+3V on IN1 (solid shape): 40.6,41.91 40.6,40.38 40.22,40 38.7,40 38.44,40.25 38.44,41.93 38.65,42.13 40.37,42.13
+3V on IN1 (solid shape): 82.58,25.84 82.58,24.99 80.9,23.31 77.95,23.31 77.76,23.49 77.76,24.25 78.76,25.25 79.77,25.25 79.78,25.2 79.79,25.15 79.82,25.09 79.84,25.05 79.88,25 79.92,24.97 79.97,24.94 80.02,24.91 80.07,24.9 80.13,24.89 80.18,24.89 80.24,24.9 80.29,24.91 80.34,24.94 80.39,24.97 80.43,25 80.47,25.05 80.5,25.09 80.52,25.15 80.53,25.2 80.54,25.25 80.54,25.31 80.53,25.37 80.51,25.42 80.48,25.47 80.45,25.51 80.41,25.55 80.37,25.59 80.32,25.62 80.27,25.64 80.21,25.65 80.16,25.65 80.1,25.65 80.05,25.64 79.99,25.62 79.94,25.59 79.9,25.55 79.86,25.51 79.83,25.47 79.8,25.42 79.79,25.37 79.78,25.31 79.77,25.25 78.76,25.25 79.4,25.9 79.4,25.9 79.51,26.01 82.41,26.01
+3V on IN1 (solid shape): outline of 309 points within 16.73,70.23 31.58,79.5
+3V on IN1 (solid shape): outline of 1707 points within 114.05,179.07 145.63,198.37
+3V on IN2 (solid shape): 26.89,101.98 26.89,101.47 26.5,101.09 25.11,101.09 24.73,101.47 24.73,102.23 25.11,102.61 26.25,102.61
+3V on IN2 (solid shape): 29.43,76.58 29.43,75.56 29.17,75.31 27.77,75.31 27.65,75.43 27.65,76.7 27.77,76.83 29.17,76.83
+3V on IN2 (solid shape): outline of 395 points within 162.65,98.8 171.79,109.95
+3V3_TPM on BOTTOM (solid shape): 215.4,47.35 215.4,46.14 215.28,46.02 214.52,46.02 214.35,45.86 211.96,45.86 211.96,45.54 211.66,45.23 210.96,45.23 210.84,45.35 210.84,45.78 211.01,45.95 211.38,45.95 211.61,46.18 211.61,46.3 212.05,46.75 212.05,46.86 212.84,46.86 213.19,47.21 213.19,48.03 213.43,48.26 214.49,48.26
+3V3_TPM on IN2 (solid shape): outline of 422 points within 213.32,46.6 218.4,60.32
+3V_CR on TOP (solid shape): 58.76,31.16 58.76,30.35 58.79,30.32 58.79,28.32 58.43,27.96 58.43,27.15 58.24,26.96 58.22,26.95 58.06,26.85 57.96,26.68 57.95,26.67 57.85,26.56 57.85,26.09 57.65,25.88 57.65,25.58 57.65,25.58 57.65,24.59 57.34,24.59 57.34,26.43 57.6,26.68 57.6,27 57.61,27.02 57.61,27.06 57.7,27.15 57.7,29.5 57.76,29.5 57.76,30.44 57.72,30.44 57.72,30.88 58.2,31.36 58.56,31.36
+3V_EC on TOP (solid shape): 210.27,42.77 210.27,42.76 210.42,42.61 210.42,41.01 210.19,40.78 209.62,40.78 209.56,40.84 209.56,41.76 209.08,42.24 208.09,42.24 207.91,42.06 207.91,41.47 208.19,41.19 208.52,41.19 208.67,41.04 208.67,40.4 208.39,40.13 206.46,40.13 206.34,40.25 206.34,40.64 206.39,40.69 206.87,40.69 206.97,40.79 206.97,42.41 207.5,42.94 210.11,42.94
+3V_GFX on TOP (solid shape): 179.18,26.51 179.18,25.6 178.85,25.27 178.02,25.27 177.56,25.73 177.56,26.56 177.79,26.79 178.9,26.79
+3V_GFX on TOP (solid shape): 211.57,142.74 211.57,141.75 210.53,140.71 210.53,137.92 210.27,137.66 208.83,137.66 208.65,137.84 208.65,138.25 207.96,138.93 207.96,139.44 208.06,139.54 208.32,139.54 208.76,139.98 208.76,140.69 208.36,141.09 208.34,141.2 208.29,141.3 208.29,142.72 208.47,142.9 211.42,142.9
+3V_GFX on TOP (solid shape): 74.39,17.01 74.71,16.82 75.03,17.01 75.97,17.01 77.55,15.43 77.55,14.81 77.36,14.62 72.02,14.62 71.81,14.83 71.81,16.79 72.03,17.01
+3V_GFX on TOP (solid shape): 188.15,155.01 188.15,154.65 188.18,154.06 188.75,153.9 188.77,153.91 188.96,153.72 188.94,153.69 188.92,153.44 189.01,153.21 189.01,152.94 188.97,152.5 189.3,152.19 189.7,151.79 189.7,150.08 190.18,149.6 190.84,149.6 190.97,149.47 190.97,147.44 190.89,147.37 189.95,147.37 189.95,148.71 189.04,149.63 189.04,151.41 188.2,152.24 188.2,153.13 187.52,153.82 187.31,154.02 187.31,154.39 187.32,154.39 187.32,154.94 187.49,155.11 188.05,155.11
+3V_GFX on TOP (solid shape): 176.59,152.65 176.59,151.28 176.36,151.05 176.36,148.87 174.84,147.34 174.84,146.63 174.69,146.48 174.18,146.48 173.7,146.96 173.7,149.35 174.93,149.35 174.93,149.29 174.94,149.24 174.96,149.19 174.99,149.14 175.02,149.1 175.06,149.06 175.11,149.03 175.15,149.01 175.2,148.99 175.26,148.98 175.31,148.98 175.37,148.98 175.42,149 175.47,149.02 175.51,149.05 175.55,149.08 175.59,149.12 175.62,149.17 175.64,149.22 175.66,149.27 175.67,149.32 175.67,149.37 175.66,149.43 175.64,149.48 175.62,149.53 175.59,149.57 175.55,149.61 175.51,149.65 175.47,149.68 175.42,149.7 175.37,149.71 175.31,149.72 175.26,149.72 175.2,149.71 175.15,149.69 175.11,149.66 175.06,149.63 175.02,149.59 174.99,149.55 174.96,149.5 174.94,149.45 174.93,149.4 174.93,149.35 173.7,149.35 173.7,149.73 173.95,149.98 173.95,150.87 174.42,151.34 175.34,151.34 175.38,151.35 175.45,151.37 175.5,151.4 175.56,151.44 175.61,151.48 175.65,151.53 175.69,151.58 175.72,151.64 175.74,151.7 175.76,151.76 175.76,151.83 175.76,151.89 175.75,151.96 175.73,152.02 175.71,152.08 175.67,152.13 175.65,152.16 175.65,152.6 175.96,152.9 176.34,152.9
+3V_GFX on TOP (solid shape): outline of 88 points within 171.41,137.08 200.42,143.68
+3V_GFX on BOTTOM (solid shape): 176.66,153.2 176.66,152 176.31,151.66 176.03,151.66 175.52,152.18 175.52,152.3 176.19,152.97 176.19,153.23 176.24,153.28 176.58,153.28
+3V_GFX on BOTTOM (solid shape): 188.4,155.7 188.4,155.52 188.28,155.39 188.17,155.39 188.11,155.33 188.1,155.07 188.23,154.83 188.23,154.74 188.08,154.43 188.16,154.1 188.3,154.1 188.44,153.96 188.44,153.75 188.25,153.56 187.9,153.56 187.4,154.06 187.39,154.08 187.39,154.31 187.4,154.33 187.4,154.36 187.62,154.58 187.62,154.62 187.63,154.63 187.63,155.6 187.63,155.62 187.87,155.86 188.24,155.86
+3V_GFX on IN1 (solid shape): 213.23,48.71 212.02,47.51 212.02,45.26 211.01,45.26 211.01,47.93 212.51,49.42
+3V_GFX on IN1 (solid shape): outline of 156 points within 198.21,139.19 210.27,141.6
+3V_GFX on IN1 (solid shape): outline of 567 points within 165.06,141.35 176.97,152.95
+3V_GFX on IN2 (solid shape): 211.62,28.82 211.62,27.63 211.52,27.53 209.56,27.53 208.75,28.34 208.75,29.05 208.9,29.21 211.24,29.21
+3V_GFX on IN2 (solid shape): 179.13,26.51 179.13,26.13 179.64,25.62 179.64,24.84 179.49,24.68 178.02,24.68 177.79,24.91 177.79,26.51 177.89,26.62 179.03,26.62
+3V_MAIN on TOP (solid shape): 210.58,144.47 211.57,144.47 211.67,144.37 211.67,143.63 211.54,143.51 206.72,143.51 206.46,143.76 206.46,145.21 206.84,145.59 209.46,145.59
+3V_MAIN on TOP (solid shape): outline of 159 points within 186.98,142.49 189.83,153.56
+3V_MAIN on BOTTOM (solid shape): 188.44,153.2 188.44,152.05 188.25,151.86 187.92,151.86 187.44,152.35 187.44,152.9 187.88,153.34 188.3,153.34
+3V_MAIN on BOTTOM (solid shape): 208.75,146.91 208.75,146.35 208.72,146.33 208.72,145.64 204.94,141.85 204.56,141.85 204.43,141.98 204.43,142.74 204.05,143.12 202.27,143.12 201.89,142.74 201.89,141.61 201.25,140.97 200.24,140.97 200.11,141.09 200.11,142.46 203.97,146.33 203.97,146.93 204.05,147.01 204.46,147.01 204.64,146.83 205.24,146.83 205.45,147.04 205.78,147.04 205.91,146.91 205.91,146.53 206.16,146.27 207.89,146.27 208.19,146.58 208.19,146.99 208.27,147.06 208.6,147.06
+3V_MAIN on IN1 (solid shape): outline of 265 points within 188.94,141.09 205.32,145.03
+3V_PCH_ME on BOTTOM (solid shape): outline of 249 points within 168.07,89.41 175.22,104.9
+3V_RTC on IN1 (solid shape): 164.11,92.25 164.11,91.77 163.88,91.54 163.88,90.41 163.82,90.3 163.69,90.29 163.32,90.27 163.14,89.94 163.11,89.85 163.02,89.81 162.53,89.81 162.34,90 162.34,91.66 162.41,91.77 162.54,91.76 162.99,91.76 163.13,92.2 163.14,92.31 163.25,92.36 163.99,92.36
+3V_S5 on TOP (solid shape): 169,75.81 169,74.93 168.74,74.67 167.98,74.67 167.09,75.56 167.09,76.07 167.47,76.45 168.36,76.45
+3V_S5 on TOP (solid shape): 197.18,84.79 197.18,83.67 197.05,83.54 195.52,83.54 195.37,83.69 195.37,84.76 195.52,84.91 197.06,84.91
+3V_S5 on TOP (solid shape): 211.34,67.74 211.34,65.88 211.26,65.81 210.27,65.81 210.15,65.93 210.15,67.61 210.4,67.86 211.21,67.86
+3V_S5 on TOP (solid shape): 188.71,109.24 188.71,108.28 188.63,108.2 187.9,108.2 187.53,108.57 187.53,109.95 187.55,109.98 187.97,109.98
+3V_S5 on TOP (solid shape): 195.49,102.74 195.49,100.68 195.34,100.53 194.65,100.53 194.48,100.71 194.48,102.74 194.58,102.84 195.39,102.84
+3V_S5 on TOP (solid shape): 159.6,138.32 159.6,137.29 159.87,137.03 159.87,135.96 159.56,135.96 159.43,136.09 159.43,136.77 159.39,136.81 159.39,136.82 158.15,138.06 158.15,139.09 158.33,139.26 158.66,139.26
+3V_S5 on TOP (solid shape): 46.67,97.18 46.67,95.37 46.55,95.25 43.35,95.25 43.01,94.92 43.01,93.98 42.89,93.85 41.25,93.85 41.11,93.99 41.11,96.24 42.43,97.56 46.29,97.56
+3V_S5 on TOP (solid shape): 175.18,77.35 175.18,76.51 177.53,76.51 178.02,76.02 178.02,75.33 177.88,75.19 175.29,75.19 174.18,76.3 173.92,76.3 173.81,76.4 173.81,77.35 173.87,77.41 175.12,77.41
+3V_S5 on TOP (solid shape): 197.31,91.99 197.31,91.22 196.33,90.24 196.33,89.49 196.24,89.39 195.2,89.39 195.18,89.43 195.03,89.6 194.81,89.64 194.71,89.68 194.67,89.77 194.67,90.03 194.82,90.19 194.93,90.19 195.84,91.1 195.84,92.07 196.06,92.29 197.01,92.29
+3V_S5 on TOP (solid shape): 166.82,92.95 167.61,92.95 169,91.57 169,91.56 169.38,91.18 169.38,89.66 168.45,88.73 167.51,88.73 166.8,88.01 166.8,87.84 166.71,87.75 165.82,87.75 164.93,88.64 164.93,89.32 166.29,90.67 167.83,90.67 167.98,90.82 167.98,91.45 167.25,92.19 166.94,92.19 166.45,91.69 165.32,91.69 164.98,92.03 164.98,92.62 165.48,93.12 165.5,93.12 165.58,93.15 165.64,93.21 166.56,93.21
+3V_S5 on TOP (solid shape): 179.69,110.65 179.69,108.78 179.39,108.48 174.53,108.48 174.21,108.8 173.2,108.8 173.01,108.99 173.01,108.99 172.97,109.02 172.56,109.02 172.23,108.69 171.87,108.69 171.86,108.68 170.65,108.68 169.56,109.78 169.56,110.31 169.62,110.37 170.31,110.37 170.56,110.12 170.56,109.74 171.5,109.74 171.92,110.16 174.1,110.16 174.37,109.89 176.94,109.89 177.13,109.7 178.27,109.7 178.47,109.9 178.47,110.23 178.02,110.68 177.92,111 177.6,111.1 177.53,111.17 177.53,111.81 177.76,112.04 178.31,112.04
+3V_S5 on TOP (solid shape): 169.17,119.5 169.24,119.43 169.34,119.38 169.38,119.37 169.38,118.74 169.25,118.61 168.49,118.61 168.33,118.45 168.33,117.1 168.47,116.96 169.13,116.96 169.28,116.8 169.28,116.48 169.17,116.37 168.65,116.37 168.58,116.43 168.16,116.43 167.92,116.19 167.92,115.06 168.58,114.4 168.58,113.88 168.44,113.74 167.53,113.74 167.47,113.79 167.47,114.17 167.35,114.3 167.3,114.3 167.29,114.31 167.09,114.36 166.89,114.3 166.59,114.3 166.46,114.42 166.46,115.06 166.62,115.22 166.93,115.22 166.93,115.53 166.97,115.57 166.97,116.35 167.03,116.42 167.03,117.01 167.31,117.29 167.36,117.29 167.37,117.3 167.38,117.3 167.48,117.41 167.58,117.51 167.58,117.52 167.59,117.53 167.58,117.67 167.58,119.27 167.81,119.5
+3V_S5 on BOTTOM (solid shape): 168.86,90.37 168.86,89.41 167.41,89.41 166.84,89.98 166.84,90.22 167.4,90.78 168.46,90.78
+3V_S5 on BOTTOM (solid shape): 197.77,92.41 197.77,90.16 197.64,90.03 196.53,90.03 196.37,90.19 196.37,92.45 196.52,92.6 197.58,92.6
+3V_S5 on BOTTOM (solid shape): 67.27,29 67.27,27.68 67.6,27.35 69.23,27.35 69.3,27.28 69.3,25.52 69.15,25.37 64.15,25.37 63.84,25.68 63.84,28.95 64.12,29.23 67.04,29.23
+3V_S5 on BOTTOM (solid shape): 182.64,113.61 182.64,112.57 182.33,112.26 179.95,112.26 179.57,111.88 179.57,111.76 178.63,110.82 178.12,110.82 177.97,110.97 177.97,111.25 177.74,111.48 177.74,112.37 179.16,113.79 180.91,113.79 181.42,114.3 181.95,114.3
+3V_S5 on BOTTOM (solid shape): 197.55,84.58 197.55,83.16 197.45,83.05 196.63,83.05 196.53,83.16 196.53,83.51 196.36,83.68 195.44,83.68 194.42,82.67 194.42,82.5 194.3,82.37 193.97,82.37 193.83,82.51 193.83,83.88 193.87,83.97 193.96,84.01 194.3,84.18 194.31,84.56 194.31,84.69 194.42,84.75 197.38,84.75
+3V_S5 on BOTTOM (solid shape): 171.67,126.87 171.67,125.73 171.03,125.09 169.51,125.09 169.38,124.96 169.38,124.05 169.21,123.88 168.43,123.88 168.28,123.73 167.43,123.73 167.05,123.91 166.76,123.59 166.66,123.48 166.66,123.36 166.64,123.33 166.61,123.31 165.79,123.31 165.15,123.95 164.3,123.95 164.17,124.07 164.17,124.91 164.32,125.06 164.32,125.53 164.52,125.73 165.63,125.73 166.03,125.33 166.03,124.86 166.36,124.53 167.06,124.53 167.15,124.62 167.88,124.62 167.94,124.55 168.6,124.32 168.25,124.92 168.12,125.04 168.12,125.36 168.74,125.98 170.01,125.98 170.52,125.47 170.78,125.47 171.11,125.8 171.11,126.36 170.8,126.67 170.8,127.02 170.88,127.1 171.44,127.1
+3V_S5 on SVCC (solid shape): 159.22,138.85 159.22,130.76 157.44,128.98 157.44,128.31 157.7,128.06 157.7,125.11 157.95,124.86 157.95,123.97 160.64,121.28 168,121.28 169,120.29 169,117.06 170.52,115.54 170.52,110.66 170.6,110.58 170.6,109.4 170.39,109.19 170.15,109.19 169.61,109.72 165.17,109.72 164.93,109.96 164.93,110.13 165.23,110.43 165.74,110.43 166.46,111.14 166.46,115.42 165.68,116.2 164.32,116.2 163.66,115.54 163.66,112.62 163.4,112.36 163.08,112.36 162.98,112.47 159.81,115.57 156.51,115.57 155.66,116.41 155.66,132.88 156.55,133.77 156.55,138.85 157.02,139.31 158.76,139.31
+3V_S5 on IN1 (solid shape): 195.59,102.51 195.59,100.4 195.39,100.2 194.48,100.2 194.37,100.3 194.37,102.48 194.53,102.64 195.47,102.64
+3V_S5 on IN1 (solid shape): 198.18,93.85 198.18,91.31 198.06,91.18 196.84,91.18 196.68,91.33 196.68,93.82 196.86,94 198.03,94
+3V_S5 on IN1 (solid shape): 207.66,23.95 207.66,23.49 208.34,22.81 208.34,22.4 208.01,22.07 207.61,22.07 206.39,23.29 206.39,23.87 206.64,24.13 207.48,24.13
+3V_S5 on IN1 (solid shape): 186.11,110.95 186.85,110.95 188.33,109.47 188.33,108.73 188.2,108.61 187.34,108.61 186.37,109.57 186.37,109.77 186.13,110.02 186.04,110.13 185.93,110.22 185.74,110.41 184.98,110.41 183.3,112.09 182.91,112.09 181.6,113.4 181.6,114.03 181.82,114.25 182.81,114.25
+3V_S5 on IN1 (solid shape): outline of 445 points within 44.41,27.22 66.38,97.15
+3V_S5 on IN2 (solid shape): 52.49,83.03 52.49,80.77 52.18,80.46 51.57,80.46 50.69,81.35 50.69,83.16 50.76,83.23 52.29,83.23
+3V_S5 on IN2 (solid shape): 207.68,24.94 207.68,23.26 207.58,23.16 206.54,23.16 206.39,23.31 206.39,24.89 206.59,25.09 207.53,25.09
+3V_S5 on IN2 (solid shape): 211.11,67.66 211.11,66.59 210.86,66.34 209.05,66.34 208.93,66.47 208.93,67.66 209.13,67.86 210.91,67.86
+3V_S5 on IN2 (solid shape): 177.32,75.12 177.32,73.73 176.97,73.39 176.94,73.4 176.53,73.19 176.61,72.75 176.61,72.34 176.49,72.22 175.62,72.22 175.45,72.39 175.45,76.43 175.58,76.56 175.88,76.56
+3VPCU on TOP (solid shape): 79.12,19.49 79.12,16.93 78.63,16.44 77.43,16.44 77.28,16.59 77.28,18.32 77.44,18.47 77.74,18.47 77.95,18.69 77.95,19.43 78.13,19.61 79,19.61
+3VPCU on TOP (solid shape): outline of 497 points within 94.32,27.43 190.31,55.11
+3VPCU on BOTTOM (solid shape): 190.12,61.65 190.32,61.65 190.32,62.65 190.62,62.65 190.62,61.21 190.62,61.21 190.62,55.78 186.52,51.68 185.64,51.68 185.38,51.94 185.38,57.91 185.64,58.16 187.41,58.16 187.82,58.57 187.82,60.72 189.74,62.65 190.12,62.65
+3VPCU on BOTTOM (solid shape): outline of 257 points within 70.86,25.06 92.83,43.4
+3VPCU on BOTTOM (solid shape): outline of 324 points within 56.98,6.35 69.81,12.19
+3VPCU on IN2 (solid shape): outline of 238 points within 193.37,23.11 198.87,28.82
+3VPCU on IN2 (solid shape): outline of 888 points within 67.91,35.13 96.99,46.48
+3VPCU_EC on TOP (solid shape): 209.26,35.3 209.26,34.79 209.64,34.41 209.64,34.16 209.26,33.78 209.26,33.27 209.13,33.14 208.5,33.14 208.24,33.4 208.24,35.3 208.37,35.43 209.13,35.43
+3VPCU_EC on TOP (solid shape): 200.11,49.27 200.11,48.76 200.01,48.66 199.78,48.66 198.84,47.72 198.84,47.67 198.79,47.62 198.59,47.62 198.21,47.24 197.32,47.24 197.07,47.49 197.07,48.26 197.46,48.26 197.46,48.2 197.47,48.15 197.49,48.1 197.52,48.05 197.55,48.01 197.59,47.97 197.64,47.94 197.68,47.92 197.73,47.9 197.79,47.89 197.84,47.89 197.9,47.89 197.95,47.91 198,47.93 198.04,47.96 198.08,47.99 198.12,48.03 198.15,48.08 198.17,48.12 198.19,48.18 198.2,48.23 198.2,48.28 198.19,48.34 198.17,48.39 198.15,48.44 198.12,48.48 198.08,48.52 198.04,48.56 198,48.58 197.95,48.61 197.9,48.62 197.84,48.63 197.79,48.62 197.73,48.61 197.68,48.6 197.64,48.57 197.59,48.54 197.55,48.5 197.52,48.46 197.49,48.41 197.47,48.36 197.46,48.31 197.46,48.26 197.07,48.26 197.07,49.14 197.57,49.65 199.73,49.65
+3VPCU_EC on BOTTOM (solid shape): 208.24,50.29 208.24,49.4 208.11,49.27 207.48,49.27 207.35,49.4 207.35,50.29 207.48,50.41 208.11,50.41
+3VPCU_ECPLL on BOTTOM (solid shape): 207.99,48.89 207.99,48.38 206.08,46.48 205.83,46.48 205.7,46.6 205.7,47.11 206.34,47.75 206.34,48.89 206.46,49.02 207.86,49.02
+5V on TOP (solid shape): 222.34,50.67 222.34,48.64 222.08,48.38 220.43,48.38 220.18,48.64 220.18,50.67 220.43,50.92 222.08,50.92
+5V on TOP (solid shape): 214.46,134.31 214.46,131.62 214.31,131.47 214.06,131.47 213.8,131.21 213.8,130.09 213.75,130.04 212.74,130.04 212.59,130.2 212.59,131.42 212.74,131.57 212.74,132.38 212.99,132.63 212.99,134.01 213.4,134.41 214.36,134.41
+5V on TOP (solid shape): 22.69,116.2 22.69,115.11 22.82,114.98 22.82,113.99 22.75,113.91 21.25,113.91 20.92,114.25 18.66,114.25 17.87,113.46 17.36,113.46 17.34,113.48 15.99,113.48 15,112.49 15,111.96 14.62,111.58 13.65,111.58 13.42,111.8 13.42,111.86 13.44,111.96 13.42,112.06 13.42,113.24 13.42,113.25 13.58,113.41 14.67,113.41 15.9,114.63 17.04,114.63 19.11,116.71 22.19,116.71
+5V on TOP (solid shape): 53.81,50.84 53.81,49.41 53.38,48.98 49.15,48.98 48.69,49.1 48.5,48.66 47.21,47.37 47.21,44.09 51.02,40.28 51.02,33.4 49.24,31.62 49.24,31.36 49.25,31.35 49.25,31.1 49.01,30.86 48.73,30.86 48.6,30.73 48.6,28.49 47.89,27.77 46.25,27.77 46.25,28.48 47.38,28.48 47.38,29.62 47.32,29.67 45.98,29.67 45.68,29.97 45.68,32.97 46.16,33.45 48.32,33.45 49.52,34.64 49.52,38.83 45.74,42.61 45.74,49.06 43.04,51.76 37.71,51.76 37.45,51.51 35.57,51.51 34.35,50.29 34.05,50.29 33.85,50.49 33.85,50.82 33.64,51.02 33.64,52.27 35.85,54.48 50.18,54.48
+5V on TOP (solid shape): outline of 120 points within 134.71,187.57 138.77,190.37
+5V on BOTTOM (solid shape): 84.91,30.06 84.91,29.15 84.49,28.73 84.07,28.73 83.41,28.08 82.39,28.08 81.86,27.55 80.64,27.55 80.49,27.7 80.49,29.21 81.54,30.26 84.71,30.26
+5V on BOTTOM (solid shape): 223.23,97.79 223.23,96.13 222.97,95.88 221.45,95.88 220.81,95.25 217.64,95.25 217,95.88 217,97.15 220.94,97.15 220.94,97.66 219.93,97.66 219.93,97.15 218.53,97.15 218.53,97.66 217.51,97.66 217.51,97.15 217,97.15 217,97.79 217.39,98.17 222.85,98.17
+5V on BOTTOM (solid shape): outline of 269 points within 213.7,48.49 225.39,73.4
+5V on SVCC (solid shape): outline of 164 points within 52.67,14.52 224.83,97.79
+5V on IN1 (solid shape): 216.54,133.76 216.54,131.53 216.13,131.12 215.73,131.52 214.06,131.52 213.7,131.87 213.7,132.74 213.96,132.99 215.07,132.99 216.04,133.96 216.34,133.96
+5V on IN1 (solid shape): 220.31,97.91 220.31,96.01 219.93,95.63 218.27,95.63 217.77,96.13 217.77,96.64 218.15,97.02 218.4,97.28 218.4,98.17 220.05,98.17
+5V on IN1 (solid shape): 148.49,195.87 148.49,193.96 148.33,193.8 147.25,193.8 147.11,193.95 147.11,195.52 147.22,195.73 147.2,195.96 147.3,196.07 148.29,196.07
+5V on IN1 (solid shape): outline of 214 points within 198.56,188.34 211.04,192.21
+5V on IN2 (solid shape): outline of 666 points within 135.72,187.83 148.44,196.46
+5V on IN2 (solid shape): outline of 900 points within 208.88,68.07 220.56,96.45
+5V_HDD on TOP (solid shape): 229.2,56.26 229.2,52.95 228.94,52.7 225.89,52.7 224.88,51.68 220.43,51.68 220.18,51.94 220.18,55.49 220.69,56 228.05,56 228.43,56.38 229.07,56.38
+5V_KB on TOP (solid shape): 214.16,137.51 214.16,136.75 213.6,136.19 213.6,134.97 213.25,134.62 211.37,134.62 210.96,135.02 210.96,137.21 211.16,137.4 211.78,137.4 211.78,137.41 213.19,137.41 213.4,137.61 214.06,137.61
+5V_KB_R on TOP (solid shape): 211.8,139.37 211.8,137.87 211.6,137.67 211.06,137.67 210.96,137.77 210.96,139.49 211.11,139.65 211.52,139.65
+5V_KB_R on BOTTOM (solid shape): 211.04,139.7 211.32,139.7 211.47,139.54 211.47,138.25 211.22,138 207.3,138 207.3,138.5 208.7,138.5 208.8,138.61 208.8,139.89 208.7,140 207.3,140 207.3,140.5 210.23,140.5
+5V_ODD on BOTTOM (solid shape): 226.53,101.85 226.53,100.33 226.28,100.07 225.64,100.07 225.13,99.56 225.13,98.67 224.88,98.42 221.2,98.42 221.07,98.55 220.18,98.55 219.93,98.8 219.93,101.09 220.81,101.98 226.4,101.98
+5V_PVDD on TOP (solid shape): 45.81,36.57 45.81,35.56 45.17,34.92 42.71,34.92 42.35,34.57 40.75,34.57 40.47,34.29 39.13,34.29 38.93,34.49 38.93,35.48 38.7,35.71 37.83,35.71 37.76,35.78 37.76,36.04 37.55,36.24 37.12,36.24 36.89,36.01 36.89,35.73 36.36,35.2 35.21,35.2 35.21,35.41 36.29,35.41 36.72,35.84 36.72,36.36 36.94,36.59 37.2,36.59 37.3,36.69 37.8,36.69 37.81,36.7 45.68,36.7
+5V_S5 on TOP (solid shape): 28.93,60.9 29.4,60.9 29.45,60.96 29.46,60.96 29.53,60.93 29.56,60.87 29.56,60.82 29.94,60.44 30.32,60.82 30.32,60.87 30.36,60.93 30.42,60.96 30.96,60.96 31.1,60.82 31.57,60.82 31.7,60.96 32.89,60.96 32.9,60.91 33.26,60.59 33.63,60.91 33.63,60.96 38.57,60.96 38.82,60.7 38.82,57.7 38.52,57.4 32.85,57.4 32.6,57.65 32.21,57.65 32.21,57.7 31.86,58.02 31.48,57.74 31.47,57.7 25,57.7 24.06,57.7 24.06,56.48 23.71,56.13 22.31,56.13 22.06,56.38 22.06,57.12 22.06,57.13 22.27,58.16 22.25,59.22 22.25,59.24 22.44,59.43 23.33,59.43 23.71,59.81 25.49,59.81 25.5,59.82 25.52,59.83 25.75,59.93 25.86,60.16 25.86,60.18 26,60.32 26.02,60.32 26.15,60.35 26.27,60.43 26.76,60.92 26.79,60.96 28.87,60.96
+5V_S5 on TOP (solid shape): outline of 193 points within 70.96,34.81 83.36,58.63
+5V_S5 on BOTTOM (solid shape): 81.47,36.6 81.47,35.89 81.31,35.73 80.2,35.73 79.98,35.51 79.98,33.97 79.85,33.84 77.8,33.84 77.67,33.96 77.67,36.08 78.41,36.82 81.25,36.82
+5V_S5 on BOTTOM (solid shape): 212.31,30.35 212.31,26.67 212.18,26.54 210.99,26.54 210.4,27.12 210.4,29.08 210.05,29.43 209.41,29.43 209.21,29.64 209.21,30.58 209.31,30.68 210.02,30.68 210.02,30.69 211.97,30.69
+5V_S5 on BOTTOM (solid shape): outline of 223 points within 34.22,57.6 73.93,70.72
+5V_S5 on SVCC (solid shape): outline of 87 points within 72.22,24.33 212.66,39.37
+5V_S5 on IN1 (solid shape): 210.96,31.87 210.96,31.68 210.68,31.3 211,30.94 211.05,30.93 211.05,29.55 210.96,29.46 209.38,29.46 209.23,29.61 209.23,30.58 209.59,30.93 209.59,31.92 209.64,31.98 210.85,31.98
+5VA on TOP (solid shape): 45.07,32.43 45.07,29.88 44.86,29.67 43.69,29.67 42.63,30.73 42.38,30.73 42.28,30.83 42.28,32.15 42.76,32.63 44.87,32.63
+5VA on TOP (solid shape): 30.9,30.17 29.68,28.95 28.77,28.95 28.54,28.72 28.54,28.23 27.88,27.58 27.88,27.54 27.52,27.17 26.89,27.17 26.63,27.43 26.63,28.77 28.03,30.17 30.62,30.17 30.7,30.25 30.7,31.3 30.9,31.3
+5VA on IN1 (solid shape): outline of 336 points within 29.12,27.17 43.65,32
+5VODD on BOTTOM (solid shape): 230.56,110.37 232.23,110.37 232.37,110.22 232.37,108.71 232.24,108.58 231.48,108.58 231.23,108.33 231.23,101.6 230.09,100.45 227.42,100.45 227.16,100.71 227.16,104.52 227.93,105.28 227.93,110.36 228.05,110.49 230.44,110.49
+5VPCU on TOP (solid shape): 24.6,39.49 24.35,39.24 21.88,39.24 21.77,39.35 21.77,40.8 22.8,40.8 23.22,40.38 23.58,40.38 24.02,40.81 24.6,40.81
+5VPCU on TOP (solid shape): 29.5,45.54 29.5,43.38 29.43,43.3 26.96,43.3 26.89,43.38 26.89,45.18 27.01,45.31 28.11,45.31 28.42,45.63 28.5,45.64 29.4,45.64
+5VPCU on TOP (solid shape): outline of 437 points within 47.61,25.17 83.63,46.79
+5VPCU on BOTTOM (solid shape): 80.02,114.55 80.02,113.91 79.77,113.66 78.63,113.66 78.1,113.13 77.01,113.13 77.01,113.41 77.85,113.41 77.87,113.41 79.13,114.68 79.9,114.68
+5VPCU on BOTTOM (solid shape): 70.46,38.87 70.46,37.78 72.41,35.83 77.32,35.83 77.51,35.64 77.51,33.6 77.9,33.21 80.26,33.21 80.26,33.22 80.72,33.22 81.97,34.47 83.52,34.47 83.76,34.23 83.76,32.89 79.87,29 79.87,27.02 79.76,26.91 77.89,26.91 75.18,29.63 75.18,29.64 73.18,31.63 68.97,31.63 68.67,31.78 68.37,31.63 65.72,31.63 63.53,33.83 63.53,33.89 62.28,33.89 61.98,33.59 60.36,33.59 59.41,32.64 57.03,32.64 56.79,32.88 56.79,36.81 57.19,37.21 60.09,37.21 61.82,38.93 70.4,38.93
+5VPCU on BOTTOM (solid shape): outline of 146 points within 27.47,43.07 49.48,47.77
+5VPCU on IN1 (solid shape): 87.59,33.88 87.82,33.8 88.05,33.88 88.14,33.88 88.35,33.67 88.35,32.17 88.13,31.95 81.56,31.95 81.38,32.13 81.38,33.66 81.6,33.88
+5VPCU on IN1 (solid shape): outline of 328 points within 22.29,39.24 29.81,46.17
+15V on TOP (solid shape): 53.81,63.88 53.81,62.61 53.68,62.48 52.03,62.48 51.78,62.73 51.78,63.75 52.16,64.13 53.56,64.13
+A3VPCU on TOP (solid shape): 196.05,36.95 196.68,36.95 196.81,37.08 197.19,37.08 197.32,36.95 197.32,36.44 197.07,36.19 195.29,36.19 194.4,35.3 194.27,35.3 194.02,35.56 194.02,36.7 194.53,37.21 195.8,37.21
+VCCCORE on TOP (solid shape): outline of 1871 points within 127.9,114.17 149.06,157.23
+VCCCORE on BOTTOM (solid shape): outline of 675 points within 133.84,113.92 138.77,117.07
+VCCCORE on BOTTOM (solid shape): outline of 1682 points within 132.03,124.55 152.62,156.93
+VCCCORE on SVCC (solid shape): 147.92,157.77 147.92,138.89 139.28,130.25 139.28,114.97 139.38,114.88 138.29,113.79 134.76,113.79 134.66,113.89 134.66,115.09 134.33,115.42 134.33,117.22 133.95,117.6 126.69,117.6 125.92,118.36 127.25,118.36 128.23,119.34 128.23,124.12 128.74,124.63 128.74,132.37 130.64,134.28 130.64,136.39 132.55,136.39 132.55,140.2 130.64,140.2 130.64,151.17 132.04,152.57 132.04,156.8 131.17,157.67 131.17,158.41 131.89,159.25 146.55,159.25
+VCCCORE on IN1 (solid shape): outline of 879 points within 126.89,114.12 138.37,126.03
+VCCEOPIO on BOTTOM (solid shape): 92.77,102.61 92.77,94.46 90.26,91.94 67.35,91.94 66.69,92.6 65.95,92.6 65.8,92.76 65.8,94.69 65.9,94.78 68.05,94.78 68.31,95.04 86.04,95.04 87.26,96.26 87.26,102.41 87.59,102.74 92.65,102.74
+VCCEOPIO on BOTTOM (solid shape): 122.73,118.49 122.77,118.47 122.78,118.44 122.78,117.07 123.86,117.07 123.9,117.06 123.91,117.02 123.91,116.96 123.28,116.33 122.68,116.33 122.65,116.34 122.65,116.36 122.39,116.54 122.09,116.44 122.06,116.43 122.02,116.44 121.63,116.84 121.63,117.33 121.66,117.37 121.66,117.6 121.63,117.63 121.63,118.11 121.75,118.23 122.01,118.23 122.26,118.49
+VCCEOPIO on IN1 (solid shape): 96.23,101.85 94.07,99.69 89.5,99.69 88.99,100.2 88.99,102.46 89.27,102.74 96.23,102.74
+VCCEOPIO on IN1 (solid shape): outline of 2439 points within 100.29,109.72 124.42,121.25
+VCCGT on TOP (solid shape): outline of 10026 points within 102.96,96.13 131.71,151.6
+VCCGT on BOTTOM (solid shape): outline of 97 points within 120.1,144.14 139.53,157.35
+VCCGT on BOTTOM (solid shape): 122.53,126.94 122.59,126.92 122.65,126.9 122.69,126.9 122.76,126.91 122.81,126.87 122.81,126.85 123.02,126.67 123.27,126.78 123.28,126.8 123.39,126.86 123.45,126.84 123.5,126.78 123.45,126.72 123.29,126.6 123.25,126.4 123.22,126.29 123.11,126.25 123.06,126.26 123.01,126.25 122.9,126.29 122.86,126.4 122.58,126.72 122.35,126.37 122.23,126.25 122.14,126.26 122.06,126.25 122.03,126.24 121.98,126.27 121.98,126.28 121.89,126.4 121.77,126.47 121.71,126.52 121.7,126.6 121.78,126.68 122.07,126.68 122.07,126.68 122.28,126.71 122.4,126.88 122.4,126.9 122.45,126.95 122.51,126.95
+VCCGT on BOTTOM (solid shape): outline of 811 points within 122.88,114.22 133.18,117.07
+VCCGT on BOTTOM (solid shape): outline of 1334 points within 106.39,117.85 131.79,127.25
+VCCGT on SVCC (solid shape): 129.63,157.77 129.65,157.74 129.74,157.66 129.78,157.61 131.03,156.38 131.03,152.99 129.63,151.59 129.63,140.2 128.36,140.2 128.36,136.39 129.63,136.39 129.63,134.7 127.72,132.79 127.72,125.05 127.22,124.54 127.22,119.76 126.83,119.38 123.49,119.38 121.64,121.23 104.76,121.23 104.76,122.43 104.77,122.43 104.76,122.46 104.76,123.22 104.74,123.24 104.74,124.93 104.76,125.11 104.74,125.14 104.74,130.34 117.18,142.79 117.18,157.77 118.66,159.25 128.26,159.25
+VCCGT on IN1 (solid shape): 127.83,125.75 127.83,120.42 126.99,119.58 124.7,119.58 123.15,121.13 123.15,126.23 123.66,126.74 126.83,126.74
+VCCGT on IN1 (solid shape): outline of 241 points within 121.95,143.51 131.15,158.11
+VCCHDA on IN1 (solid shape): outline of 638 points within 140.93,105.91 146.14,116.33
+VCCIO on TOP (solid shape): 179.54,78.35 179.54,76.96 179.41,76.83 178.47,76.83 177.89,77.42 177.89,78.35 178.14,78.61 179.29,78.61
+VCCIO on TOP (solid shape): 215.35,93.98 215.35,92.71 215.1,92.45 213.7,92.45 213.45,92.71 213.45,94.1 213.7,94.36 214.97,94.36
+VCCIO on TOP (solid shape): 132.79,117.59 132.79,116.7 132.68,116.58 132.04,116.58 131.03,117.6 131.03,117.85 131.13,117.95 132.42,117.95
+VCCIO on TOP (solid shape): 152.53,136.36 152.53,135.16 152.29,134.92 151.23,134.92 150.65,134.34 150.23,134.34 150.05,134.16 150.05,133.7 149.92,133.57 149.19,133.57 149.01,133.75 149.01,134.39 149.69,135.07 149.69,135.48 150.81,136.6 152.29,136.6
+VCCIO on TOP (solid shape): outline of 132 points within 138.78,114.04 141.74,116.71
+VCCIO on BOTTOM (solid shape): 179.67,78.22 179.67,76.2 179.54,76.07 178.27,76.07 178.07,76.27 178.07,78.54 178.14,78.61 179.28,78.61
+VCCIO on BOTTOM (solid shape): 104.36,122.42 104.36,117.6 103.97,117.22 100.55,117.22 100.16,117.6 100.16,117.98 99.94,118.21 99.2,118.21 99.2,121.46 99.45,121.71 101.43,121.71 102.4,122.68 104.1,122.68
+VCCIO on BOTTOM (solid shape): 140.57,115.7 140.6,115.65 140.6,114.63 140.09,114.12 139.87,114.12 139.59,114.4 139.46,114.4 139.18,114.12 138.9,114.12 138.85,114.17 138.85,114.57 139.33,115.05 139.33,115.64 139.38,115.72 139.41,115.77 139.73,116.09 139.8,116.12 140.14,116.12
+VCCIO on IN1 (solid shape): 215.86,93.88 215.86,92.96 215.48,92.58 214.34,92.58 214.21,92.71 214.21,93.3 215.01,94.1 215.64,94.1
+VCCIO on IN1 (solid shape): 151.07,135.15 151.07,134.62 150.94,134.49 150.35,134.49 149.97,134.12 149.97,133.35 149.76,133.14 148.86,133.14 148.51,132.8 146.3,132.8 145.94,133.17 145.94,134.44 146.1,134.6 148.2,134.6 148.2,134.55 148.22,134.49 148.24,134.44 148.27,134.39 148.3,134.35 148.34,134.31 148.39,134.28 148.44,134.26 148.49,134.24 148.55,134.23 148.61,134.23 148.66,134.24 148.71,134.26 148.76,134.28 148.81,134.31 148.85,134.35 148.89,134.39 148.92,134.44 148.94,134.49 148.95,134.55 148.96,134.6 148.96,134.66 148.95,134.71 148.93,134.77 148.9,134.82 148.87,134.86 148.83,134.9 148.79,134.93 148.74,134.96 148.69,134.98 148.63,134.99 148.58,135 148.52,134.99 148.47,134.98 148.42,134.96 148.37,134.93 148.32,134.9 148.28,134.86 148.25,134.82 148.23,134.77 148.21,134.71 148.2,134.66 148.2,134.6 146.1,134.6 146.75,135.25 150.96,135.25
+VCCIO on IN1 (solid shape): outline of 435 points within 137.12,114.12 141.44,130.88
+VCCIO on IN2 (solid shape): outline of 2839 points within 102.2,114.8 141.31,126.77
+VCCOPC on BOTTOM (solid shape): 68.36,97.1 68.36,95.4 68.11,95.14 65.95,95.14 65.8,95.3 65.8,97.23 65.9,97.32 68.14,97.32
+VCCOPC on BOTTOM (solid shape): 108.17,130.81 108.17,129.54 108.42,129.28 108.42,127.63 108.29,127.5 105.75,127.5 105.63,127.63 105.63,131.06 105.75,131.19 107.78,131.19
+VCCOPC on BOTTOM (solid shape): 122.77,123.62 122.77,120.44 121.93,119.61 121.77,119.61 121.69,119.69 121.69,119.84 122.26,120.42 122.26,121.28 122.11,121.43 121.78,121.43 121.69,121.53 121.69,121.66 121.79,121.76 121.95,121.76 122.26,122.08 122.26,123.06 122.06,123.26 121.79,123.26 121.69,123.35 121.69,123.51 121.83,123.64 122.75,123.64
+VCCOPC on IN1 (solid shape): 85.81,106.17 85.81,100.67 80.34,95.2 67.07,95.2 66.76,95.5 66.76,96.9 67.02,97.15 67.91,97.15 69.56,98.8 73.03,98.8 77.59,103.36 84.29,103.36 84.29,103.3 84.31,103.25 84.33,103.2 84.36,103.15 84.4,103.11 84.44,103.07 84.48,103.04 84.53,103.02 84.59,103 84.64,102.99 84.7,102.99 84.75,103 84.81,103.02 84.86,103.04 84.9,103.07 84.95,103.11 84.98,103.15 85.01,103.2 85.03,103.25 85.05,103.3 85.05,103.36 85.05,103.42 85.04,103.47 85.02,103.52 85,103.57 84.96,103.62 84.93,103.66 84.88,103.69 84.83,103.72 84.78,103.74 84.73,103.75 84.67,103.76 84.62,103.75 84.56,103.74 84.51,103.72 84.46,103.69 84.42,103.66 84.38,103.62 84.34,103.57 84.32,103.52 84.3,103.47 84.29,103.42 84.29,103.36 77.59,103.36 81.66,107.44 84.54,107.44
+VCCOPC on IN1 (solid shape): outline of 662 points within 105.75,121.05 123.02,128.94
+VCCOPC_SW on BOTTOM (solid shape): 65.15,82.87 65.15,80.98 63.73,79.57 60.04,79.57 59.93,79.68 59.93,80.53 59.33,81.12 59.33,82.38 58.93,82.79 58.93,82.8 58.21,82.8 57.47,82.8 57.43,82.81 57.42,82.85 57.42,83.01 57.43,83.04 57.47,83.06 58.21,83.06 58.21,83.05 58.93,83.05 58.93,83.06 59.07,83.21 64.81,83.21
+VCCOPC_VBST on BOTTOM (solid shape): 59.18,82.3 59.18,80.96 59.68,80.47 59.68,79.58 59.61,79.51 58.81,79.51 58.65,79.67 58.65,81.87 58.61,81.9 58.61,81.95 58.57,81.95 58.21,82.3 58.21,82.5 58.23,82.54 58.27,82.55 58.93,82.55
+VCCOPC_VIN on TOP (solid shape): 55.88,82.62 55.88,81.02 55.62,80.76 55.59,80.76 55.47,80.74 55.36,80.68 52.54,80.68 52.19,81.03 52.19,82.53 52.53,82.87 55.63,82.87
+VCCOPC_VIN on BOTTOM (solid shape): 56.32,82.55 57.77,82.55 57.81,82.54 57.82,82.5 57.82,82.19 57.63,82 56.56,82 56.29,81.74 56.29,81.41 56.12,81.23 55.91,81.13 55.81,80.92 55.65,80.77 55.64,80.76 55.61,80.75 55.33,80.65 55.22,80.36 55.22,80.34 55.21,80.32 54.92,80.04 54.92,79.22 54.81,79.05 54.81,78.84 54.65,78.68 54.65,77.78 54.88,77.56 54.89,77.56 54.92,77.53 54.92,77.06 54.6,76.74 54.6,76.22 54.79,75.9 55.16,75.9 55.61,75.9 55.65,75.88 55.92,75.7 56.22,75.8 56.29,75.83 56.36,75.8 56.58,75.58 56.58,74.59 56.57,74.55 56.53,74.54 52.79,74.54 52.15,75.17 52.15,76.14 52.32,76.45 52.15,76.76 52.15,82.42 52.57,82.84 56.03,82.84
+VCCPDSW_3P3 on IN2 (solid shape): outline of 399 points within 146.39,113.41 156.27,120.77
+VCCPGPPG on TOP (solid shape): 167.46,118.38 167.46,117.67 167.47,117.57 167.46,117.56 167.4,117.49 167.33,117.42 167.32,117.41 167.26,117.41 167.21,117.36 166.75,117.36 166.75,116.53 166.67,116.45 165.76,116.45 165.75,116.49 165.71,116.6 165.63,116.68 165.63,117.66 165.79,117.81 166.33,117.81 166.51,117.99 166.51,118.4 166.64,118.53 167.31,118.53
+VCCPGPPG on IN1 (solid shape): outline of 84 points within 148.04,117.41 150.2,118.87
+VCCPLL on BOTTOM (solid shape): 150.41,136.19 150.41,135.17 150.23,135 150.23,134.74 150.74,134.23 150.74,133.8 150.56,133.63 150.36,133.63 150.15,133.83 150.15,133.98 149.69,134.44 149.69,135.02 149.39,135.33 149.39,136.51 150.09,136.51
+VCCPLL on BOTTOM (solid shape): 145.63,125.57 145.63,125.42 145.6,125.4 145.55,125.37 145.51,125.34 145.42,125.3 145.34,125.33 144.94,125.37 144.75,125.01 144.76,124.99 144.71,124.93 144.69,124.92 144.6,124.86 144.53,124.77 144.53,124.76 144.34,124.57 144.32,124.56 142.99,124.56 142.86,124.68 142.86,125.04 143.14,125.32 143.98,125.32 144.17,125.51 144.31,125.51 144.56,125.76 145.45,125.76
+VCCPLL on IN1 (solid shape): outline of 147 points within 141.14,126.84 143.83,130.09
+VCCPRIM_3P3 on IN1 (solid shape): 165.78,120.06 165.82,120.06 165.87,120.06 166.54,120.06 166.6,120 166.67,120 167.09,119.57 167.09,118.99 166.71,118.61 166.41,118.61 166.3,118.67 166.29,118.78 165.93,119.29 165.56,118.78 165.55,118.67 165.44,118.61 164.9,118.61 164.4,119.11 163.48,119.11 163.18,118.81 160.27,118.81 160.15,118.87 160.16,119 160.07,119.49 159.58,119.49 159.5,119.46 159.42,119.48 159.02,119.51 158.81,119.16 158.78,119.07 158.69,119.03 158.46,119.03 158.46,119.09 158.21,119.4 157.81,119.32 157.8,119.31 157.76,119.29 157.71,119.31 157.71,119.32 157.25,119.38 157.07,118.96 157.04,118.86 156.95,118.81 156.6,118.81 156.44,118.96 156.44,119.87 156.63,120.06
+VCCPRIM_3P3 on IN1 (solid shape): outline of 508 points within 145.5,117.6 154.68,122.55
+VCCPRTCPRIM_3P3 on TOP (solid shape): 169.35,96.12 169.35,94.35 169.3,94.34 169.06,94.16 169.03,93.87 168.94,93.77 168.68,93.77 168.16,94.29 167.04,94.29 166.93,94.4 166.93,95.16 167.1,95.33 167.31,95.33 167.32,95.33 167.73,95.33 167.83,95.23 167.83,94.76 167.85,94.75 167.85,94.73 167.91,94.61 168.03,94.55 168.05,94.55 168.36,94.55 168.38,94.55 168.49,94.61 168.55,94.73 168.56,94.75 168.57,94.76 168.57,96 168.78,96.21 169.27,96.21
+VCCPRTCPRIM_3P3 on IN2 (solid shape): outline of 935 points within 147.15,106.04 157.7,118.14
+VCCSA on TOP (solid shape): outline of 641 points within 140.14,114.8 156.68,153.28
+VCCSA on BOTTOM (solid shape): 157.03,156.03 157.03,156.03 157.03,154.49 157.05,154.47 157.05,154.3 157.58,154.3 157.58,154.47 157.6,154.49 157.6,156.04 157.81,156.25 158.92,156.25 159.15,156.02 159.15,153.08 158.49,152.43 157.8,152.43 157.7,152.32 157.7,147.32 157.58,147.2 153.5,147.2 152.74,147.96 152.74,152.9 153.12,153.28 153.12,154.05 153.1,154.07 153.1,155.71 153.65,156.25 156.81,156.25
+VCCSA on BOTTOM (solid shape): outline of 84 points within 141.31,115.18 143.43,117.07
+VCCSA on BOTTOM (solid shape): outline of 525 points within 139.42,124.54 143.72,127.44
+VCCSA on SVCC (solid shape): 159.35,157.77 159.35,143.09 159.33,143.06 155.54,139.27 155.54,134.19 154.65,133.3 154.65,116.28 153.93,115.57 143.77,115.57 143.52,115.31 141.29,115.31 140.3,116.31 140.3,129.83 148.93,138.47 148.93,157.8 150.18,159.25 157.98,159.25
+VCCSA on IN1 (solid shape): outline of 348 points within 139.43,115.57 143.83,127.53
+VCCSTG on TOP (solid shape): outline of 422 points within 143.28,126.44 152.76,134.48
+VDDQ on BOTTOM (solid shape): 183.22,71.12 183.22,70.35 182.97,70.1 182.82,70.1 182.51,69.8 182.51,69.31 182.14,68.94 181.43,68.94 181.19,68.7 180.1,68.7 180.06,68.72 180.05,68.75 180.05,69.57 180.07,69.59 181.29,69.59 181.43,69.73 181.45,69.74 181.48,69.74 181.85,69.86 181.91,70.25 181.9,70.26 181.9,71.01 182.13,71.24 183.1,71.24
+VDDQ_VTT on TOP (solid shape): 178.85,72.49 178.85,71.7 178.65,71.5 174.97,71.5 174.46,70.99 173.57,70.99 173.32,71.24 173.32,72.39 173.53,72.6 175.58,72.6 175.6,72.62 178.72,72.62
+VDDQ_VTT on TOP (solid shape): outline of 112 points within 163.16,47.37 169.51,69.34
+VDDQ_VTT on BOTTOM (solid shape): 166.15,48.21 166.15,47.11 165.09,46.05 164.39,46.05 164.39,48.33 164.7,48.64 165.73,48.64
+VDDQ_VTT on BOTTOM (solid shape): 179.92,72.39 179.92,70.33 179.44,69.85 179.44,68.83 179.41,68.8 179.29,68.8 179.24,68.86 179.24,70.05 178.92,70.37 178.92,70.95 178.3,71.57 178.3,72.56 178.42,72.69 179.62,72.69
+VDDQ_VTT on BOTTOM (solid shape): 167.73,66.12 167.73,60.57 166.4,59.25 164.39,59.25 164.39,61.88 163.92,62.35 163.41,62.35 163.28,62.48 163.28,64.73 165.37,64.73 165.37,63.97 165.91,63.43 166.68,63.43 167.22,63.97 167.22,64.73 166.68,65.27 165.91,65.27 165.37,64.73 163.28,64.73 163.28,66.29 164.09,67.1 164.09,69.45 164.4,69.45
+VDDQ_VTT on BOTTOM (solid shape): 166.33,57.53 166.33,55.75 165.91,55.32 165.45,55.26 165.39,54.8 164.83,54.25 164.09,54.25 164.09,56.94 164.81,57.65 166.2,57.65
+VDDQC on TOP (solid shape): 133.82,116.25 133.82,115.51 133.52,115.21 133.52,114.7 133.58,114.64 133.69,114.64 133.84,114.5 133.84,114.26 133.7,114.12 133.36,114.12 133.06,114.42 133.06,115.44 132.8,115.69 132.74,115.69 132.74,115.7 132.29,115.7 132.17,115.82 132.17,116.2 132.3,116.33 133.74,116.33
AGND_DDR on TOP (solid shape): 183.17,69.9 183.17,68.27 182.59,67.69 180.81,67.69 179.92,66.8 176.24,66.8 176.11,66.92 176.11,67.15 176.72,67.76 176.75,67.76 177.54,68.55 181.77,68.55 182.09,68.87 182.09,69.81 182.38,70.1 182.97,70.1
GND on TOP (solid shape): 202.78,146.05 198.72,146.05 198.72,149.6 202.78,149.6
GND on TOP (solid shape): 160.87,91.69 159.35,91.69 159.09,91.94 159.09,92.71 159.35,92.96 160.87,92.96
GND on TOP (solid shape): 17.16,42.97 17.16,40.81 16.88,40.53 14.49,40.53 14.29,40.74 14.29,42.9 14.49,43.1 17.03,43.1
GND on TOP (solid shape): 76.79,114.65 76.79,111.1 76.43,110.74 74.18,110.74 74.05,110.87 74.05,114.55 74.43,114.93 76.52,114.93
GND on TOP (solid shape): 111.75,119.88 111.75,118.56 111.65,118.46 109.61,118.46 109.46,118.61 109.46,119.83 109.61,119.99 111.65,119.99
GND on TOP (solid shape): 122.77,190.62 122.77,188.59 122.64,188.46 119.47,188.46 119.34,188.59 119.34,189.35 121.12,191.13 122.26,191.13
GND on TOP (solid shape): 122.9,184.91 122.9,183.51 122.77,183.38 120.1,183.38 119.98,183.51 119.98,185.03 120.1,185.16 122.64,185.16
GND on TOP (solid shape): 198.34,197.03 198.34,196.29 198.18,196.13 195.98,196.13 194.3,197.81 194.3,198.87 194.46,199.03 196.35,199.03
GND on TOP (solid shape): 208.57,156.51 208.57,155.9 207.84,155.16 198.77,155.16 198.26,155.67 198.26,156.49 198.39,156.61 208.47,156.61
GND on TOP (solid shape): 226.21,50.65 226.21,48.16 225.96,47.91 222.99,47.91 222.79,48.11 222.79,50.68 223.03,50.92 225.94,50.92
GND on TOP (solid shape): 9.36,111.63 9.36,111.12 9,110.77 7.15,110.77 7,110.92 7,111.55 7.1,111.65 9.33,111.65
GND on TOP (solid shape): 55.98,86.18 55.98,83.39 55.61,83.02 52.53,83.02 52.18,83.37 52.18,86.19 52.48,86.49 55.68,86.49
GND on TOP (solid shape): 111.65,116.79 111.65,115.52 111.49,115.36 111.24,115.36 111.14,115.46 111.14,115.72 110.68,116.18 110.68,116.84 110.73,116.89 111.54,116.89
GND on TOP (solid shape): 156.49,198.05 156.49,195 156.17,194.69 153.38,194.69 153.12,194.94 153.12,198.24 153.25,198.37 156.17,198.37
GND on TOP (solid shape): 218.94,156.26 218.94,155.7 219.21,155.42 219.21,154.83 218.3,153.92 212.59,153.92 212.41,154.1 212.41,156.49 212.56,156.64 218.55,156.64
GND on TOP (solid shape): 135.09,130.22 135.09,128.9 135.06,128.88 134.55,128.88 134.49,128.89 134.1,129.28 134.1,129.56 134.79,130.25 135.06,130.25
GND on TOP (solid shape): 216.37,116.71 216.37,109.85 215.61,109.09 213.58,109.09 213.32,109.34 213.32,115.69 214.46,116.84 216.24,116.84
GND on TOP (solid shape): 24.19,54.12 24.35,53.97 25.11,53.97 25.36,53.72 25.36,51.43 24.98,51.05 23.05,51.05 22.8,51.3 22.8,53.36 23.48,54.05 23.48,55.18 24.19,55.18
GND on TOP (solid shape): 116.04,128.7 119.57,128.7 119.7,128.82 120.05,128.82 120.17,128.71 120.17,127.77 119.93,127.53 115.63,127.53 115.35,127.81 115.35,128.85 115.48,128.98 115.76,128.98
GND on TOP (solid shape): 147.51,149.02 147.51,145.21 147.33,145.03 145.35,145.03 144.89,145.49 144.89,148.61 145.5,149.22 147.31,149.22
GND on TOP (solid shape): 151.7,164.33 151.7,158.21 151.44,157.95 148.65,157.95 148.37,158.23 148.37,162.1 147.76,162.71 144.38,162.71 144.22,162.87 144.22,164.71 144.81,165.3 150.73,165.3
GND on TOP (solid shape): 190.69,127.88 190.69,124.71 189.55,123.57 183.96,123.57 182.56,124.96 182.56,126.49 182.58,126.5 182.58,127.49 183.1,128.01 190.56,128.01
GND on TOP (solid shape): 210.91,184.93 210.91,181.83 210.3,181.22 209.26,181.22 208.75,180.72 207.86,180.72 207.73,180.84 207.73,184.02 207.48,184.27 207.48,185.31 207.61,185.44 210.4,185.44
GND on TOP (solid shape): 185.76,101.85 185.76,100.71 185.38,100.33 185.08,100.33 185.04,100.33 185,100.33 184.23,100.33 183.86,100.71 183.86,101.34 184.49,101.98 185.64,101.98
GND on TOP (solid shape): 117.46,123.47 117.46,122.45 116.42,121.41 112.36,121.41 112.23,121.53 112.23,122.42 112.48,122.68 113.63,122.68 114.13,123.19 116.42,123.19 116.55,123.31 116.55,123.69 116.67,123.82 117.11,123.82
GND on TOP (solid shape): 119.98,125.47 119.98,125.09 119.85,124.96 118.53,124.96 118.15,125.34 115.53,125.34 115.46,125.27 115.46,125.14 115.3,124.99 115.05,124.99 114.9,125.14 114.9,125.42 115.2,125.73 119.72,125.73
GND on TOP (solid shape): 186.78,105.66 188.63,105.66 188.76,105.53 188.76,104.85 188.68,104.77 186.02,104.77 185.51,105.28 185.51,106.42 185.64,106.55 185.89,106.55
GND on TOP (solid shape): 214.31,141.17 214.31,138.38 214.06,138.12 213.3,138.12 212.84,137.66 212.23,137.66 212.13,137.77 212.13,139.39 211.67,139.85 211.06,139.85 210.91,140 210.91,140.81 211.52,141.42 214.06,141.42
GND on TOP (solid shape): 128.49,148.84 128.49,143.63 127.98,143.12 127.98,141.85 127.85,141.73 127.22,141.73 127.09,141.85 127.09,146.93 127.6,147.44 127.72,147.44 127.85,147.57 127.85,148.71 128.1,148.97 128.36,148.97
GND on TOP (solid shape): 161.88,165.06 161.88,164.32 161.87,164.3 161.87,162.33 161.3,161.77 160.19,161.77 159.09,162.86 158.87,162.86 158.86,162.87 155.5,162.87 155.37,162.99 155.37,164.7 155.9,165.23 161.72,165.23
GND on TOP (solid shape): 197.7,193.16 197.95,193.16 198.97,192.15 199.61,192.15 200.24,191.51 200.24,191.26 200.14,191.16 199.76,191.16 199.53,191.38 190.59,191.38 190.33,191.64 190.33,192.27 190.59,192.53 191.86,192.53 192.62,193.29 197.57,193.29
GND on TOP (solid shape): 207.1,35.94 207.1,35.43 206.59,34.92 206.21,34.92 205.96,34.67 205.96,33.4 205.45,32.89 204.81,32.89 204.69,33.02 204.69,34.67 204.94,34.92 205.45,34.92 206.53,36 206.54,36 206.6,36.06 206.97,36.06
GND on TOP (solid shape): 16.47,32 16.47,31.07 16.62,30.92 17.11,30.92 17.15,30.88 17.15,30.72 17.12,30.68 15.1,30.68 14.74,31.04 14.74,31.29 14.79,31.34 15.19,31.34 15.5,31.65 15.5,31.98 15.54,32.02 16.45,32.02
GND on TOP (solid shape): 150.28,155.82 150.96,155.82 151.22,155.57 151.22,153.28 149.19,151.25 148.81,151.25 148.55,151.51 148.55,155.72 148.55,155.77 146.87,157.45 144.13,157.45 144.01,157.57 144.01,158.19 144.33,158.52 147.59,158.52
GND on TOP (solid shape): 206.71,197.35 208.5,197.35 208.62,197.23 208.62,196.85 207.73,195.96 207.73,194.81 206.94,194.02 205.7,194.02 205.23,193.54 204.68,193.54 204.11,194.12 204.11,197.01 204.48,197.38 206.68,197.38
GND on TOP (solid shape): 196.53,115.88 196.53,114.51 196.67,114.37 199.35,114.37 200.3,115.33 202.93,115.33 203.04,115.21 203.04,114.61 202.84,114.4 202.84,110.71 202.59,110.46 192.32,110.46 190.14,112.64 190.14,114.99 190.42,115.27 194.32,115.27 195.4,116.35 196.06,116.35
GND on TOP (solid shape): 57.9,56.63 57.9,55.83 58.04,55.69 58.04,55.67 58.06,55.67 58.27,55.47 58.63,55.47 58.96,55.13 58.96,54.35 58.82,54.2 56.71,54.2 56.52,54.39 56.52,56.59 56.74,56.81 57.73,56.81
GND on TOP (solid shape): 18.12,48.3 18.12,47.88 18.46,47.54 18.8,47.54 18.94,47.4 18.94,47.22 18.91,47.19 18.38,47.19 18.3,47.28 17.19,47.28 16.93,47.53 16.58,47.53 16.52,47.59 16.52,47.78 16.53,47.79 17.22,47.79 17.36,47.93 17.36,48.42 17.49,48.55 17.87,48.55
GND on TOP (solid shape): 192.61,150.07 192.61,147.11 193.26,146.47 193.26,146.02 193.1,145.87 192.3,145.87 192.3,145.86 192.19,145.86 192.14,145.81 192.14,145.7 191.9,145.46 191.58,145.46 191.38,145.66 191.38,149.6 191.15,149.83 190.28,149.83 190,150.11 190,150.47 190.11,150.57 192.11,150.57
GND on TOP (solid shape): 105.37,130.42 105.37,117.88 105.09,117.6 104.48,117.6 104.18,117.9 104.18,120.04 104.43,120.29 104.43,122.09 103.95,122.58 96.89,122.58 96.66,122.8 96.66,126.64 98.44,128.42 101.19,128.42 103.45,130.68 105.12,130.68
GND on TOP (solid shape): 100.16,72.39 100.16,70.61 100.04,70.48 96.23,70.48 96.1,70.61 96.1,70.86 95.72,71.24 95.72,71.75 94.69,72.78 94.69,72.89 94.67,73.03 94.58,73.16 94.58,73.18 94.58,73.78 95.08,74.29 98.26,74.29
GND on TOP (solid shape): 228.08,58.15 228.46,57.78 229,57.81 229.26,57.81 229.39,57.68 229.39,57.06 229.22,56.89 228.22,56.89 227.84,56.51 227.36,56.51 227.36,58.15
GND on TOP (solid shape): 178.22,153.05 178.22,152.29 178.52,151.99 178.52,149.09 178.45,149.02 178.45,145.82 178.02,145.39 178.02,141.83 177.86,141.68 176.39,141.68 176.26,141.8 176.26,145.51 176.25,145.53 176.25,146.16 175.83,146.58 175.2,146.58 175.02,146.76 175.02,147.24 176.53,148.75 176.53,150.96 176.92,151.35 176.92,153.18 177,153.26 178.01,153.26
GND on TOP (solid shape): 8.2,115.44 8.49,115.27 8.79,115.12 8.98,114.93 9.25,114.93 9.72,114.79 10.2,114.69 10.35,114.55 13.25,114.55 13.47,114.32 13.47,113.91 12.92,113.36 10.25,113.36 9.66,113.94 7.79,113.94 7.71,114.02 7.71,114.27 7.25,114.73 7.25,114.98 7.26,114.99 7.26,115.12 7.58,115.44
GND on TOP (solid shape): 68.15,56.45 68.78,56.45 68.95,56.27 68.95,55.49 68.76,55.3 67.54,55.3 66.73,54.49 66.73,53.03 66.65,52.95 66.51,52.95 66.46,52.9 66.46,52.44 66.39,52.37 65.97,52.37 65.73,52.61 65.73,52.9 65.67,52.96 65.3,52.96 64.83,53.43 64.83,54.81 64.89,54.87 65.97,54.87 66.09,54.98 66.09,55.73 66.22,55.87 66.91,55.87 67.53,56.49 68.15,56.49
GND on TOP (solid shape): 111.54,128.14 111.56,128.12 111.57,128.09 111.57,127.59 111.54,127.57 111.35,127.25 111.54,126.93 111.57,126.91 111.57,126.44 111.49,126.36 109.46,126.36 109.08,126.74 109.08,127.76 109.46,128.14
GND on TOP (solid shape): 144.74,120.77 144.74,119.41 144.12,118.79 144.12,118.75 144.11,118.74 144.11,117.98 144.12,117.97 144.12,117.95 144.49,117.58 144.49,116.63 144.42,116.57 144.38,116.57 144.13,116.58 143.93,116.43 143.75,116.43 143.6,116.58 143.6,120.39 143.34,120.65 143.34,121.15 143.47,121.28 144.23,121.28
GND on TOP (solid shape): 217.69,199.26 217.69,191.81 217,191.13 214.97,191.13 214.72,190.88 214.72,189.86 214.46,189.61 213.89,189.61 211.8,191.7 211.8,197.01 211.81,197.02 211.81,197.73 212.04,197.96 212.17,198.21 212.09,198.47 212.08,198.5 212.08,198.52 212.09,198.54 212.96,199.41 217.54,199.41
GND on TOP (solid shape): 131.38,166.17 132.6,166.17 133.37,165.4 140.49,165.4 141.33,164.56 141.33,161.91 141.11,161.69 138.64,161.69 137.22,163.11 133.69,163.11 133.41,162.83 133.41,160.24 133.14,159.97 129.78,159.97 129.56,160.19 129.56,162.78 128.06,164.28 127.78,164.28 127.77,164.28 127.6,164.32 127.43,164.28 127.42,164.28 125.67,164.28 125.36,164.59 125.36,166.56 125.47,166.67 130.87,166.67
GND on TOP (solid shape): 134.4,113.84 135.22,113.84 135.34,113.97 138.19,113.97 138.34,113.81 138.34,112.92 138.19,112.77 137.91,112.77 137.76,112.92 137.76,113.2 137.48,113.48 136.66,113.48 136.59,113.41 136.59,111.68 136.44,111.53 136.18,111.53 135.98,111.73 135.98,113.15 135.67,113.46 135.24,113.46 135.12,113.33 135.12,113.12 135.11,113.08 135.11,113.05 135.04,112.98 134.33,112.98 133.82,113.48 133.49,113.48 133.39,113.58 133.39,113.89 133.49,113.99 134.25,113.99
GND on TOP (solid shape): 229.39,52.12 229.39,48.97 229.22,48.8 229.04,48.8 229.02,48.81 228.25,48.72 228.1,47.95 228.1,47.32 228.07,47.29 227.36,47.29 227.36,52.19 229.31,52.19

# Allegro board Quanta ZRW REV F - BoardView (.BRD).brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
M_B_DQ11: length 79.2
  IN2 w0.127: v1(114.71,117.35) 114.71,117.58 114.31,117.98 113.37,117.98 113.12,118.23 109.52,118.23 105.84,114.56 105.84,112.91 100.13,107.2 100.13,91.84 100.25,91.71 100.67,91.71 100.8,91.59 100.8,91.33 100.67,91.21 100.25,91.21 100.13,91.08 100.13,90.82 100.25,90.7 100.67,90.7 100.8,90.57 100.8,90.32 100.67,90.19 100.25,90.19 100.13,90.06 100.13,89.81 100.25,89.68 100.67,89.68 100.8,89.55 100.8,89.3 100.67,89.17 100.25,89.17 100.13,89.05 100.13,88.79 100.25,88.67 100.67,88.67 100.8,88.54 100.8,88.28 100.67,88.16 100.25,88.16 100.13,88.03 100.13,87.66 100.29,87.5 100.42,87.5 100.83,87.09 100.83,74.39 101.43,73.78 101.43,69.25 104.1,66.58 104.1,64.38 104.23,64.26 v1(105.37,64.26)
  BOTTOM w0.076: U35.AH68 117.9,116.46 117.56,116.81 117.17,116.81 116.93,116.92 116.74,116.92 116.58,116.85 116.43,116.85 116.3,116.91 115.7,116.91 115.62,116.98 115.08,116.98 v1(114.71,117.35)
  BOTTOM w0.114: JDIM1.15 105.44,67.27 104.74,66.56 104.74,64.89 v1(105.37,64.26)
M_B_DQ12: length 76.4
  IN2 w0.127: v1(114.65,118.74) 114.65,119.21 113.7,120.16 108.84,120.16 104.29,115.61 104.29,113.52 98.46,107.69 98.46,86.6 98.59,86.48 98.78,86.48 98.91,86.35 98.91,86.1 98.78,85.97 98.59,85.97 98.46,85.84 98.46,85.59 98.59,85.46 98.78,85.46 98.91,85.33 98.91,85.08 98.78,84.95 98.59,84.95 98.46,84.83 98.46,84.57 98.59,84.44 98.78,84.44 98.91,84.32 98.91,84.06 98.78,83.94 98.59,83.94 98.46,83.81 98.46,83.56 98.59,83.43 98.78,83.43 98.91,83.3 98.91,83.05 98.78,82.92 98.59,82.92 98.46,82.79 98.46,82.54 98.59,82.41 98.78,82.41 98.91,82.29 98.91,82.03 98.78,81.9 98.59,81.9 98.46,81.78 98.46,81.52 98.59,81.4 98.78,81.4 98.91,81.27 98.91,81.02 98.78,80.89 98.59,80.89 98.46,80.76 98.46,80.51 98.59,80.38 98.78,80.38 98.91,80.25 98.91,80 98.78,79.87 98.59,79.87 98.46,79.75 98.46,79.49 98.59,79.36 98.78,79.36 98.91,79.24 98.91,78.98 98.78,78.86 98.59,78.86 98.46,78.73 98.46,78.48 98.59,78.35 98.78,78.35 98.91,78.22 98.91,77.97 98.78,77.84 98.59,77.84 98.46,77.71 98.46,69.26 101.37,66.35 v1(102.46,66.35)
  BOTTOM w0.076: U35.AF71 115.99,117.98 115.93,117.98 115.52,118.39 115.01,118.39 v1(114.65,118.74)
  BOTTOM w0.114: JDIM1.5 102.44,66.36 v1(102.46,66.35)
M_B_DQ13: length 77.7
  IN2 w0.127: v1(115.94,118.79) 115.94,118.94 114.06,120.82 108.57,120.82 103.63,115.89 103.63,113.79 97.8,107.96 97.8,68.48 101.41,64.88 101.41,63.6 101.94,63.07 v1(102.38,63.07)
  BOTTOM w0.076: U35.AF69 117.38,117.69 116.71,118.36 116.37,118.36 v1(115.94,118.79)
  BOTTOM w0.114: JDIM1.6 102.74,61.36 102.81,61.43 102.81,62.64 102.39,63.07 v1(102.38,63.07)
M_B_DQ14: length 77.2
  IN2 w0.127: v1(112.8,117.37) 109.59,117.37 106.5,114.28 106.5,112.64 100.84,106.97 100.84,95.33 101.74,94.43 101.74,81.77 101.87,81.64 102.17,81.64 102.3,81.52 102.3,81.26 102.17,81.14 101.87,81.14 101.74,81.01 101.74,80.75 101.87,80.63 102.17,80.63 102.3,80.5 102.3,80.25 102.17,80.12 101.87,80.12 101.74,79.99 101.74,79.74 101.87,79.61 102.17,79.61 102.3,79.48 102.3,79.23 102.17,79.1 101.87,79.1 101.74,78.98 101.74,78.72 101.87,78.6 102.17,78.6 102.3,78.47 102.3,78.21 102.17,78.09 101.87,78.09 101.74,77.96 101.74,77.71 101.87,77.58 102.17,77.58 102.3,77.45 102.3,77.2 102.17,77.07 101.87,77.07 101.74,76.94 101.74,76.69 101.87,76.56 102.17,76.56 102.3,76.44 102.3,76.18 102.17,76.06 101.87,76.06 101.74,75.93 101.74,75.67 101.87,75.55 102.17,75.55 102.3,75.42 102.3,75.17 102.17,75.04 101.87,75.04 101.74,74.91 101.74,74.66 101.87,74.53 102.17,74.53 102.3,74.4 102.3,69.4 106.02,65.68 106.02,63.48 v1(105.51,62.98)
  BOTTOM w0.076: v1(112.8,117.37) 113.59,116.58 114.64,116.58 114.74,116.49 115.31,116.49 115.6,116.2 116.28,116.2 116.43,116.26 116.63,116.26 U35.AH70
  BOTTOM w0.114: v1(105.51,62.98) 106.34,62.15 JDIM1.18
M_B_DQ15: length 77.6
  IN2 w0.127: v1(105.56,61.67) 105.61,61.67 106.51,62.58 106.51,64.07 106.35,64.23 106.35,65.82 102.63,69.54 102.63,82.04 102.5,82.17 102.32,82.17 102.2,82.29 102.2,82.55 102.32,82.67 102.5,82.67 102.63,82.8 102.63,83.06 102.5,83.18 102.32,83.18 102.2,83.31 102.2,83.56 102.32,83.69 102.5,83.69 102.63,83.82 102.63,84.07 102.5,84.2 102.32,84.2 102.2,84.33 102.2,84.58 102.32,84.71 102.5,84.71 102.63,84.83 102.63,85.09 102.5,85.21 102.32,85.21 102.2,85.34 102.2,85.6 102.32,85.72 102.5,85.72 102.63,85.85 102.63,86.1 102.5,86.23 102.32,86.23 102.2,86.36 102.2,86.61 102.32,86.74 102.5,86.74 102.63,86.87 102.63,87.12 102.5,87.25 102.32,87.25 102.2,87.37 102.2,87.63 102.32,87.75 102.5,87.75 102.63,87.88 102.63,88.14 102.5,88.26 102.32,88.26 102.2,88.39 102.2,88.64 102.32,88.77 102.5,88.77 102.63,88.9 102.63,89.15 102.5,89.28 102.32,89.28 102.2,89.41 102.2,89.66 102.32,89.79 102.5,89.79 102.63,89.91 102.63,90.17 102.5,90.29 102.32,90.29 102.2,90.42 102.2,90.68 102.32,90.8 102.5,90.8 102.63,90.93 102.63,91.18 102.5,91.31 102.32,91.31 102.2,91.44 102.2,91.69 102.32,91.82 102.5,91.82 102.63,91.95 102.63,92.2 102.5,92.33 102.32,92.33 102.2,92.45 102.2,92.71 102.32,92.83 102.5,92.83 102.63,92.96 102.63,94.17 101.17,95.63 101.17,106.84 106.83,112.5 106.83,113.87 110.01,117.04 112.28,117.04 112.53,116.79 113.49,116.79 v1(114.07,117.37)
  BOTTOM w0.076: v1(114.07,117.37) 114.51,116.94 114.87,116.94 114.99,116.82 115.49,116.82 115.57,116.73 116.28,116.73 116.4,116.68 116.61,116.68 116.78,116.75 116.9,116.75 117.13,116.64 117.31,116.64 U35.AH69
  BOTTOM w0.114: v1(105.56,61.67) 105.74,61.48 JDIM1.16
M_B_DQ16: length 62.8
  IN2 w0.127: v1(113.25,66.92) 113.25,67.04 111.49,68.8 111.49,71.37 110.64,72.22 110.64,86.92 110.77,87.05 111.09,87.05 111.21,87.17 111.21,87.43 111.09,87.55 110.77,87.55 110.64,87.68 110.64,87.94 110.77,88.06 111.09,88.06 111.21,88.19 111.21,88.44 111.09,88.57 110.77,88.57 110.64,88.7 110.64,88.95 110.77,89.08 111.09,89.08 111.21,89.21 111.21,89.46 111.09,89.59 110.77,89.59 110.64,89.71 110.64,89.97 110.77,90.09 111.09,90.09 111.21,90.22 111.21,90.48 111.09,90.6 110.77,90.6 110.64,90.73 110.64,90.98 110.77,91.11 111.09,91.11 111.21,91.24 111.21,91.49 111.09,91.62 110.77,91.62 110.64,91.75 110.64,92 110.77,92.13 111.09,92.13 111.21,92.25 111.21,92.51 111.09,92.63 110.77,92.63 110.64,92.76 110.64,95.99 106.62,100.01 106.62,103.48 112,108.86 114.4,108.86 116.66,111.12 117.18,111.12 118.45,112.39 v2(118.96,112.39)
  BOTTOM w0.114: v1(113.25,66.92) 113.09,66.92 113,67.01 113,67.32 113.24,67.57 JDIM1.41 ; v2(118.96,112.39) U35.AT66
M_B_DQ17: length 62.5
  IN2 w0.127: v2(118.91,111.76) 118.33,111.76 117.36,110.79 116.8,110.79 114.49,108.48 112.08,108.48 106.95,103.34 106.95,100.15 111.58,95.51 111.58,95.1 111.46,94.97 111.1,94.97 110.97,94.85 110.97,94.59 111.1,94.47 111.46,94.47 111.58,94.34 111.58,94.09 111.46,93.96 111.1,93.96 110.97,93.83 110.97,93.58 111.1,93.45 111.46,93.45 111.58,93.32 111.58,71.89 111.85,71.62 111.85,68.96 113.7,67.11 113.7,65.52 113.54,65.35 v1(113.26,65.35)
  BOTTOM w0.114: JDIM1.39 112.64,65.7 112.99,65.35 v1(113.26,65.35) ; U35.AU66 v2(118.91,111.76)
M_B_DQ18: length 65.7
  IN2 w0.076: 115.89,101.19 116.74,102.04 116.74,102.55 117.31,103.12 117.31,105.62 118.38,106.69 118.38,107.89 120.57,110.09 120.57,111.22 120.22,111.58 120.22,112.65 v2(119.84,113.03)
  IN2 w0.127: 115.89,101.19 115.67,100.97 115.67,98.52 114.92,97.77 114.92,90.56 115.04,90.43 115.54,90.43 115.67,90.3 115.67,90.05 115.54,89.92 115.04,89.92 114.92,89.8 114.92,89.54 115.04,89.41 115.54,89.41 115.67,89.29 115.67,89.03 115.54,88.91 115.04,88.91 114.92,88.78 114.92,88.53 115.04,88.4 115.54,88.4 115.67,88.27 115.67,88.02 115.54,87.89 115.04,87.89 114.92,87.76 114.92,87.51 115.04,87.38 115.54,87.38 115.67,87.26 115.67,87 115.54,86.87 115.04,86.87 114.92,86.75 114.92,86.49 115.04,86.37 115.54,86.37 115.67,86.24 115.67,85.99 115.54,85.86 115.04,85.86 114.92,85.73 114.92,85.48 115.04,85.35 115.54,85.35 115.67,85.22 115.67,84.97 115.54,84.84 115.04,84.84 114.92,84.72 114.92,84.46 115.04,84.33 115.54,84.33 115.67,84.21 115.67,83.95 115.54,83.83 115.04,83.83 114.92,83.7 114.92,83.45 115.04,83.32 115.54,83.32 115.67,83.19 115.67,82.94 115.54,82.81 115.04,82.81 114.92,82.68 114.92,82.43 115.04,82.3 115.54,82.3 115.67,82.18 115.67,81.92 115.54,81.79 115.04,81.79 114.92,81.67 114.92,81.41 115.04,81.29 115.54,81.29 115.67,81.16 115.67,80.91 115.54,80.78 115.04,80.78 114.92,80.65 114.92,80.4 115.04,80.27 115.54,80.27 115.67,80.14 115.67,77.61 115.38,77.32 115.38,71.86 115.67,71.57 115.67,68.31 116.65,67.33 v1(116.65,66.92)
  BOTTOM w0.114: v1(116.65,66.92) 116.26,66.53 116.02,66.53 115.85,66.71 115.85,66.97 116.24,67.37 JDIM1.51 ; U35.AP65 v2(119.84,113.03)
M_B_DQ19: length 66.4
  IN2 w0.076: 116.21,100.87 117.59,102.24 117.59,105.43 118.58,106.42 118.58,107.86 120.74,110.02 120.74,111.29 120.38,111.65 120.38,113.13 v2(119.84,113.68)
  IN2 w0.127: 116.21,100.87 116,100.66 116,97.66 115.88,97.53 115.4,97.53 115.28,97.41 115.28,97.15 115.4,97.02 115.88,97.02 116,96.9 116,96.64 115.88,96.52 115.4,96.52 115.28,96.39 115.28,96.14 115.4,96.01 115.88,96.01 116,95.88 116,95.63 115.88,95.5 115.4,95.5 115.28,95.37 115.28,95.12 115.4,94.99 115.88,94.99 116,94.87 116,94.61 115.88,94.48 115.4,94.48 115.28,94.36 115.28,94.1 115.4,93.98 115.88,93.98 116,93.85 116,93.6 115.88,93.47 115.4,93.47 115.28,93.34 115.28,93.09 115.4,92.96 115.88,92.96 116,92.83 116,92.58 115.88,92.45 115.4,92.45 115.28,92.33 115.28,92.07 115.4,91.94 115.88,91.94 116,91.82 116,91.56 115.88,91.44 115.4,91.44 115.28,91.31 115.28,91.06 115.4,90.93 115.88,90.93 116,90.8 116,68.81 117.11,67.71 117.11,64.92 116.92,64.73 116.7,64.73 116.57,64.86 116.57,65.29 v1(116.65,65.37)
  BOTTOM w0.114: v1(116.65,65.37) 116.65,64.78 116.75,64.68 117.06,64.68 117.18,64.8 117.18,67.05 116.84,67.39 JDIM1.53 ; v2(119.84,113.68) U35.AN65
M_B_DQ20: length 65.8
  IN2 w0.127: v1(113.25,63.21) 112.48,63.98 112.48,66.85 109.98,69.35 109.98,95.59 105.96,99.61 105.96,104.89 111.99,110.92 115.58,110.92 116.93,112.26 116.93,113.03 117.69,113.79 118.38,113.79 v2(118.91,114.32)
  BOTTOM w0.114: v1(113.25,63.21) 113.75,62.71 113.75,61.55 113.54,61.34 JDIM1.42
  BOTTOM w0.127: U35.AN66 v2(118.91,114.32)
M_B_DQ21: length 64.8
  IN2 w0.127: v2(118.96,113.71) 118.96,113.66 116.8,111.5 116.63,111.5 115.72,110.59 112.2,110.59 106.29,104.67 106.29,99.79 110.31,95.77 110.31,72.08 110.9,71.5 110.9,68.92 112.81,67.01 112.81,64.95 113.7,64.06 113.7,62.22 v1(113.27,61.79)
  BOTTOM w0.114: v1(113.27,61.79) 112.94,61.46 JDIM1.40
  BOTTOM w0.127: U35.AP66 v2(118.96,113.71)
M_B_DQ22: length 64.1
  IN2 w0.076: 115.64,101.43 116.29,102.08 116.29,102.64 117.03,103.37 117.03,105.76 118.2,106.93 118.2,107.95 120.38,110.13 120.38,111.15 119.84,111.7 v2(119.84,111.73)
  IN2 w0.127: 115.64,101.43 115.34,101.13 115.34,98.66 114.59,97.9 114.59,79.79 114.71,79.66 115.21,79.66 115.34,79.53 115.34,79.28 115.21,79.15 114.71,79.15 114.59,79.03 114.59,78.77 114.71,78.64 115.21,78.64 115.34,78.52 115.34,78.26 115.21,78.14 114.71,78.14 114.59,78.01 114.59,77.76 114.71,77.63 114.93,77.63 115.05,77.51 115.05,77.18 114.93,77.05 114.46,77.05 114.36,76.96 114.36,76.67 114.49,76.55 114.93,76.55 115.05,76.42 115.05,76.17 114.93,76.04 114.46,76.04 114.36,75.94 114.36,75.63 114.46,75.53 114.93,75.53 115.05,75.4 115.05,75.15 114.93,75.02 114.79,75.02 114.64,74.87 114.64,74.66 114.79,74.51 114.93,74.51 115.05,74.39 115.05,74.13 114.93,74.01 114.79,74.01 114.64,73.86 114.64,73.65 114.79,73.5 114.93,73.5 115.05,73.37 115.05,73.12 114.93,72.99 114.79,72.99 114.64,72.84 114.64,72.63 114.79,72.48 114.93,72.48 115.05,72.36 115.05,71.72 115.34,71.43 115.34,68.11 116.21,67.24 116.21,61.5 116.04,61.34 115.28,61.34 115.15,61.46 v1(115.15,61.84)
  BOTTOM w0.114: U35.AT65 v2(119.84,111.73) ; v1(115.15,61.84) 115.56,61.84 115.94,61.46 JDIM1.50
M_B_DQ23: length 63.7
  IN2 w0.127: v1(115.18,63.46) 115.53,63.11 115.75,63.11 115.88,63.24 115.88,67.09 114.26,68.7 114.26,69.37 114.39,69.49 114.88,69.49 115.01,69.62 115.01,69.87 114.88,70 114.39,70 114.26,70.13 114.26,70.38 114.39,70.51 114.88,70.51 115.01,70.64 115.01,70.89 114.88,71.02 114.39,71.02 114.26,71.14 114.26,72 114.03,72.23 114.03,78.44 114.26,78.66 114.26,78.92 114.01,79.17 114.01,79.43 114.26,79.68 114.26,79.94 114.01,80.19 114.01,80.45 114.26,80.7 114.26,80.96 114.01,81.2 114.01,81.46 114.26,81.71 114.26,81.97 114.01,82.22 114.01,82.48 114.26,82.73 114.26,83.79 114.13,83.92 113.63,83.92 113.5,84.05 113.5,84.3 113.63,84.43 114.13,84.43 114.26,84.56 114.26,84.81 114.13,84.94 113.63,84.94 113.5,85.06 113.5,85.32 113.63,85.44 114.13,85.44 114.26,85.57 114.26,85.83 114.13,85.95 113.75,85.95 113.63,86.08 113.63,86.33 113.75,86.46 114.13,86.46 114.26,86.59 114.26,98.04 115.01,98.79 115.01,101.58 115.56,102.13 115.56,106.07 116.17,106.68 117.31,106.68 117.97,107.34 117.97,108.1 120.04,110.17 120.04,110.95 v2(119.91,111.08)
  BOTTOM w0.114: v1(115.18,63.46) 116.54,62.1 JDIM1.52 ; U35.AU65 119.91,111.14 v2(119.91,111.08)
M_B_DQ24: length 55.1
  IN2 w0.076: 117.3,99.78 117.27,99.81 117.27,99.91 119.11,101.74 119.11,105.3 119.47,105.66 119.47,107.82 121.26,109.61 121.26,111.23 121.69,111.67 v2(121.69,111.79)
  IN2 w0.127: v1(118.71,66.72) 118.71,67.94 117.3,69.35 117.3,84.03 117.42,84.16 117.49,84.16 117.61,84.28 117.61,84.54 117.49,84.67 117.42,84.67 117.3,84.79 117.3,85.05 117.42,85.17 117.49,85.17 117.61,85.3 117.61,85.55 117.49,85.68 117.42,85.68 117.3,85.81 117.3,86.06 117.42,86.19 117.49,86.19 117.61,86.32 117.61,86.57 117.49,86.7 117.42,86.7 117.3,86.82 117.3,87.08 117.42,87.21 117.49,87.21 117.61,87.33 117.61,87.59 117.49,87.71 117.42,87.71 117.3,87.84 117.3,88.09 117.42,88.22 117.49,88.22 117.61,88.35 117.61,88.6 117.49,88.73 117.42,88.73 117.3,88.86 117.3,89.11 117.42,89.24 117.49,89.24 117.61,89.36 117.61,89.62 117.49,89.75 117.42,89.75 117.3,89.87 117.3,90.13 117.42,90.25 117.49,90.25 117.61,90.38 117.61,90.63 117.49,90.76 117.42,90.76 117.3,90.89 117.3,91.14 117.42,91.27 117.49,91.27 117.61,91.4 117.61,91.65 117.49,91.78 117.42,91.78 117.3,91.9 117.3,92.16 117.42,92.29 117.49,92.29 117.61,92.41 117.61,92.67 117.49,92.79 117.42,92.79 117.3,92.92 117.3,93.17 117.42,93.3 117.49,93.3 117.61,93.43 117.61,93.68 117.49,93.81 117.42,93.81 117.3,93.94 117.3,94.19 117.42,94.32 117.49,94.32 117.61,94.44 117.61,94.7 117.49,94.83 117.42,94.83 117.3,94.95 117.3,95.21 117.42,95.33 117.49,95.33 117.61,95.46 117.61,95.71 117.49,95.84 117.42,95.84 117.3,95.97 117.3,96.22 117.42,96.35 117.49,96.35 117.61,96.48 117.61,96.73 117.49,96.86 117.42,96.86 117.3,96.98 117.3,97.24 117.42,97.37 117.49,97.37 117.61,97.49 117.61,97.75 117.49,97.87 117.42,97.87 117.3,98 117.3,98.25 117.42,98.38 117.49,98.38 117.61,98.51 117.61,98.76 117.49,98.89 117.42,98.89 117.3,99.02 117.3,99.78
  BOTTOM w0.114: JDIM1.57 118.04,67.38 v1(118.71,66.72) ; U35.AT61 v2(121.69,111.79)
M_B_DQ25: length 54.7
  IN2 w0.076: 117.94,99.13 117.94,99.26 117.82,99.39 117.82,99.91 119.39,101.48 119.39,104.95 119.85,105.41 119.85,107.95 121.42,109.52 121.42,110.24 121.69,110.51 v2(121.69,111.12)
  IN2 w0.127: v1(118.71,65.4) 119.16,65.85 119.16,67.96 117.63,69.49 117.63,71.56 117.94,71.88 117.94,76.76 117.82,76.89 117.75,76.89 117.63,77.02 117.63,77.27 117.75,77.4 117.82,77.4 117.94,77.53 117.94,77.78 117.82,77.91 117.75,77.91 117.63,78.03 117.63,78.29 117.75,78.42 117.82,78.42 117.94,78.54 117.94,78.8 117.82,78.92 117.75,78.92 117.63,79.05 117.63,79.3 117.75,79.43 117.82,79.43 117.94,79.56 117.94,79.81 117.82,79.94 117.75,79.94 117.63,80.07 117.63,80.32 117.75,80.45 117.82,80.45 117.94,80.57 117.94,80.83 117.82,80.96 117.75,80.96 117.63,81.08 117.63,81.34 117.75,81.46 117.82,81.46 117.94,81.59 117.94,81.84 117.82,81.97 117.75,81.97 117.63,82.1 117.63,82.35 117.75,82.48 117.82,82.48 117.94,82.61 117.94,82.86 117.82,82.99 117.75,82.99 117.63,83.11 117.63,83.37 117.75,83.5 117.82,83.5 117.94,83.62 117.94,99.13
  BOTTOM w0.114: U35.AU61 v2(121.69,111.12) ; JDIM1.59 118.64,67.39 119.21,66.82 119.21,65.91 v1(118.71,65.4)
M_B_DQ26: length 57.9
  IN2 w0.076: 123.25,109.33 123.25,111.27 123,111.53 123,112.67 v2(122.62,113.06)
  IN2 w0.127: 123.25,109.33 121.57,107.65 121.57,100.7 120.46,99.59 120.46,71.78 120.89,71.34 120.89,69.7 122.01,68.59 122.01,64.5 120.48,62.98 120.48,61.21 120.61,61.08 121.16,61.08 121.29,61.21 v1(121.29,61.66)
  BOTTOM w0.114: v1(121.29,61.66) 121.34,61.6 JDIM1.68 ; U35.AP60 v2(122.62,113.06)
M_B_DQ27: length 58.1
  IN2 w0.076: 123.36,109.04 123.53,109.22 123.53,111.25 123.16,111.62 123.16,113.16 v2(122.62,113.71)
  IN2 w0.127: 123.36,109.04 121.88,107.56 121.88,100.53 120.87,99.51 120.87,72 121.37,71.49 121.37,69.7 122.43,68.63 122.43,63.01 122.03,62.61 121.84,62.61 v1(121.29,63.16)
  BOTTOM w0.114: v2(122.62,113.71) U35.AN60 ; JDIM1.70 121.94,62.5 v1(121.29,63.16)
M_B_DQ28: length 57.6
  IN2 w0.076: 116.71,100.36 118.12,101.77 118.12,105.2 118.91,105.99 118.91,107.89 120.93,109.91 120.93,111.41 121.14,111.62 121.14,113.3 121.57,113.73 v2(121.68,113.73)
  IN2 w0.127: v1(117.9,61.68) 117.42,61.68 117.14,61.96 117.14,64.01 117.74,64.62 117.74,67.97 116.64,69.08 116.64,100.29 116.71,100.36
  BOTTOM w0.114: U35.AN61 v2(121.68,113.73) ; v1(117.9,61.68) 117.74,61.53 JDIM1.56
M_B_DQ29: length 56.9
  IN2 w0.076: 116.97,100.11 116.97,100.33 118.29,101.65 118.29,105.12 119.09,105.91 119.09,107.82 121.09,109.82 121.09,111.32 121.31,111.54 121.31,112.96 121.44,113.09 v2(121.69,113.09)
  IN2 w0.127: v1(117.94,63.2) 117.69,63.2 117.49,63.39 117.49,63.89 118.12,64.51 118.12,68.07 116.97,69.22 116.97,100.11
  BOTTOM w0.114: JDIM1.58 118.34,63.07 118.22,63.2 v1(117.94,63.2) ; U35.AP61 v2(121.69,113.09)
M_B_DQ30: length 57
  IN2 w0.076: 120.13,98.88 120.13,99.34 120.15,99.36 120.15,99.72 121.37,100.93 121.37,107.84 123,109.47 123,111.27 122.62,111.66 v2(122.62,111.75)
  IN2 w0.127: v1(121.29,66.98) 121.41,66.98 121.58,67.14 121.58,68.14 120.13,69.59 120.13,72.68 120,72.81 119.93,72.81 119.8,72.94 119.8,73.19 119.93,73.32 120,73.32 120.13,73.44 120.13,73.7 120,73.82 119.93,73.82 119.8,73.95 119.8,74.21 119.93,74.33 120,74.33 120.13,74.46 120.13,74.71 120,74.84 119.93,74.84 119.8,74.97 119.8,75.22 119.93,75.35 120,75.35 120.13,75.48 120.13,75.73 120,75.86 119.93,75.86 119.8,75.98 119.8,76.24 119.93,76.36 120,76.36 120.13,76.49 120.13,76.75 120,76.87 119.93,76.87 119.8,77 119.8,77.25 119.93,77.38 120,77.38 120.13,77.51 120.13,77.76 120,77.89 119.93,77.89 119.8,78.02 119.8,78.27 119.93,78.4 120,78.4 120.13,78.52 120.13,78.78 120,78.9 119.93,78.9 119.8,79.03 119.8,79.29 119.93,79.41 120,79.41 120.13,79.54 120.13,79.79 120,79.92 119.93,79.92 119.8,80.05 119.8,80.3 119.93,80.43 120,80.43 120.13,80.56 120.13,80.81 120,80.94 119.93,80.94 119.8,81.06 119.8,81.32 119.93,81.44 120,81.44 120.13,81.57 120.13,81.83 120,81.95 119.93,81.95 119.8,82.08 119.8,82.33 119.93,82.46 120,82.46 120.13,82.59 120.13,82.84 120,82.97 119.93,82.97 119.8,83.1 119.8,83.35 119.93,83.48 120,83.48 120.13,83.6 120.13,83.86 120,83.98 119.93,83.98 119.8,84.11 119.8,84.37 119.93,84.49 120,84.49 120.13,84.62 120.13,84.87 120,85 119.93,85 119.8,85.13 119.8,85.38 119.93,85.51 120,85.51 120.13,85.64 120.13,85.89 120,86.02 119.93,86.02 119.8,86.14 119.8,86.4 119.93,86.52 120,86.52 120.13,86.65 120.13,86.91 120,87.03 119.93,87.03 119.8,87.16 119.8,87.41 119.93,87.54 120,87.54 120.13,87.67 120.13,87.92 120,88.05 119.93,88.05 119.8,88.18 119.8,88.43 119.93,88.56 120,88.56 120.13,88.68 120.13,88.94 120,89.06 119.93,89.06 119.8,89.19 119.8,89.45 119.93,89.57 120,89.57 120.13,89.7 120.13,89.95 120,90.08 119.93,90.08 119.8,90.21 119.8,90.46 119.93,90.59 120,90.59 120.13,90.72 120.13,90.97 120,91.1 119.93,91.1 119.8,91.22 119.8,91.48 119.93,91.6 120,91.6 120.13,91.73 120.13,91.99 120,92.11 119.93,92.11 119.8,92.24 119.8,92.49 119.93,92.62 120,92.62 120.13,92.75 120.13,93 120,93.13 119.93,93.13 119.8,93.26 119.8,93.51 119.93,93.64 120,93.64 120.13,93.76 120.13,94.02 120,94.14 119.93,94.14 119.8,94.27 119.8,94.53 119.93,94.65 120,94.65 120.13,94.78 120.13,98.88
  BOTTOM w0.114: JDIM1.67 121.04,67.48 121.29,67.23 v1(121.29,66.98) ; U35.AT60 v2(122.62,111.75)
M_B_DQ31: length 56.9
  IN2 w0.076: v2(122.62,111.1) 122.62,109.52 121.07,107.97 121.07,101.01 119.82,99.77 119.7,99.77 119.47,99.54 119.47,99.31
  IN2 w0.127: 119.47,99.31 119.47,98.86 119.6,98.73 119.67,98.73 119.8,98.61 119.8,98.35 119.67,98.22 119.6,98.22 119.47,98.1 119.47,97.84 119.6,97.72 119.67,97.72 119.8,97.59 119.8,97.34 119.67,97.21 119.6,97.21 119.47,97.08 119.47,96.83 119.6,96.7 119.67,96.7 119.8,96.57 119.8,96.32 119.67,96.19 119.6,96.19 119.47,96.07 119.47,95.81 119.6,95.68 119.67,95.68 119.8,95.56 119.8,95.3 119.67,95.18 119.6,95.18 119.47,95.05 119.47,69.79 120.77,68.49 120.77,64.99 120.87,64.89 121.16,64.89 121.29,65.02 v1(121.29,65.37)
  BOTTOM w0.114: U35.AU60 v2(122.62,111.1) ; JDIM1.69 121.64,67.54 122.28,66.91 122.28,64.66 122.15,64.53 121.42,64.53 121.29,64.66 v1(121.29,65.37)
M_B_DQ32: length 56.7
  IN2 w0.076: 136.99,100.78 136.35,101.42 136.35,106.31 135.98,106.68 135.98,107.61 134.24,109.34 134.15,109.34 133.6,109.89 v2(133.6,111.15)
  IN2 w0.127: 136.99,100.78 137.01,100.78 138.83,98.95 139.1,98.95 139.73,98.32 139.73,92.34 140.11,91.96 140.11,79.56 144.14,75.53 144.14,66.32 143.87,66.05 143.87,63.06 v1(142.57,61.76)
  BOTTOM w0.114: v1(142.57,61.76) 142.34,61.54 JDIM1.130 ; v2(133.6,111.15) 134.03,111.43 U35.AU40
M_B_DQ33: length 57.7
  IN2 w0.076: v2(133.6,111.8) 133.22,111.42 133.22,108.89 136.18,105.94 136.18,101.3 137.24,100.24
  IN2 w0.127: v1(142.57,63.11) 142.68,63.11 143.5,63.93 143.5,66.23 143.81,66.54 143.81,75.39 139.78,79.42 139.78,91.83 139.4,92.21 139.4,98.29 138.96,98.74 138.74,98.74 137.24,100.24
  BOTTOM w0.114: JDIM1.132 142.94,61.4 143.09,61.55 143.09,62.73 142.72,63.11 v1(142.57,63.11) ; U35.AT40 134.03,112.08 v2(133.6,111.8)
M_B_DQ34: length 58
  IN2 w0.076: v2(135.47,111.75) 135.85,111.37 135.85,110.1 136.49,109.47 136.72,109.47 140.17,106.02 140.17,100.48 140.53,100.13 141.13,100.13 142.26,99 142.26,98.88
  IN2 w0.127: 142.26,98.88 142.26,97.29 142.35,97.2 142.35,93.45 143.01,92.79 143.01,84.25 143.19,84.07 143.19,80.14 146.66,76.67 146.66,67.45 147.09,67.02 147.09,64.29 v1(146.26,63.46)
  BOTTOM w0.114: v2(135.47,111.75) U35.AT37 ; JDIM1.140 145.34,62.55 v1(146.26,63.46)
M_B_DQ35: length 57.5
  IN2 w0.076: v2(135.47,111.06) 135.47,110.24 136.49,109.22 136.74,109.22 138.56,107.4 138.56,106.47 139.92,105.11 139.92,100.51 140.46,99.96 140.92,99.96 141.93,98.95 141.93,98.88
  IN2 w0.127: 141.93,98.88 141.93,97.15 142.02,97.06 142.02,93.31 142.68,92.65 142.68,87.45 142.35,87.12 142.35,83.94 142.48,83.82 142.74,83.82 142.86,83.69 142.86,83.43 142.74,83.31 142.48,83.31 142.35,83.18 142.35,82.93 142.48,82.8 142.74,82.8 142.86,82.67 142.86,82.42 142.74,82.29 142.48,82.29 142.35,82.16 142.35,81.91 142.48,81.78 142.74,81.78 142.86,81.66 142.86,81.4 142.74,81.28 142.48,81.28 142.35,81.15 142.35,80.89 142.48,80.77 142.74,80.77 142.86,80.64 142.86,80 146.33,76.53 146.33,67.3 146.76,66.87 146.76,65.84 v1(146.31,65.39)
  BOTTOM w0.114: JDIM1.143 146.24,67.35 146.76,66.83 146.76,65.84 v1(146.31,65.39) ; v2(135.47,111.06) U35.AU37
M_B_DQ36: length 58.4
  IN2 w0.076: 136.72,100.45 136.02,101.16 136.02,105.87 133.06,108.83 133.06,111.89 v1(133.6,112.43)
  IN2 w0.127: v1(142.56,65.53) 142.94,65.53 143.17,65.76 143.17,66.37 143.48,66.68 143.48,75.25 139.07,79.66 139.07,83.8 139.2,83.93 139.32,83.93 139.45,84.05 139.45,84.31 139.32,84.43 139.2,84.43 139.07,84.56 139.07,84.81 139.2,84.94 139.32,84.94 139.45,85.07 139.45,85.32 139.32,85.45 139.2,85.45 139.07,85.58 139.07,85.83 139.2,85.96 139.32,85.96 139.45,86.08 139.45,86.34 139.32,86.47 139.2,86.47 139.07,86.59 139.07,86.92 139.2,87.05 139.32,87.05 139.45,87.18 139.45,87.43 139.32,87.56 139.2,87.56 139.07,87.69 139.07,87.94 139.2,88.07 139.32,88.07 139.45,88.19 139.45,91.56 139.07,91.94 139.07,98.32 138.87,98.52 138.65,98.52 136.72,100.45
  BOTTOM w0.114: U35.AR40 133.6,112.45 v1(133.6,112.43) ; JDIM1.129 142.04,67.32 141.95,67.22 141.95,65.78 142.2,65.53 v1(142.56,65.53)
M_B_DQ37: length 58.8
  IN2 w0.076: v2(133.6,113.1) 132.49,113.1 132.3,112.9 132.3,109.35 135.85,105.8 135.85,100.61 136.26,100.2
  IN2 w0.127: 136.26,100.2 136.67,100.2 138.74,98.13 138.74,91.14 138.87,91.01 138.99,91.01 139.12,90.89 139.12,90.63 138.99,90.51 138.87,90.51 138.74,90.38 138.74,90.13 138.87,90 138.99,90 139.12,89.87 139.12,89.62 138.99,89.49 138.87,89.49 138.74,89.36 138.74,89.11 138.87,88.98 138.99,88.98 139.12,88.86 139.12,88.6 138.99,88.47 138.87,88.47 138.74,88.35 138.74,78.88 140.41,77.21 140.59,77.21 140.73,77.35 140.91,77.35 141.09,77.17 141.09,76.99 140.95,76.85 140.95,76.67 141.13,76.49 141.31,76.49 141.45,76.63 141.63,76.63 141.81,76.45 141.81,76.27 141.67,76.13 141.67,75.95 141.85,75.77 142.03,75.77 142.17,75.91 142.35,75.91 142.53,75.73 142.53,75.55 142.39,75.41 142.39,75.23 143.15,74.48 143.15,69.23 143.02,69.1 142.86,69.1 142.74,68.97 142.74,68.72 142.86,68.59 143.02,68.59 143.15,68.46 143.15,68.21 143.02,68.08 142.86,68.08 142.74,67.96 142.74,67.7 142.86,67.57 143.02,67.57 143.15,67.45 143.15,67.17 142.92,66.94 v1(142.57,66.94)
  BOTTOM w0.114: v2(133.6,113.1) U35.AP40 ; JDIM1.131 142.64,67.02 v1(142.57,66.94)
M_B_DQ38: length 59.5
  IN2 w0.076: 141.24,98.88 141.24,98.95 140.56,99.63 140.32,99.63 139.41,100.55 139.41,105.15 138.14,106.42 138.14,107.18 137.63,107.69 137.5,107.69 134.92,110.28 134.92,112.51 v2(135.47,113.06)
  IN2 w0.127: v1(146.26,61.94) 145.79,61.94 145.63,62.1 145.63,63.46 146.34,64.17 146.34,64.73 145.87,65.21 145.87,66.64 145.67,66.84 145.67,76.26 141.69,80.24 141.69,92.71 141.36,93.04 141.36,96.79 141.27,96.88 141.27,98.85 141.24,98.88
  BOTTOM w0.114: v2(135.47,113.06) U35.AP37 ; v1(146.26,61.94) 145.94,61.62 JDIM1.142
M_B_DQ39: length 59.3
  IN2 w0.076: 141.6,98.88 141.39,99.08 141.34,99.08 140.63,99.8 140.39,99.8 139.66,100.53 139.66,105.13 138.39,106.4 138.39,107.31 136.74,108.96 136.49,108.96 135.08,110.37 135.08,112.02 v2(135.47,112.41)
  IN2 w0.127: v1(146.31,66.66) 146,66.97 146,76.4 142.02,80.37 142.02,87.51 142.15,87.64 142.23,87.64 142.35,87.76 142.35,88.02 142.23,88.15 142.15,88.15 142.02,88.27 142.02,88.6 142.15,88.73 142.23,88.73 142.35,88.86 142.35,89.11 142.23,89.24 142.15,89.24 142.02,89.36 142.02,89.62 142.15,89.75 142.23,89.75 142.35,89.87 142.35,90.13 142.23,90.25 142.15,90.25 142.02,90.38 142.02,90.63 142.15,90.76 142.23,90.76 142.35,90.89 142.35,91.14 142.23,91.27 142.15,91.27 142.02,91.4 142.02,91.65 142.15,91.78 142.23,91.78 142.35,91.9 142.35,92.16 142.23,92.29 142.15,92.29 142.02,92.41 142.02,92.84 141.69,93.17 141.69,96.92 141.6,97.02 141.6,98.88
  BOTTOM w0.114: v1(146.31,66.66) 146.06,66.66 145.88,66.49 145.88,65.07 145.8,64.99 145.41,64.99 145.29,65.11 145.29,66.76 145.64,67.12 JDIM1.141 ; v2(135.47,112.41) U35.AR37
M_B_DQ40: length 60
  IN2 w0.076: v2(137.25,111.77) 137.36,111.77 137.71,111.43 137.71,109.42 140.49,106.63 141.44,106.63 141.87,106.21 142.5,106.21 142.84,105.87 142.84,100.07 143.89,99.02 143.89,98.88
  IN2 w0.127: v1(148.02,61.89) 148.94,62.81 148.94,67.47 148.55,67.86 148.55,77.11 145.32,80.34 145.32,82.38 145.19,82.5 145.07,82.5 144.95,82.63 144.95,82.88 145.07,83.01 145.19,83.01 145.32,83.14 145.32,83.39 145.19,83.52 145.07,83.52 144.95,83.65 144.95,83.9 145.07,84.03 145.19,84.03 145.32,84.15 145.32,84.38 144.69,85.01 144.69,85.69 144.82,85.81 145.19,85.81 145.32,85.94 145.32,93.01 143.98,94.35 143.98,97.87 143.89,97.97 143.89,98.88
  BOTTOM w0.114: v1(148.02,61.89) 147.74,61.61 JDIM1.148 ; v2(137.25,111.77) U35.AT33
M_B_DQ41: length 59.6
  IN2 w0.076: 143.56,98.88 141.82,100.61 141.82,105.93 141.28,106.47 140.42,106.47 137.25,109.65 v2(137.25,111.12)
  IN2 w0.127: v1(148.02,63.16) 148.61,63.75 148.61,67.33 148.22,67.72 148.22,73.66 148.01,73.87 148.01,77.18 144.61,80.58 144.61,84.58 144.36,84.83 144.36,86.37 144.49,86.49 144.86,86.49 144.99,86.62 144.99,86.87 144.86,87 144.49,87 144.36,87.13 144.36,87.38 144.49,87.51 144.86,87.51 144.99,87.64 144.99,87.89 144.86,88.02 144.49,88.02 144.36,88.14 144.36,88.47 144.95,89.06 144.95,92.91 143.65,94.21 143.65,97.73 143.56,97.83 143.56,98.88
  BOTTOM w0.114: v2(137.25,111.12) U35.AU33 ; JDIM1.146 147.14,62.28 v1(148.02,63.16)
M_B_DQ42: length 59
  IN2 w0.076: v2(139.05,111.11) 139.05,110.59 139.41,110.23 139.41,109.91 141.48,107.83 141.48,107.61 142.39,106.7 142.7,106.7 143.38,106.02 143.38,105.33 144.8,103.92 144.8,100.53 145.57,99.75 145.57,98.88
  IN2 w0.127: 145.57,98.88 145.57,94.9 146.84,93.63 146.84,80.96 150.45,77.34 v1(150.45,66.9)
  BOTTOM w0.114: v1(150.45,66.9) 151.24,66.9 151.6,66.54 151.6,64.65 151.47,64.52 151.09,64.52 150.96,64.65 150.96,65.65 150.79,65.83 149.9,65.83 149.69,66.04 149.69,67.15 149.82,67.28 150.17,67.28 150.44,67.55 JDIM1.157 ; v2(139.05,111.11) U35.AU30
M_B_DQ43: length 60
  IN2 w0.076: v2(139.05,111.76) 139.05,111.64 139.59,111.11 139.59,109.96 141.65,107.9 141.65,107.68 142.46,106.87 142.77,106.87 143.65,105.98 143.65,105.3 145.12,103.83 145.12,100.58 145.9,99.81 145.9,98.88
  IN2 w0.127: 145.9,98.88 145.9,95.08 147.17,93.81 147.17,81.1 150.78,77.48 150.78,67.54 151.02,67.31 151.02,65.83 150.58,65.4 v1(150.46,65.4)
  BOTTOM w0.114: v2(139.05,111.76) U35.AT30 ; v1(150.46,65.4) 150.46,64.13 150.71,63.88 151.6,63.88 151.98,64.26 151.98,66.67 151.04,67.61 JDIM1.159
M_B_DQ44: length 60.3
  IN2 w0.076: v2(137.25,112.42) 137.02,112.42 136.86,112.26 136.86,110.42 137.05,110.24 137.05,109.61 140.38,106.28 141.24,106.28 141.57,105.95 141.57,100.63 143.23,98.97 143.23,98.88
  IN2 w0.127: 143.23,98.88 143.23,97.69 143.32,97.6 143.32,93.85 143.98,93.19 143.98,92.78 144.11,92.65 144.49,92.65 144.61,92.52 144.61,92.27 144.49,92.14 144.11,92.14 143.98,92.01 143.98,91.76 144.11,91.63 144.49,91.63 144.61,91.51 144.61,91.25 144.49,91.13 144.11,91.13 143.98,91 143.98,90.74 144.11,90.62 144.49,90.62 144.61,90.49 144.61,90.24 144.49,90.11 144.11,90.11 143.98,89.98 143.98,89.7 144.11,89.58 144.49,89.58 144.61,89.45 144.61,89.19 144.49,89.07 144.11,89.07 143.98,88.94 143.98,84.65 144.28,84.34 144.28,80.44 147.63,77.1 147.63,73.28 147.89,73.02 147.89,69.72 147.82,69.64 147.82,67.66 147.89,67.59 147.89,67.58 148.17,67.31 v1(148.17,66.13)
  BOTTOM w0.114: JDIM1.147 147.44,67.3 147.39,67.24 147.39,67.05 147.66,66.77 147.66,66.47 147.39,66.19 147.39,65.74 147.54,65.59 147.73,65.59 148.17,66.03 v1(148.17,66.13) ; v2(137.25,112.42) U35.AR33
M_B_DQ45: length 61.7
  IN2 w0.076: v2(137.25,113.07) 136.7,112.52 136.7,110.35 136.88,110.17 136.88,109.54 140.31,106.12 140.97,106.12 141.31,105.77 141.31,100.58 142.9,99 142.9,98.88
  IN2 w0.127: 142.89,98.88 142.89,97.55 142.99,97.46 142.99,93.71 143.65,93.05 143.65,84.51 143.88,84.28 143.88,80.35 147.3,76.93 147.3,71.38 147.56,71.12 147.56,69.93 147.3,69.66 147.3,67.71 147.56,67.45 147.56,67.45 147.72,67.28 147.72,64.83 147.95,64.6 v1(148.17,64.6)
  BOTTOM w0.114: v1(148.17,64.6) 148.51,64.26 148.93,64.26 149.19,64.51 149.19,65.71 149.07,65.83 148.71,65.83 148.59,65.94 148.59,66.17 148.71,66.29 149.07,66.29 149.19,66.4 149.19,66.63 149.07,66.74 148.71,66.74 148.59,66.86 148.59,67.14 148.48,67.26 148.17,67.26 148.04,67.38 JDIM1.149 ; v2(137.25,113.07) U35.AP33
M_B_DQ46: length 59.9
  IN2 w0.076: v2(139.05,112.41) 139.43,112.02 139.43,111.53 139.81,111.15 139.81,109.97 141.81,107.97 141.81,107.81 142.6,107.03 142.84,107.03 143.97,105.9 143.97,105.29 145.38,103.88 145.38,100.56 146.23,99.71 146.23,98.88
  IN2 w0.127: v1(151.23,63.08) 151.6,63.45 151.6,64.56 151.47,64.69 151.14,64.69 151.02,64.82 151.02,65.07 151.14,65.2 151.47,65.2 151.6,65.33 151.6,67.28 151.11,67.77 151.11,77.62 147.5,81.23 147.5,93.95 146.23,95.22 146.23,98.88
  BOTTOM w0.114: JDIM1.158 150.74,61.46 150.46,61.75 150.46,62.86 150.67,63.08 v1(151.23,63.08) ; v2(139.05,112.41) U35.AR30
M_B_DQ47: length 60.4
  IN2 w0.076: v2(139.05,113.06) 139.59,112.51 139.59,111.6 139.99,111.2 139.99,110.03 141.98,108.04 141.98,107.88 142.65,107.21 142.89,107.21 144.21,105.89 144.21,105.28 145.63,103.86 145.63,100.54 146.56,99.61 146.56,98.88
  IN2 w0.127: v1(151.24,61.72) 151.24,61.34 151.37,61.21 151.73,61.21 151.93,61.41 151.93,67.42 151.45,67.9 151.45,77.75 147.83,81.37 147.83,94.09 146.56,95.36 146.56,98.88
  BOTTOM w0.114: v1(151.24,61.72) 151.34,61.62 JDIM1.160 ; v2(139.05,113.06) U35.AP30
M_B_DQ48: length 61.3
  IN2 w0.076: v2(140.9,111.12) 140.9,110.05 141.4,109.55 142.24,109.55 143.85,107.95 143.85,107.31 145.14,106.03 145.14,105.97 146.65,104.46 146.65,100.96 148.18,99.42 148.18,98.87
  IN2 w0.127: 148.18,98.87 148.18,96.03 149.45,94.76 149.45,82.04 153.21,78.28 v1(153.21,71.37)
  BOTTOM w0.114: JDIM1.163 152.24,70.98 151.73,71.5 151.73,72.64 151.85,72.77 152.1,72.77 152.21,72.65 152.21,71.87 152.32,71.75 152.55,71.75 152.67,71.87 152.67,72.65 152.78,72.77 153.01,72.77 153.12,72.65 153.12,72.12 153.24,72 153.47,72 153.58,72.12 153.58,72.65 153.7,72.77 153.96,72.77 154.08,72.65 154.08,72.12 154.19,72 154.42,72 154.53,72.12 154.53,72.65 154.65,72.77 155.03,72.77 155.28,72.51 155.28,71.62 155.21,71.55 153.39,71.55 v1(153.21,71.37) ; v2(140.9,111.12) U35.AU27
M_B_DQ49: length 60.9
  IN2 w0.076: 147.85,99.37 146.39,100.83 146.39,104.26 144.97,105.69 144.97,105.94 143.56,107.35 143.56,107.91 142.08,109.39 141.33,109.39 140.5,110.22 140.5,111.26 140.9,111.66 v2(140.9,111.77)
  IN2 w0.127: v1(153.69,62.95) 154.16,62.95 154.32,63.11 154.32,64.46 153.89,64.89 153.89,65.11 153.28,65.72 153.28,66.65 153.4,66.78 153.76,66.78 153.89,66.91 153.89,67.16 153.76,67.29 153.4,67.29 153.28,67.41 153.28,68.17 152.74,68.7 152.74,68.98 152.87,69.11 153.05,69.11 153.17,69.23 153.17,69.49 153.05,69.62 152.87,69.62 152.74,69.74 152.74,78.29 149.12,81.91 149.12,94.63 147.85,95.9 147.85,99.37
  BOTTOM w0.114: JDIM1.164 152.54,61.46 153.12,62.04 153.12,62.39 v1(153.69,62.95) ; v2(140.9,111.77) U35.AT27
M_B_DQ50: length 59.1
  IN2 w0.076: 147.41,104.08 147.41,105.54 145.86,107.08 145.86,107.43 144.08,109.22 143.73,109.22 142.33,110.62 142.33,111.28 v2(141.83,111.77)
  IN2 w0.127: 147.41,104.08 147.41,101.68 150.03,99.07 150.03,96.8 151.8,95.02 151.8,83.69 155.14,80.35 155.14,69.03 156.35,67.82 156.35,63.71 v1(154.96,62.32)
  BOTTOM w0.114: JDIM1.174 155.54,61.74 v1(154.96,62.32) ; v2(141.83,111.77) U35.AT25
M_B_DQ51: length 58.4
  IN2 w0.076: v2(141.83,111.12) 141.83,110.88 143.74,108.97 144.09,108.97 145.7,107.36 145.7,107.01 147.2,105.52 147.2,101.43 149.34,99.28
  IN2 w0.127: 149.34,99.28 149.69,98.93 149.69,96.66 151.47,94.88 151.47,82.44 154.81,79.1 154.81,68.89 156.02,67.68 156.02,65.14 v1(154.98,64.1)
  BOTTOM w0.114: v1(154.98,64.1) 155.01,64.1 155.73,63.38 155.73,62.48 156.14,62.06 JDIM1.176 ; v2(141.83,111.12) U35.AU25
M_B_DQ52: length 61.2
  IN2 w0.076: v2(140.9,113.07) 140.52,112.69 140.52,111.51 140.34,111.33 140.34,110.15 141.27,109.22 142.02,109.22 143.27,107.96 143.27,107.39 144.81,105.86 144.81,105.47 146.14,104.14 146.14,100.62 147.52,99.23 147.52,98.88
  IN2 w0.127: 147.52,98.88 147.52,95.76 148.79,94.49 148.79,81.77 152.41,78.15 152.41,68.48 152.95,67.95 152.95,65.4 153.07,65.27 153.25,65.27 153.38,65.15 153.38,64.89 153.25,64.77 153.07,64.77 152.95,64.64 152.95,64.31 153.12,64.13 153.6,64.13 v1(153.69,64.22)
  BOTTOM w0.114: v2(140.9,113.07) U35.AP27 ; JDIM1.165 152.84,65.07 v1(153.69,64.22)
M_B_DQ53: length 61.8
  IN2 w0.076: v2(140.9,113.72) 140.36,113.17 140.36,111.59 140.17,111.4 140.17,110.08 141.2,109.05 141.95,109.05 143.1,107.9 143.1,107.23 144.52,105.82 144.52,105.25 145.88,103.88 145.88,100.58 147.19,99.27 147.19,98.88
  IN2 w0.127: v1(153.69,61.67) 152.87,61.67 152.62,61.93 152.62,62.26 152.74,62.38 152.9,62.38 153.02,62.51 153.02,62.76 152.9,62.89 152.74,62.89 152.62,63.02 152.62,67.81 152.08,68.35 152.08,78.01 148.46,81.63 148.46,94.35 147.19,95.62 147.19,98.88
  BOTTOM w0.114: v2(140.9,113.72) U35.AN27 ; v1(153.69,61.67) 153.39,61.67 153.14,61.43 JDIM1.166
M_B_DQ54: length 61.3
  IN2 w0.076: 147.92,103.87 147.92,105.5 146.19,107.22 146.19,107.57 144.14,109.63 143.79,109.63 143.1,110.31 143.1,112.57 142.51,113.15 142.4,113.15 v2(141.83,113.73)
  IN2 w0.127: 147.92,103.87 147.92,102.44 150.69,99.67 150.69,97.07 152.62,95.14 152.62,84.2 155.92,80.89 155.92,69.19 157.06,68.04 157.06,66.16 157.22,66 v1(157.53,66)
  BOTTOM w0.114: v2(141.83,113.73) U35.AN25 ; v1(157.53,66) 156.8,65.27 156.44,65.27 156.16,65.55 156.16,65.91 156.28,66.02 156.82,66.02 156.93,66.13 156.93,66.48 156.82,66.59 156.28,66.59 156.16,66.71 156.16,67.02 156.44,67.31 JDIM1.177
M_B_DQ55: length 60.6
  IN2 w0.076: 147.66,104.14 147.66,105.52 146.03,107.15 146.03,107.5 144.07,109.46 143.72,109.46 142.51,110.67 142.51,111.35 142.25,111.6 142.25,112.65 v2(141.83,113.08)
  IN2 w0.127: v1(157.53,64.73) 156.68,65.58 156.68,67.96 155.47,69.16 155.47,80.49 152.29,83.68 152.29,95 150.36,96.93 150.36,99.53 147.66,102.23 147.66,104.14
  BOTTOM w0.114: v2(141.83,113.08) U35.AP25 ; v1(157.53,64.73) 156.54,64.73 155.84,65.42 JDIM1.175
M_B_DQ56: length 61.7
  IN2 w0.076: 147.07,107.18 146.69,107.56 146.69,107.78 144.79,109.67 144.79,110.28 144.11,110.97 144.11,111.32 v2(144.54,111.75)
  IN2 w0.127: v1(158.89,66.85) 158.51,66.85 158.36,67 158.36,68.58 157.21,69.73 157.21,72 157.34,72.13 157.44,72.13 157.57,72.25 157.57,72.51 157.44,72.63 157.34,72.63 157.21,72.76 157.21,73.02 157.34,73.14 157.44,73.14 157.57,73.27 157.57,73.52 157.44,73.65 157.34,73.65 157.21,73.78 157.21,74.03 157.34,74.16 157.44,74.16 157.57,74.29 157.57,74.54 157.44,74.67 157.34,74.67 157.21,74.79 157.21,75.05 157.34,75.17 157.44,75.17 157.57,75.3 157.57,75.56 157.44,75.68 157.34,75.68 157.21,75.81 157.21,76.06 157.34,76.19 157.44,76.19 157.57,76.32 157.57,76.57 157.44,76.7 157.34,76.7 157.21,76.83 157.21,77.16 157.34,77.28 157.52,77.28 157.65,77.41 157.65,77.66 157.52,77.79 157.34,77.79 157.21,77.92 157.21,78.17 157.34,78.3 157.52,78.3 157.65,78.43 157.65,78.68 157.52,78.81 157.34,78.81 157.21,78.93 157.21,79.5 157.34,79.62 157.44,79.62 157.57,79.75 157.57,80.01 157.44,80.13 157.34,80.13 157.21,80.26 157.21,80.51 157.34,80.64 157.44,80.64 157.57,80.77 157.57,81.28 156.84,82 156.84,82.18 156.91,82.25 156.91,82.43 156.73,82.61 156.55,82.61 156.48,82.54 156.3,82.54 156.12,82.72 156.12,82.9 156.19,82.97 156.19,83.15 156.01,83.33 155.83,83.33 155.76,83.26 155.58,83.26 155.4,83.44 155.4,83.62 155.47,83.69 155.47,83.87 155.29,84.05 155.11,84.05 155.04,83.98 154.86,83.98 154.68,84.16 154.68,84.34 154.75,84.41 154.75,84.59 154.57,84.77 154.39,84.77 154.33,84.7 154.15,84.7 153.91,84.93 153.91,86.03 154.07,86.19 154.07,86.53 153.91,86.7 153.91,87.04 154.07,87.2 154.07,87.55 153.91,87.71 153.91,88.06 154.07,88.22 154.07,88.57 153.91,88.73 153.91,89.07 154.07,89.24 154.07,89.58 153.91,89.74 153.91,90.94 154.07,91.11 154.07,91.45 153.91,91.61 153.91,91.96 154.07,92.12 154.07,92.47 153.91,92.63 153.91,92.98 154.07,93.14 154.07,93.48 153.91,93.65 153.91,93.99 154.07,94.15 154.07,94.5 153.91,94.66 153.91,96.49 151.98,98.42 151.98,100.83 148.89,103.92 148.89,105.36 147.07,107.18
  BOTTOM w0.114: JDIM1.183 158.24,67.34 157.96,67.06 157.96,66.73 158.25,66.44 158.48,66.44 v1(158.89,66.85) ; v2(144.54,111.75) U35.AT22
M_B_DQ57: length 61.9
  IN2 w0.127: v2(144.54,111.1) 145,110.64 145,109.74 146.03,108.71 146.75,108.71 147.79,107.67 147.79,107.13 149.11,105.81 149.11,104.34 152.31,101.13 152.31,98.75 154.4,96.66 154.4,85.41 157.98,81.84 157.98,71.22 157.57,70.81 157.57,69.84 158.71,68.69 158.71,67.8 159.35,67.16 159.35,65.99 v1(158.89,65.53)
  BOTTOM w0.114: v1(158.89,65.53) 159.01,65.4 160.12,65.4 160.24,65.29 160.24,64.51 159.98,64.26 158.33,64.26 157.95,64.64 157.95,66.29 157.64,66.59 JDIM1.181 ; v2(144.54,111.1) U35.AU22
M_B_DQ58: length 60.2
  IN2 w0.127: v1(160.98,66.76) 160.98,67.87 160.58,68.27 160.58,69.01 159.72,69.88 159.72,70.21 159.5,70.43 159.5,70.72 159.72,70.94 159.72,71.23 159.5,71.44 159.5,71.74 159.72,71.95 159.72,72.24 159.5,72.46 159.5,72.75 159.72,72.97 159.72,73.26 159.5,73.48 159.5,73.77 159.72,73.98 159.72,74.28 159.5,74.49 159.5,74.78 159.72,75 159.72,75.29 159.5,75.51 159.5,75.8 159.72,76.02 159.72,76.31 159.5,76.52 159.5,76.82 159.72,77.03 159.72,77.32 159.5,77.54 159.5,77.83 159.72,78.05 159.72,78.34 159.5,78.56 159.5,78.85 159.72,79.06 159.72,79.36 159.5,79.57 159.5,79.86 159.72,80.08 159.72,80.37 159.5,80.59 159.5,80.88 159.72,81.1 159.72,82.28 155.91,86.09 155.91,97.29 154.9,98.3 154.9,99.99 154.46,100.43 154.08,100.43 153.95,100.56 153.95,100.81 154.08,100.94 154.46,100.94 154.58,101.07 154.58,101.32 154.46,101.45 154.08,101.45 153.95,101.58 153.95,101.83 154.08,101.96 154.46,101.96 154.58,102.08 154.58,102.34 154.46,102.47 154.08,102.47 153.95,102.59 153.95,102.85 154.08,102.97 154.46,102.97 154.58,103.1 154.58,103.82 150.2,108.2 148.68,108.2 147.31,109.57 146.27,109.57 145.76,110.08 145.76,111.12 145.46,111.42 v2(145.46,111.76)
  BOTTOM w0.114: JDIM1.191 160.64,67.1 v1(160.98,66.76) ; v2(145.46,111.76) U35.AU21
M_B_DQ59: length 61
  IN2 w0.076: v2(145.46,112.41) 145.84,112.03 145.84,111.4 146.44,110.8 146.61,110.8 146.8,110.61
  IN2 w0.127: v1(162.01,62.99) 161.51,63.5 161.51,65.27 161.43,65.35 161.43,68.01 160.93,68.5 160.93,69.17 160.06,70.04 160.06,82.4 156.24,86.22 156.24,97.43 155.47,98.2 155.47,103.69 150.58,108.58 148.83,108.58 146.8,110.61
  BOTTOM w0.114: v2(145.46,112.41) U35.AT21 ; v1(162.01,62.99) 161.36,62.34 161.36,61.49 161.54,61.3 JDIM1.194
M_B_DQ60: length 63.7
  IN2 w0.076: v2(144.54,113.64) 143.27,112.37 143.27,111.24 144.34,110.17 144.34,109.66 146.36,107.64 146.36,107.29 148.3,105.35 148.3,105.15
  IN2 w0.127: 148.3,105.15 148.3,103.49 151.32,100.47 151.32,98.14 153.25,96.22 153.25,84.46 156.55,81.16 156.55,69.45 157.7,68.31 157.7,66.67 158.09,66.27 158.09,63.99 158.95,63.13 158.95,62.86 158.77,62.68 158.23,62.68 158.08,62.84 158.08,63.11 157.76,63.44 v1(157.53,63.44)
  BOTTOM w0.114: v2(144.54,113.64) U35.AN22 ; v1(157.53,63.44) 157.97,62.99 157.97,61.34 157.94,61.31 JDIM1.182
M_B_DQ61: length 63.5
  IN2 w0.076: 148.58,104.92 148.58,105.3 146.52,107.36 146.52,107.71 144.51,109.73 144.51,110.24 143.73,111.02 143.73,112.19 v1(144.54,113)
  IN2 w0.127: 148.58,104.92 148.58,103.77 151.65,100.69 151.65,98.28 153.58,96.35 153.58,84.8 156.88,81.49 156.88,69.59 158.03,68.44 158.03,66.81 158.44,66.39 158.44,64.11 159.28,63.27 159.28,61.4 159.09,61.21 158.76,61.21 158.64,61.34 158.64,61.59 158.51,61.72 158.25,61.72 158.13,61.59 158.13,61.34 158,61.21 157.65,61.21 157.52,61.34 v1(157.52,61.72)
  BOTTOM w0.114: v1(157.52,61.72) 157.34,61.54 JDIM1.180 ; v1(144.54,113) U35.AP22
M_B_DQ62: length 62.3
  IN2 w0.076: 146.47,111.18 146.34,111.18 146.01,111.5 146.01,113.13 v2(145.46,113.68)
  IN2 w0.127: 146.47,111.18 146.72,111.18 148.93,108.96 150.67,108.96 155.83,103.8 155.83,98.31 156.57,97.56 156.57,86.36 160.39,82.54 160.39,70.18 160.65,69.93 160.82,69.93 161.03,70.14 161.21,70.14 161.39,69.96 161.39,69.78 161.18,69.57 161.18,69.39 161.36,69.21 161.54,69.21 161.75,69.42 161.93,69.42 162.11,69.24 162.11,69.06 161.9,68.85 161.9,68.67 162.65,67.92 162.65,65.78 162.39,65.53 162.13,65.53 162,65.65 v1(162,65.91)
  BOTTOM w0.114: v2(145.46,113.68) U35.AP21 ; v1(162,65.91) 162,66.18 161.46,66.72 161.46,67 161.24,67.21 JDIM1.193
M_B_DQ63: length 63.9
  IN2 w0.127: v1(162.01,64.38) 162.98,65.35 162.98,68.84 160.73,71.09 160.73,82.68 156.9,86.5 156.9,97.7 156.24,98.37 156.24,103.86 150.63,109.47 149.94,109.47 148.95,110.46 147.92,110.46 146.85,111.53 146.85,113.32 146.35,113.82 146.11,113.82 145.62,114.3 v2(145.46,114.3)
  BOTTOM w0.114: v2(145.46,114.3) U35.AN21 ; JDIM1.192 160.94,63.32 v1(162.01,64.38)
M_B_DQS0: length 75.2
  IN2 w0.127: v1(119.76,117.03) 119.63,116.9 119.63,116.51 119.41,116.29 117.52,116.29 117.11,115.88 117.11,115.02 115.69,113.6 110.21,113.6 109.33,112.72 109.33,111.46 103.7,105.82 103.7,98.53 104.62,97.61 104.62,97.23 104.23,96.83 104.23,96.6 104.45,96.38 104.68,96.38 105.07,96.78 105.45,96.78 106.39,95.84 106.39,82.39 106.76,82.03 106.76,69.3 109.91,66.14 109.91,64.99 v1(109,64.07)
  BOTTOM w0.114: U35.AH65 v1(119.76,117.03) ; JDIM1.29 109.64,66.73 109.92,66.46 109.92,65.67 110.68,64.91 110.68,64.45 110.38,64.15 109.08,64.15 v1(109,64.07)
M_B_DQS1: length 77.2
  IN2 w0.127: v1(104.36,63.31) 103.77,62.72 103.52,62.72 103.37,62.87 103.37,66.42 99.78,70 99.78,72.15 99.91,72.28 100.33,72.28 100.6,72.54 100.6,73.12 100.33,73.39 99.91,73.39 99.78,73.52 99.78,86.98 99.47,87.3 99.47,107.45 105.17,113.15 105.17,115.25 109.15,119.24 113.37,119.24 113.44,119.17 113.47,119.17 113.56,119.08 113.56,118.92 v1(113.38,118.75)
  BOTTOM w0.076: U35.AG70 116.96,117.32 116.76,117.32 116.55,117.42 116.46,117.42 116.32,117.36 115.95,117.36 115.26,118.04 114.19,118.04 113.87,118.36 113.77,118.36 v1(113.38,118.75)
  BOTTOM w0.114: JDIM1.12 104.54,61.38 104.86,61.7 104.86,62.8 v1(104.36,63.31)
M_B_DQS2: length 64.7
  IN2 w0.076: 119.62,110.46 119.57,110.51 119.57,110.77 119.52,110.82 119.52,111.45 119.45,111.52 119.45,112.01 v2(119.82,112.38)
  IN2 w0.127: v1(115.21,66.22) 115.21,65.52 115.06,65.37 114.84,65.37 114.58,65.63 114.58,67.48 113.24,68.82 113.24,82.42 112.46,83.21 112.46,89.88 112.59,90 113.1,90 113.37,90.27 113.37,90.85 113.1,91.12 112.59,91.12 112.46,91.25 112.46,91.63 112.59,91.75 113.1,91.75 113.37,92.02 113.37,92.6 113.1,92.87 112.59,92.87 112.46,93 112.46,93.38 112.59,93.51 113.1,93.51 113.37,93.78 113.37,94.36 113.1,94.63 112.59,94.63 112.46,94.75 112.46,95.13 112.59,95.26 113.1,95.26 113.37,95.53 113.37,96.11 113.1,96.38 112.59,96.38 112.46,96.5 112.46,97.14 114.35,99.03 114.35,102.86 114.13,103.08 114.13,106.32 115.51,107.69 115.89,107.69 116.6,108.4 116.6,109.34 117.16,109.9 118.05,109.9 118.33,109.62 119.16,109.62 119.62,110.08 119.62,110.46
  BOTTOM w0.114: v2(119.82,112.38) U35.AR65 ; v1(115.21,66.22) 115.21,65.65 115.09,65.53 114.96,65.53 114.79,65.7 114.57,65.92 114.57,67.11 114.7,67.25 114.96,67.25 115.04,67.34 JDIM1.47
M_B_DQS3: length 56.7
  IN2 w0.076: 118.83,98.88 118.84,98.89 118.84,98.89 118.81,98.93 118.81,99.62 120.23,101.05 120.23,107.84 120.59,108.2 120.74,108.2 122.39,109.85 122.39,110.68 122.24,110.83 122.24,112.24 122.4,112.4 v5(122.59,112.4)
  IN2 w0.127: v1(119.12,63.46) 119.04,63.46 118.87,63.62 118.87,64.03 120.09,65.25 120.09,68.27 118.5,69.85 118.5,71.17 118.83,71.5 118.83,98.88
  BOTTOM w0.114: JDIM1.64 120.14,61.33 119.95,61.52 119.88,61.6 119.88,62.8 119.58,63.09 119.3,63.09 119.12,63.27 v1(119.12,63.46) ; U35.AR60 v5(122.59,112.4)
M_B_DQS4: length 58.2
  IN2 w0.076: 140.28,98.73 140.28,98.77 139.67,99.37 138.68,99.37 137.87,100.18 137.87,101.44 138.23,101.79 138.23,105.44 136.99,106.68 136.99,107.69 133.99,110.7 133.99,111.81 134.53,112.36 v2(134.53,112.42)
  IN2 w0.127: v1(144.47,65.34) 144.68,65.13 144.85,65.13 144.99,65.28 144.99,66.28 144.77,66.49 144.77,75.92 140.75,79.95 140.75,92.23 140.37,92.61 140.37,98.64 140.28,98.73
  BOTTOM w0.114: v1(144.47,65.34) 144.47,65.3 144.25,65.08 144.13,65.08 144.01,65.2 144.01,66.93 144.44,67.37 JDIM1.137 ; U35.AR38 134.95,112.53 134.84,112.42 v2(134.53,112.42)
M_B_DQS5: length 59.8
  IN2 w0.076: 144.86,98.98 144.4,99.44 144.29,99.44 143.22,100.51 143.22,105.95 142.63,106.54 142.16,106.54 141.16,107.54 141.16,107.54 140.25,108.45 140.25,108.45 140.21,108.49 139.91,108.49 138.59,109.81 138.59,110.55 138.67,110.63 138.67,111.99 138.48,112.17 138.31,112.17 138.11,112.38 v2(138.11,112.39)
  IN2 w0.127: 144.86,98.98 144.86,94.71 146.2,93.36 146.2,80.7 149.43,77.47 149.43,70.42 149.82,70.03 149.82,64.93 150.7,64.05 150.7,63.08 150.42,62.8 150.14,62.8 v1(149.95,62.61)
  BOTTOM w0.114: JDIM1.154 149.54,61.34 149.29,61.59 149.29,62.46 149.43,62.61 v1(149.95,62.61) ; v2(138.11,112.39) U35.AR32
M_B_DQS6: length 60
  IN2 w0.076: v2(140.9,112.42) 141.13,112.42 141.28,112.26 141.28,110.9 144.15,108.03 144.44,108.03 144.85,107.62 144.85,107.39 146.87,105.38 146.87,101.22 148.82,99.27 148.82,98.62
  IN2 w0.127: v1(154.55,66.61) 154.92,66.24 155.05,66.24 155.15,66.34 155.15,67.32 153.94,68.53 153.94,78.46 150.09,82.31 150.09,86.21 150.36,86.48 150.47,86.48 150.6,86.6 150.6,86.98 150.47,87.11 150.36,87.11 150.09,87.38 150.09,87.96 150.36,88.23 150.47,88.23 150.6,88.36 150.6,88.74 150.47,88.86 150.36,88.86 150.09,89.13 150.09,89.71 150.36,89.98 150.47,89.98 150.6,90.11 150.6,90.49 150.47,90.62 150.36,90.62 150.09,90.89 150.09,91.47 150.36,91.73 150.47,91.73 150.6,91.86 150.6,92.24 150.47,92.37 150.36,92.37 150.09,92.64 150.09,93.22 150.36,93.49 150.47,93.49 150.6,93.61 150.6,93.99 150.47,94.12 150.36,94.12 150.09,94.39 150.09,95.03 148.82,96.3 148.82,98.62
  BOTTOM w0.114: JDIM1.171 154.64,67.35 154.52,67.23 154.26,67.23 154.21,67.17 154.2,67.17 153.86,66.83 153.86,66.34 153.97,66.23 154.17,66.23 v1(154.55,66.61) ; U35.AR27 141.35,112.55 141.22,112.42 v2(140.9,112.42)
M_B_DQS7: length 61.8
  IN2 w0.076: v2(145.46,113.03) 145.08,112.65 145.08,111.27 145.38,110.97 145.38,110.14 146.3,109.22 146.91,109.22 148.26,107.86 148.26,107.75 148.29,107.73 148.29,107.72
  IN2 w0.127: v1(159.92,62.54) 160.11,62.73 160.49,62.73 160.79,63.04 160.79,63.68 160.25,64.22 160.25,67.68 159.72,68.22 159.72,68.98 158.86,69.83 158.86,82.19 155.28,85.77 155.28,97.03 153.19,99.12 153.19,101.92 149.96,105.15 149.96,105.83 148.29,107.5 148.29,107.72
  BOTTOM w0.114: JDIM1.188 159.74,61.4 159.37,61.77 159.37,62.56 159.52,62.71 159.75,62.71 v1(159.92,62.54) ; v2(145.46,113.03) 145.04,112.73 U35.AR21
M_B_DQS#0: length 75.2
  IN2 w0.127: v1(109,65.37) 109.4,64.97 109.56,64.97 109.67,65.09 109.67,66.04 106.51,69.2 106.51,81.93 106.15,82.29 106.15,95.74 105.35,96.54 105.17,96.54 104.78,96.14 104.35,96.14 103.99,96.5 103.99,96.93 104.38,97.33 104.38,97.51 103.45,98.43 103.45,105.92 109.09,111.56 109.09,112.82 110.11,113.84 115.59,113.84 116.87,115.12 116.87,115.98 117.42,116.53 119.31,116.53 119.39,116.61 119.39,116.74 v1(119.11,117.03)
  BOTTOM w0.114: v1(109,65.37) 109.43,64.94 109.43,64.55 109.6,64.38 110.28,64.38 110.45,64.55 110.45,64.82 109.69,65.58 109.69,66.37 109.42,66.64 109.42,67.15 109.29,67.27 109.16,67.27 109.04,67.39 JDIM1.27 ; U35.AH66 v1(119.11,117.03)
M_B_DQS#1: length 77.1
  IN2 w0.127: v1(114.02,118.74) 113.8,118.96 113.8,119.15 113.78,119.17 113.47,119.48 109.05,119.48 104.93,115.35 104.93,113.25 99.23,107.55 99.23,87.2 99.54,86.88 99.54,73.42 99.81,73.15 100.23,73.15 100.36,73.02 100.36,72.64 100.23,72.52 99.81,72.52 99.54,72.25 99.54,69.9 103.12,66.32 103.12,62.77 103.42,62.48 103.84,62.48 v1(104.36,61.96)
  BOTTOM w0.076: v1(114.02,118.74) 114.02,118.44 114.26,118.21 115.33,118.21 116.02,117.52 116.28,117.52 116.43,117.59 116.59,117.59 116.8,117.49 117.27,117.49 117.73,117.03 U35.AG69
  BOTTOM w0.114: JDIM1.10 103.94,61.55 v1(104.36,61.96)

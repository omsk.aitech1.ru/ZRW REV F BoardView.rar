# Allegro board Quanta ZRW REV F - BoardView (.BRD).brd (continued)
## Footprints (pads in the part's own frame, mm; a bottom-side part is the same pattern mirrored in y, then rotated) (continued)
SOT23-2_8-95-6P
  rect 1.346x0.508 smd: 1(1.325,-0.95) 2(1.325,0) 3(1.325,0.95) 4(-1.325,0.95) 5(-1.325,0) 6(-1.325,-0.95)
SOT23-5
  rect 1.016x0.711 smd: 1(1.2,-0.95) 2(1.2,0) 3(1.2,0.95) 4(-1.2,0.95) 5(-1.2,-0.95)
SOT23_123-2_8-1_9
  rect 1.092x0.533 smd: 1(1.45,-0.95) 2(1.45,0.95) 3(-1.45,0)
SOT23_213-3_3-2
  rect 1.27x1.016 smd: 1(1.016,1.016) 2(1.016,-1.016) 3(-1.016,0)
SOT323_213-2_1-1_3-2N7002W
  rect 0.787x0.61 smd: 1(0.8,0.65) 2(0.8,-0.65) 3(-0.8,0)
SOT353-1-2_125-65-5P
  rect 1.245x0.279 smd: 1(1.045,-0.65) 2(1.045,0) 3(1.045,0.65) 4(-1.045,0.65) 5(-1.045,-0.65)
SPAD-ZRZ-1NP
  custom 0.025x0.025 smd: 1(0,0)
SSOP5-P-A-TOSHIBA-B
  rect 1.067x0.305 smd: 1(0.85,-0.65) 2(0.85,0) 3(0.85,0.65) 4(-0.85,0.65) 5(-0.85,-0.65)
SW-TME-533B-Q-TR-6P
  rect 1.803x1.092 smd: 1(-3.1,1.85) 2(3.1,1.85) 3(-3.1,-1.85) 4(3.1,-1.85)
  rect 0.991x0.61 smd: 5(0,2.5) 6(0,-2.5)
TP2050
  round 0.508 smd: 1(0,0)
TP2650
  round 0.66 smd: 1(0,0)
TP2675
  round 0.66 smd: 1(0,0)
TRF-N1010G-25P
  rect 0.635x1.778 smd: 1(-5.5,-4.54) 2(-4.5,-4.54) 3(-3.5,-4.54) 4(-2.5,-4.54) 5(-1.5,-4.54) 6(-0.5,-4.54) 7(0.5,-4.54) 8(1.5,-4.54) 9(2.5,-4.54) 10(3.5,-4.54) 11(4.5,-4.54) 12(5.5,-4.54) 13(5.5,4.45) 14(4.5,4.45) 15(3.5,4.45) 16(2.5,4.45) 17(1.5,4.45) 18(0.5,4.45) 19(-0.5,4.45) 20(-1.5,4.45) 21(-2.5,4.45) 22(-3.5,4.45) 23(-4.5,4.45) 24(-5.5,4.45)
  rect 0.889x0.787 smd: 25(-6.82,0)
TSOP6-2_8-95
  rect 0.787x0.635 smd: 1(1.2,-0.95) 2(1.2,0) 3(1.2,0.95) 4(-1.2,0.95) 5(-1.2,0) 6(-1.2,-0.95)
TSSOP28-6_4-65-SLB9635TT
  rect 0.406x1.295 smd: 1(-4.225,-3.05) 2(-3.575,-3.05) 3(-2.925,-3.05) 4(-2.275,-3.05) 5(-1.625,-3.05) 6(-0.975,-3.05) 7(-0.325,-3.05) 8(0.325,-3.05) 9(0.975,-3.05) 10(1.625,-3.05) 11(2.275,-3.05) 12(2.925,-3.05) 13(3.575,-3.05) 14(4.225,-3.05) 15(4.225,3.05) 16(3.575,3.05) 17(2.925,3.05) 18(2.275,3.05) 19(1.625,3.05) 20(0.975,3.05) 21(0.325,3.05) 22(-0.325,3.05) 23(-0.975,3.05) 24(-1.625,3.05) 25(-2.275,3.05) 26(-2.925,3.05) 27(-3.575,3.05) 28(-4.225,3.05)
UMT_213-3-1_3
  rect 1.016x0.762 smd: 1(0.991,0.66) 2(0.991,-0.66) 3(-0.991,0)
unnamed
  round 1.016 smd: 1(0,0)
USB-2UB4029-200201F-9P-SMT
  round 1.295 hole 0.813: 1(3.5,10.2) 2(1,10.2) 3(-1,10.2) 4(-3.5,10.2) 5(-4,8.7) 6(-2,8.7) 7(0,8.7) 8(2,8.7) 9(4,8.7)
  oval 1.295x2.896 hole 0.711x2.311: 10(6.4,9.45) 11(-6.4,9.45)
  oval 1.295x2.108 hole 0.711x1.499: 12(-7.85,3) 13(7.85,0)
WDFN5-3_05X3_05-65
  rect 0.66x0.432 smd: 1(1.385,-0.975) 2(1.385,-0.325) 3(1.385,0.325) 4(1.385,0.975)
  custom 0.575x0.575 smd: 5(-0.735,0)
XTL-3_2X1_5-2_5-0_8H
  rect 0.991x1.803 smd: 1(-1.25,0) 2(1.25,0)
XTL-3_2X2_5-2_2X1_7
  rect 1.397x1.194 smd: 1(-1.1,-0.85) 2(1.1,-0.85) 3(1.1,0.85) 4(-1.1,0.85)
XTL-3_2X2_5-2_2X1_7-4P
  rect 1.397x1.194 smd: 1(1.1,0.85) 2(-1.1,0.85) 3(-1.1,-0.85) 4(1.1,-0.85)

## Nets
1.5VGFX_AGND: PC195.1 PC199.1 PR69.1 PR256.2 PR260.1 PR346.2 PU11.14
1.5VGFX_BST: PR250.1 PU11.10
1.5VGFX_BST1: PC191.1 PR250.2
1.5VGFX_EN: PC199.2 PR73.2 PR75.2 PU11.13
1.5VGFX_FB: PR256.1 PR259.2 PU11.12
1.5VGFX_PG: PR252.2 PU11.4
1.5VGFX_SW: PC191.2 PL9.1 PR68.1 PU11.8 PU11.9 PU11.15 PU11.16
2.469V: PR144.2 PR145.1 PU4.3
3V_LDO: PC6098.1 PR6280.1 PU6010.3
3V_MAIN_PWGD: PR307.2 PR343.1 Q6.3 R88.2 R90.1
5VMCU: R203.1 U13.38
51211V_DRVH: PQ30.1 PU12.9
51211V_DRVL: PQ30.8 PU12.6
51211V_EN: PR72.2 PR254.2 PU12.3
51211V_FB: PR66.1 PR251.2 PU12.4
51211V_SW: PC196.2 PL11.1 PQ30.9 PR76.1 PU12.8
51211V_TRIP: PR74.2 PU12.2
51211V_TST: PR71.2 PU12.5
51211V_VBST: PR258.2 PU12.10
+1.5V: C384.1 C385.1 C409.1 C410.1 C474.1 C541.2 C759.2 C773.1 L18.2 PC259.1 PC261.1 PC265.2 PL16.2 PR328.1 Q29.2 Q38.1 R366.2 R683.2 R712.1 U18.12 U18.19 U18.20 U18.31 U18.40
+1.5V_GFX: C11.2 C14.2 C15.2 C17.1 C18.1 C19.1 C20.2 C21.1 C22.2 C23.2 C24.2 C25.1 C26.1 C28.1 C31.2 C32.1 C36.1 C38.2 C39.2 C40.1 C42.2 C43.1 C44.2 C45.1 C46.1 C47.1 C48.2 C49.1 C50.1 C51.1 C52.1 C53.1 C54.1 C55.1 C56.2 C57.2 C58.2 C59.1 C60.2 C61.2 C62.2 C66.2 C67.1 C68.1 C69.2 C70.2 C71.2 C73.2 C74.2 C75.1 C81.2 C82.2 C83.2 C84.2 C94.1 C95.2 C98.2 C99.2 C100.2 C101.1 C102.2 C103.1 C104.1 C105.1 C106.2 C107.1 C108.2 C110.1 C122.2 C557.2 C558.1 C559.1 C560.1 C561.2 C562.2 C563.2 C564.1 C565.1 C566.1 C567.1 C568.1 C569.2 C570.2 C571.2 C572.2 C573.2 C574.1 C575.2 C576.2 C579.2 C582.1 C583.2 C584.1 C585.1 C586.1 C587.1 C588.1 C592.2 C593.2 C594.2 C595.1 C596.1 C597.2 C598.1 C600.2 C601.1 C603.1 C604.1 C606.1 C608.2 C611.2 C612.1 C613.2 C614.1 C615.2 C616.2 C617.2 C618.2 C619.2 C620.2 C621.2 C622.2 C623.2 C624.1 C625.1 C630.1 C631.1 C633.2 C634.2 C635.2 C636.2 C637.2 PC176.2 PC179.2 PC182.2 PC186.2 PC187.2 PC193.2 PL9.2 PR259.1 PU11.7 R17.2 R20.2 R23.2 R25.2 R26.2 R29.2 R32.2 R33.2 R36.2 R39.2 R42.2 R46.2 R48.2 R51.2 R56.2 R57.2 R61.2 R63.2 R76.2 R80.1 R84.1 R87.1 R446.2 R452.2 R456.2 R459.2 R462.2 R466.2 R472.2 U2.A1 U2.A8 U2.B2 U2.C1 U2.C9 U2.D2 U2.D9 U2.E9 U2.F1 U2.G7 U2.H2 U2.H9 U2.K2 U2.K8 U2.N1 U2.N9 U2.R1 U2.R9 U3.A1 U3.A8 U3.B2 U3.C1 U3.C9 U3.D2 U3.D9 U3.E9 U3.F1 U3.G7 U3.H2 U3.H9 U3.K2 U3.K8 U3.N1 U3.N9 U3.R1 U3.R9 U4.A1 U4.A8 U4.B2 U4.C1 U4.C9 U4.D2 U4.D9 U4.E9 U4.F1 U4.G7 U4.H2 U4.H9 U4.K2 U4.K8 U4.N1 U4.N9 U4.R1 U4.R9 U5.A1 U5.A8 U5.B2 U5.C1 U5.C9 U5.D2 U5.D9 U5.E9 U5.F1 U5.G7 U5.H2 U5.H9 U5.K2 U5.K8 U5.N1 U5.N9 U5.R1 U5.R9 U28.A1 U28.A8 U28.B2 U28.C1 U28.C9 U28.D2 U28.D9 U28.E9 U28.F1 U28.G7 U28.H2 U28.H9 U28.K2 U28.K8 U28.N1 U28.N9 U28.R1 U28.R9 U29.A1 U29.A8 U29.B2 U29.C1 U29.C9 U29.D2 U29.D9 U29.E9 U29.F1 U29.G7 U29.H2 U29.H9 U29.K2 U29.K8 U29.N1 U29.N9 U29.R1 U29.R9 U31.A1 U31.A8 U31.B2 U31.C1 U31.C9 U31.D2 U31.D9 U31.E9 U31.F1 U31.G7 U31.H2 U31.H9 U31.K2 U31.K8 U31.N1 U31.N9 U31.R1 U31.R9 U32.A1 U32.A8 U32.B2 U32.C1 U32.C9 U32.D2 U32.D9 U32.E9 U32.F1 U32.G7 U32.H2 U32.H9 U32.K2 U32.K8 U32.N1 U32.N9 U32.R1 U32.R9 U34.B26 U34.C25 U34.E23 U34.E26 U34.F14 U34.F21 U34.G13 U34.G14 U34.G15 U34.G16 U34.G18 U34.G19 U34.G20 U34.G21 U34.H24 U34.H26 U34.J21 U34.K21 U34.L22 U34.L24 U34.L26 U34.M21 U34.N21 U34.R21 U34.T21 U34.V21 U34.W21
+1.05V_GFX: C63.2 C64.1 C65.2 C72.1 C78.2 C87.1 C90.2 C91.1 C97.1 C111.2 C119.1 C121.1 C602.2 C605.1 L1.2 L2.1 L3.1 PC232.1 PC233.2 PL14.2 PR311.2 R72.1 U34.AA10 U34.AA12 U34.AA13 U34.AA16 U34.AA18 U34.AA19 U34.AA20 U34.AA21 U34.AA22 U34.AB22 U34.AB23 U34.AC23 U34.AC24 U34.AD24 U34.AD25 U34.AE25 U34.AE26 U34.AE27 U34.AF26 U34.AF27
+1.5V_GFX_VCC: PC195.2 PR255.2 PU11.11
+1.5VA: C520.1 C524.1 L18.1 U23.40
+1.8V_PRIM: C686.1 C687.1 R565.1 U35.G61 U35.H63
+1.8V_S5: PC175.2 PC183.1 PC184.1 PL6.2 PR246.1 R180.2 R192.2 R565.2 R590.2 R593.2 R599.2 R600.2 R607.2 R608.2 R611.2 R613.2 R615.2 R765.2 R767.2 R775.1
+1.35VSUS: C308.2 C311.2 C312.2 C313.2 C318.1 C323.1 C325.1 C326.1 C327.1 C328.1 C399.1 C400.1 C401.2 C402.2 C403.1 C404.2 C416.1 C418.2 C419.2 C420.2 C421.1 C430.2 C432.2 C433.1 C444.1 C445.2 C446.1 C447.1 C464.1 C466.1 C470.2 C471.2 C472.2 C486.1 JDIM1.75 JDIM1.76 JDIM1.81 JDIM1.82 JDIM1.87 JDIM1.88 JDIM1.93 JDIM1.94 JDIM1.99 JDIM1.100 JDIM1.105 JDIM1.106 JDIM1.111 JDIM1.112 JDIM1.117 JDIM1.118 JDIM1.123 JDIM1.124 JDIM2.75 JDIM2.76 JDIM2.81 JDIM2.82 JDIM2.87 JDIM2.88 JDIM2.93 JDIM2.94 JDIM2.99 JDIM2.100 JDIM2.105 JDIM2.106 JDIM2.111 JDIM2.112 JDIM2.117 JDIM2.118 JDIM2.123 JDIM2.124 PC235.2 PC268.2 PC275.1 PL15.2 PU15.2 PU15.9 Q35.2 R194.1 R309.2 R330.2 R358.2 R679.1 U35.AU23 U35.AU28 U35.AU35 U35.AU42 U35.BB23 U35.BB32 U35.BB41 U35.BB47 U35.BB51
+1V_S5: C173.2 C179.2 C182.2 C191.2 C192.2 C217.2 C225.2 C672.1 C680.1 C695.2 C698.2 C699.2 PC212.1 PC213.2 PL11.2 PQ23.3 PQ26.5 PR251.1 R153.2 R512.2 U35.A10 U35.A14 U35.AB17 U35.AB19 U35.AB20 U35.AF18 U35.AF19 U35.AF20 U35.AF21 U35.AK20 U35.K15 U35.K17 U35.K19 U35.L15 U35.L19 U35.L21 U35.N15 U35.N16 U35.N17 U35.N18 U35.N20 U35.P15 U35.P16 U35.P18 U35.T1 U35.T19 U35.T20 U35.V15 U35.V20 U35.V21 U35.Y18
+1V_S5_ON: PR254.1 U45.2
+1V_SUS: PC6230.2 PQ23.1 PR139.1 R112.2 R550.2
+1V_VCCST: C628.1 C677.2 C814.2 C815.2 C816.2 C817.2 C818.2 C819.2 PC6228.1 PR340.1 PR341.1 Q31.3 R85.2 R134.1 R138.1 R488.2 R513.2 R514.1 R515.1 R529.1 R538.1 R550.1 R559.1 R761.2 R788.1 U33.5 U35.A18
+3V: C41.1 C175.2 C177.2 C180.2 C332.2 C342.1 C353.1 C356.1 C360.1 C371.1 C373.1 C376.1 C386.1 C388.1 C390.1 C413.1 C439.1 C448.1 JDIM1.199 JDIM2.199 L4.1 PQ18.1 PQ18.2 PQ18.3 PR137.1 PR196.1 PR197.1 PR257.2 PR266.2 PR293.2 PR295.2 PR304.2 Q1.2 Q2.2 Q2.5 Q20.2 Q23.5 Q25.2 Q32.2 Q32.5 Q41.2 Q43.2 Q43.5 R7.2 R9.2 R11.1 R12.2 R19.1 R58.2 R81.2 R82.2 R110.2 R115.2 R152.2 R204.2 R207.1 R208.2 R209.2 R211.1 R215.2 R216.2 R218.1 R220.2 R223.2 R227.2 R228.2 R234.2 R237.2 R245.2 R257.1 R277.1 R281.1 R285.2 R286.1 R292.1 R293.1 R297.1 R298.1 R305.2 R306.2 R311.1 R318.1 R319.2 R321.1 R322.2 R324.1 R347.1 R361.1 R365.2 R367.2 R374.2 R378.1 R391.1 R426.2 R444.2 R448.1 R449.1 R485.1 R533.1 R561.1 R572.2 R573.2 R574.2 R575.2 R576.2 R577.2 R609.1 R618.2 R619.1 R625.1 R629.1 R630.1 R631.2 R639.1 R711.1 R722.1 R723.1 R745.1 R780.2 R781.2 R789.2 U1.4 U1.6 U7.5 U9.5 U10.5 U13.10 U13.14 U13.40 U14.5 U16.1 U16.6 U17.6 U18.11 U18.37
+3V3_TPM: C768.1 C774.1 C775.1 C776.1 R724.1 R727.1 R744.1 R745.2 U44.10 U44.19 U44.24
+3V3_TPM_VSB: C766.1 C767.1 R723.2 R725.1 U44.5
+3V_CR: C531.1 C539.2 R391.2 U26.4
+3V_EC: C482.1 R361.2 R779.2 U45.11
+3V_GFX: C117.1 C131.2 C132.1 C135.1 C138.1 C145.1 C167.1 PQ19.1 PR164.1 Q9.2 Q10.2 Q11.1 Q14.2 Q15.2 R90.2 R91.2 R93.2 R94.2 R95.2 R97.2 R99.2 R100.1 R101.1 R108.2 R111.2 R117.1 R118.1 R379.2 R382.2 R489.2 R498.2 R499.2 R500.2 R501.2 R506.2 R507.1 R508.1 R509.2 R511.2 R516.2 R518.2 R740.2 U34.AA8 U34.AA9 U34.AB8 U34.G10 U34.G12
+3V_LAN: Q24.3 R248.1
+3V_MAIN: C124.1 C127.1 C137.1 C143.1 Q11.3 Q13.2 Q13.5 R97.1 R104.2 R494.1 R495.1 R496.1 U34.G8 U34.G9
+3V_MAIN_EN: Q17.2 R118.2 U34.A3
+3V_PCH_ME: C741.1 C754.2 R232.2 R591.1 R597.1 R649.1 R698.2 R700.1 U39.8 U41.8
+3V_RTC: C381.1 D7.3 R249.2 R252.2 R299.1 R300.1 R719.1 R756.2
+3V_RTC_1: D7.1 R308.2
+3V_RTC_2: D7.2 R301.2 R304.1
+3V_S5: C164.2 C168.2 C763.1 C808.2 C811.2 C812.2 C813.2 L19.2 PQ37.1 PR124.1 PR244.2 PR292.2 PR333.2 PR338.1 R160.2 R165.2 R166.1 R167.1 R169.2 R177.2 R179.2 R182.2 R185.2 R186.2 R187.2 R188.2 R193.2 R195.1 R198.2 R205.2 R212.2 R240.2 R247.2 R250.2 R275.2 R280.2 R283.2 R290.2 R291.1 R402.1 R439.2 R440.2 R540.2 R541.2 R542.2 R543.2 R570.1 R578.1 R580.1 R582.1 R585.1 R586.1 R628.1 R651.1 R682.1 R697.2 R700.2 R705.2 R708.2 R716.1 R725.2 R733.2 R734.2 R779.1 U6.5 U8.5 U43.5 U47.5 U48.5 U49.5 U50.5
+3V_WLAN: Q22.3 Q38.3 R221.1
+3VPCU: C345.2 C369.2 C555.1 D12.1 PC246.1 PC249.1 PC6224.1 PC6225.2 PL6012.2 PQ18.5 PQ19.3 PQ37.3 PR9.2 PR14.2 PR16.2 PR125.1 PR179.2 PR312.1 PR6279.1 PR6284.1 PU16.9 PU16.10 Q22.1 Q24.1 R52.2 R53.1 R210.2 R231.1 R260.1 R271.2 R278.2 R304.2 R368.2 R388.1 R427.2 R428.2 R429.2 R434.2 R435.2 R436.2 R437.2 R438.2 R695.1 R730.2 R731.2 R732.2 R741.2 R747.1 R753.2 R757.2 RP1.2 RP1.10
+3VPCU_EC: C508.1 C514.1 C769.1 C770.1 C771.1 C777.1 C780.1 L12.1 L22.2 R747.2 U45.26 U45.50 U45.92 U45.106 U45.114 U45.121
+3VPCU_ECPLL: C772.1 L22.1 U45.127
+5V: C187.2 C321.2 C456.1 C515.2 C525.1 C713.2 C720.2 C809.1 C810.1 CN3.1 D30.2 D31.2 L16.1 PQ38.1 PQ38.2 PQ38.3 PR153.1 Q18.1 Q21.3 Q26.3 Q28.3 Q34.1 Q34.2 Q34.5 Q34.6 R16.1 R148.1 R200.1 R201.1 R338.2 R339.2 R343.2 R672.2 U12.2 U25.1 U25.3 U37.5 U40.5
+5V_HDD: C435.1 C436.1 C437.1 C438.1 C453.1 C457.1 CN14.14 CN14.15 CN14.16 R339.1
+5V_KB: C169.2 C170.2 Q18.3 R119.1
+5V_KB_R: CN6.2 CN6.4 R119.2
+5V_ODD: Q34.4 R657.2 R672.1 R673.1
+5V_PVDD: C500.1 C501.1 C509.1 C510.1 L13.2 U23.41 U23.46
+5V_S5: C424.1 C779.1 PQ34.1 PQ34.2 PQ34.3 PR53.1 PR54.1 PR55.1 PR56.1 PR99.1 PR204.1 PR339.1 U20.5 U46.5
+5VA: C523.2 C526.1 C532.1 C536.1 L16.2 R395.1 U23.26 U25.4
+5VODD: C721.1 C726.1 C730.1 C733.1 C737.1 C740.1 CN9.9 CN9.10 R657.1
+5VPCU: C483.1 PC194.2 PC242.2 PC6226.2 PC6227.1 PD6004.2 PL6013.1 PQ34.5 PQ38.5 PR6281.2 PR6290.2 PU12.7 PU15.12 PU6010.14 R356.1 R360.1 U22.1
+15V: PR143.1 PR148.1 PR161.1 PR334.1 PR6275.1 R345.1 R686.2
+15V_ALWP: PC6209.2 PD6008.1 PR6275.2
+A3VPCU: C495.1 L12.2 U45.74
+VCCATS_1P8: C250.1 R180.1 U35.AA1
+VCCCORE: C144.2 C150.2 C181.2 C184.2 C189.2 C196.2 C200.2 C201.2 C203.2 C209.2 C212.2 C214.2 C215.2 C219.2 C222.2 C224.2 C226.2 C227.2 C228.2 C233.2 C235.2 C236.2 C237.2 C243.2 C245.2 C246.2 C251.2 C252.2 C255.2 C257.1 C258.1 C259.1 C262.2 C269.2 C272.2 C273.2 C282.2 C285.2 C289.2 C645.2 C647.1 C650.2 C651.1 C657.1 C659.2 C663.1 C664.1 C666.2 C667.1 C673.1 C674.1 C675.1 C676.1 C678.1 C679.1 PC59.1 PC161.1 PC162.1 PC164.1 PC168.1 PL4.2 PR31.2 R96.1 U35.A30 U35.A34 U35.A39 U35.A44 U35.AK33 U35.AK35 U35.AK37 U35.AK38 U35.AK40 U35.AL33 U35.AL37 U35.AL40 U35.AM32 U35.AM33 U35.AM35 U35.AM37 U35.AM38 U35.G30 U35.G32 U35.G33 U35.G35 U35.G37 U35.G38 U35.G40 U35.G42 U35.J30 U35.J33 U35.J37 U35.J40 U35.K33 U35.K35 U35.K37 U35.K38 U35.K40 U35.K42 U35.K43
+VCCDSW_1P0: C712.1 U35.AL1
+VCCEOPIO: C708.1 C709.1 R794.2 U35.AE62 U35.AG62
+VCCGT: C148.1 C151.1 C155.1 C158.1 C161.1 C171.2 C178.2 C185.1 C186.1 C188.2 C190.2 C193.2 C194.2 C195.2 C197.2 C198.2 C199.2 C202.2 C204.2 C205.2 C206.2 C210.2 C218.1 C223.1 C232.1 C239.2 C240.2 C241.2 C248.2 C274.2 C275.2 C276.2 C277.2 C279.1 C280.1 C281.1 C290.1 C291.1 C302.2 C303.2 C307.2 C310.2 C316.1 C317.1 C324.1 C690.2 C691.2 C692.2 C693.2 C694.2 C696.2 C697.2 C702.2 C703.2 C704.2 C705.2 C706.2 C707.2 PC158.1 PC159.1 PC160.1 PC163.1 PC166.1 PC167.1 PC170.1 PC172.1 PL2.2 PL3.2 PR187.2 R155.1 U35.A48 U35.A53 U35.A58 U35.A62 U35.A66 U35.AA63 U35.AA64 U35.AA66 U35.AA67 U35.AA69 U35.AA70 U35.AA71 U35.AC64 U35.AC65 U35.AC66 U35.AC67 U35.AC68 U35.AC69 U35.AC70 U35.AC71 U35.AK42 U35.AK43 U35.AK45 U35.AK46 U35.AK48 U35.AK50 U35.AK52 U35.AK53 U35.AK55 U35.AK56 U35.AK58 U35.AK60 U35.AK70 U35.AL43 U35.AL46 U35.AL50 U35.AL53 U35.AL56 U35.AL60 U35.AM48 U35.AM50 U35.AM52 U35.AM53 U35.AM56 U35.AM58 U35.AU58 U35.AU63 U35.BB57 U35.BB66 U35.J43 U35.J45 U35.J46 U35.J48 U35.J50 U35.J52 U35.J53 U35.J55 U35.J56 U35.J58 U35.J60 U35.K48 U35.K50 U35.K52 U35.K53 U35.K55 U35.K56 U35.K58 U35.K60 U35.L62 U35.L63 U35.L64 U35.L65 U35.L66 U35.L67 U35.L68 U35.L69 U35.L70 U35.L71 U35.M62 U35.N63 U35.N64 U35.N66 U35.N67 U35.N69 U35.N70 U35.N71 U35.R63 U35.R64 U35.R65 U35.R66 U35.R67 U35.R68 U35.R69 U35.R70 U35.R71 U35.T62 U35.U65 U35.U68 U35.U71 U35.W63 U35.W64 U35.W65 U35.W66 U35.W67 U35.W68 U35.W69 U35.W70 U35.W71 U35.Y62
+VCCHDA: C748.2 R683.1 R789.1 U35.AJ19
+VCCIO: C264.2 C266.2 C283.1 C284.1 C297.2 C298.2 C700.2 C701.2 C710.2 C711.2 PC6231.2 PQ26.1 PQ26.2 PQ26.3 PR138.1 PR174.2 PR200.1 R135.2 R154.2 R465.2 R544.1 U35.AK28 U35.AK30 U35.AL30 U35.AL42 U35.AM28 U35.AM30 U35.AM42
+VCCOPC: C681.2 C682.1 C683.2 C684.2 C685.2 C688.2 C689.2 R172.2 R793.2 U35.AB62 U35.P62 U35.V62
+VCCOPC_EN: PR135.2 PR136.2 PU14.5
+VCCOPC_LP#: PR288.2 PU14.6
+VCCOPC_MODE: PR289.2 PU14.7
+VCCOPC_SRC: PR344.2 PU14.12 R633.1 R634.1
+VCCOPC_SW: PC231.2 PL13.1 PU14.8
+VCCOPC_VBST: PR291.1 PU14.9
+VCCOPC_VIN: JP16.2 PC99.1 PC100.2 PC228.1 PC229.1 PU14.1
+VCCPDSW_3P3: C314.1 R210.1 R212.1 U35.AD17 U35.AD18 U35.AJ17
+VCCPGPPA: C292.1 R198.1 U35.AK15
+VCCPGPPB: C268.1 R185.1 U35.AG15
+VCCPGPPC: C230.1 R182.1 U35.Y16
+VCCPGPPD: C265.1 R187.1 U35.Y15
+VCCPGPPE: C256.1 R179.1 U35.T16
+VCCPGPPF: R192.1 U35.AF16
+VCCPGPPG: C270.1 R188.1 U35.AD15
+VCCPLL: C172.2 R112.1 U35.K20 U35.K21
+VCCPRIM_3P3: C261.2 R186.1 U35.AJ21 U35.V19
+VCCPRTC: C322.1 C352.2 R252.1 U35.AK19 U35.BB14
+VCCPRTCPRIM_3P3: C348.2 C349.1 R240.1 U35.AK17
+VCCPSPI: R193.1 U35.AJ16
+VCCSA: C114.1 C157.1 C165.1 C207.2 C216.2 C221.1 C229.1 C238.1 C242.2 C247.1 C249.2 C254.1 C260.2 C263.1 C267.2 C278.2 C288.1 C641.1 C642.1 C643.1 PC165.1 PC169.1 PC171.1 PL5.2 PR51.2 R122.1 U35.AK23 U35.AK25 U35.G23 U35.G25 U35.G27 U35.G28 U35.J22 U35.J23 U35.J27 U35.K23 U35.K25 U35.K27 U35.K28 U35.K30
+VCCSTG: C174.2 C176.2 R135.1 U35.A22 U35.G20
+VDDQ: PC237.1 PU15.5
+VDDQ_VTT: C394.2 C395.1 C396.1 C414.2 C417.2 C426.1 C429.1 C434.1 C442.1 C449.2 C455.2 C463.2 C467.1 C468.1 JDIM1.203 JDIM1.204 JDIM2.203 JDIM2.204 PC234.1 PC236.1 PU15.1 PU15.3
+VDDQC: C286.1 C299.2 R194.2 U35.AL23 U35.AM40
AGND_DDR: PC237.2 PC238.2 PC239.2 PR149.2 PR296.1 PR299.1 PR300.2 PU15.7 PU15.21 PU15.22 PU15.23 PU15.24 PU15.25 PU15.26
DVDD_IO: C489.1 C492.1 R365.1 R366.1 U23.9
GND: BT1.2 C7.2 C9.1 C11.1 C14.1 C15.1 C16.1 C17.2 C18.2 C19.2 C20.1 C21.2 C22.1 C23.1 C24.1 C25.2 C26.2 C27.1 C28.2 C29.1 C30.2 C31.1 C32.2 C33.1 C34.2 C35.1 C36.2 C37.1 C38.1 C39.1 C40.2 C41.2 C42.1 C43.2 C44.1 C45.2 C46.2 C47.2 C48.1 C49.2 C50.2 C51.2 C52.2 C53.2 C54.2 C55.2 C56.1 C57.1 C58.1 C59.2 C60.1 C61.1 C62.1 C63.1 C64.2 C65.1 C66.1 C67.2 C68.2 C69.1 C70.1 C71.1 C72.2 C73.1 C74.1 C75.2 C76.1 C77.2 C78.1 C79.2 C80.2 C81.1 C82.1 C83.1 C84.1 C85.2 C86.1 C87.2 C88.1 C89.1 C90.1 C91.2 C92.2 C93.1 C94.2 C95.1 C96.1 C97.2 C98.1 C99.1 C100.1 C101.2 C102.1 C103.2 C104.2 C105.2 C106.1 C107.2 C108.1 C109.1 C110.2 C111.1 C112.1 C113.1 C114.2 C115.1 C116.1 C117.2 C118.1 C119.2 C120.1 C121.2 C122.1 C123.1 C124.2 C125.1 C126.1 C127.2 C128.1 C129.1 C130.1 C131.1 C132.2 C133.1 C134.2 C135.2 C136.1 C137.2 C138.2 C139.2 C140.1 C141.2 C142.1 C143.2 C144.1 C145.2 C146.1 C147.2 C148.2 C149.1 C150.1 C151.2 C152.1 C153.1 C154.1 C155.2 C156.1 C157.2 C158.2 C159.1 C160.1 C161.2 C162.2 C163.1 C164.1 C165.2 C166.2 C168.1 C169.1 C170.1 C171.1 C172.1 C173.1 C174.1 C175.1 C176.1 C177.1 C178.1 C179.1 C180.1 C181.1 C182.1 C184.1 C185.2 C186.2 C187.1 C188.1 C189.1 C190.1 C191.1 C192.1 C193.1 C194.1 C195.1 C196.1 C197.1 C198.1 C199.1 C200.1 C201.1 C202.1 C203.1 C204.1 C205.1 C206.1 C207.1 C209.1 C210.1 C212.1 C214.1 C215.1 C216.1 C217.1 C218.2 C219.1 C221.2 C222.1 C223.2 C224.1 C225.1 C226.1 C227.1 C228.1 C229.2 C230.2 C232.2 C233.1 C235.1 C236.1 C237.1 C238.2 C239.1 C240.1 C241.1 C242.1 C243.1 C245.1 C246.1 C247.2 C248.1 C249.1 C250.2 C251.1 C252.1 C254.2 C255.1 C256.2 C257.2 C258.2 C259.2 C260.1 C261.1 C262.1 C263.2 C264.1 C265.2 C266.1 C267.1 C268.2 C269.1 C270.2 C272.1 C273.1 C274.1 C275.1 C276.1 C277.1 C278.1 C279.2 C280.2 C281.2 C282.1 C283.2 C284.2 C285.1 C286.2 C288.2 C289.1 C290.2 C291.2 C292.2 C297.1 C298.1 C299.1 C300.1 C301.2 C302.1 C303.1 C304.1 C305.2 C306.1 C307.1 C308.1 C309.1 C310.1 C311.1 C312.1 C313.1 C314.2 C316.2 C317.2 C318.2 C319.1 C320.1 C321.1 C322.2 C323.2 C324.2 C325.2 C326.2 C327.2 C328.2 C330.2 C332.1 C333.1 C334.1 C336.1 C337.1 C338.1 C339.1 C340.2 C342.2 C344.1 C345.1 C346.1 C347.2 C348.1 C349.2 C350.1 C351.1 C352.1 C353.2 C354.2 C355.2 C356.2 C357.2 C358.2 C359.2 C360.2 C361.1 C362.1 C363.1 C364.1 C365.1 C366.2 C367.1 C368.1 C369.1 C370.2 C371.2 C373.2 C374.2 C376.2 C377.1 C378.2 C379.2 C380.2 C381.2 C382.2 C383.2 C384.2 C385.2 C386.2 C388.2 C390.2 C391.1 C392.2 C393.2 C394.1 C395.2 C396.2 C399.2 C400.2 C401.1 C402.1 C403.2 C404.1 C409.2 C410.2 C412.2 C413.2 C414.1 C415.1 C416.2 C417.1 C418.1 C419.1 C420.1 C421.2 C422.2 C423.2 C424.2 C425.1 C426.2 C428.2 C429.2 C430.1 C431.2 C432.1 C433.2 C434.2 C435.2 C436.2 C437.2 C438.2 C439.2 C440.1 C441.2 C442.2 C443.2 C444.2 C445.1 C446.2 C447.2 C448.2 C449.1 C450.1 C451.1 C452.1 C453.2 C454.2 C455.1 C456.2 C457.2 C458.2 C460.2 C462.1 C463.1 C464.2 C465.1 C466.2 C467.2 C468.2 C469.1 C470.1 C471.1 C472.1 C473.2 C474.2 C475.1 C477.2 C479.1 C480.2 C481.2 C482.2 C483.2 C484.2 C485.2 C486.2 C487.2 C488.2 C489.2 C490.1 C491.2 C492.2 C493.1 C494.2 C496.1 C497.1 C500.2 C501.2 C502.1 C505.2 C508.2 C509.2 C510.2 C511.2 C514.2 C515.1 C517.1 C518.1 C525.2 C527.2 C530.1 C531.2 C533.1 C537.2 C538.2 C539.1 C540.2 C541.1 C542.1 C543.2 C544.1 C545.2 C546.2 C548.2 C551.2 C555.2 C556.2 C557.1 C558.2 C559.2 C560.2 C561.1 C562.1 C563.1 C564.2 C565.2 C566.2 C567.2 C568.2 C569.1 C570.1 C571.1 C572.1 C573.1 C574.2 C575.1 C576.1 C577.1 C578.1 C579.1 C580.1 C581.2 C582.2 C583.1 C584.2 C585.2 C586.2 C587.2 C588.2 C590.1 C592.1 C593.1 C594.1 C595.2 C596.2 C597.1 C598.2 C599.1 C600.1 C601.2 C602.1 C603.2 C604.2 C605.2 C606.2 C608.1 C611.1 C612.2 C613.1 C614.2 C615.1 C616.1 C617.1 C618.1 C619.1 C620.1 C621.1 C622.1 C623.1 C624.2 C625.2 C628.2 C630.2 C631.2 C633.1 C634.1 C635.1 C636.1 C637.1 C639.1 C641.2 C642.2 C643.2 C644.1 C645.1 C647.2 C650.1 C651.2 C657.2 C658.1 C659.1 C663.2 C664.2 C665.1 C666.1 C667.2 C672.2 C673.2 C674.2 C675.2 C676.2 C677.1 C678.2 C679.2 C680.2 C681.1 C682.2 C683.1 C684.1 C685.1 C686.2 C687.2 C688.1 C689.1 C690.1 C691.1 C692.1 C693.1 C694.1 C695.1 C696.1 C697.1 C698.1 C699.1 C700.1 C701.1 C702.1 C703.1 C704.1 C705.1 C706.1 C707.1 C708.2 C709.2 C710.1 C711.1 C712.2 C713.1 C714.1 C715.2 C716.1 C717.1 C718.1 C719.1 C720.1 C721.2 C722.2 C723.1 C724.2 C725.1 C726.2 C727.2 C728.1 C729.1 C730.2 C731.2 C732.2 C733.2 C734.2 C735.2 C736.2 C737.2 C738.1 C739.1 C740.2 C741.2 C742.1 C745.1 C746.2 C747.2 C748.1 C750.2 C752.2 C753.2 C754.1 C755.2 C756.1 C757.2 C758.2 C759.1 C760.2 C761.2 C762.2 C763.2 C764.2 C765.2 C766.2 C767.2 C768.2 C769.2 C770.2 C771.2 C772.2 C773.2 C774.2 C775.2 C776.2 C777.2 C778.2 C779.2 C780.2 C781.2 C782.1 C783.2 C785.1 C786.2 C787.1 C788.1 C789.2 C790.2 C791.1 C792.1 C793.1 C794.1 C796.2 C797.2 C798.1 C799.2 C800.2 C801.2 C802.2 C803.1 C804.1 C805.2 C806.2 C807.1 C808.1 C809.2 C810.2 C811.1 C812.1 C813.1 C814.1 C815.1 C816.1 C817.1 C818.1 C819.1 CN2.8 CN2.10 CN2.12 CN2.14 CN3.6 CN3.7 CN3.8 CN4.3 CN4.6 CN4.12 CN4.13 CN4.14 CN4.15 CN5.3 CN5.9 CN5.12 CN5.15 CN5.18 CN5.21 CN5.24 CN5.28 CN5.41 CN5.42 CN5.43 CN5.44 CN6.1 CN6.5 CN6.6 CN7.5 CN7.6 CN7.7 CN7.8 CN7.10 CN7.16 CN7.17 CN8.3 CN9.1 CN9.4 CN9.12 CN9.13 CN9.14 CN9.15 CN10.1 CN10.7 CN10.18 CN10.33 CN10.39 CN10.45 CN10.51 CN10.57 CN10.63 CN10.69 CN10.75 CN11.9 CN11.10 CN12.2 CN12.5 CN12.8 CN12.11 CN12.17 CN12.20 CN12.21 CN12.22 CN12.23 CN13.4 CN13.7 CN13.10 CN13.11 CN13.12 CN13.13 CN14.1 CN14.4 CN14.7 CN14.11 CN14.12 CN14.13 CN14.17 CN14.19 CN14.23 CN14.24 CN16.4 CN16.7 CN16.10 CN16.11 CN16.12 CN16.13 CN17.5 CN17.9 CN17.10 CN18.5 CN18.6 CN20.28 CN20.29 CN20.30 CN22.6 CN22.9 CN22.10 CN22.11 CN22.12 CP1.2 CP1.4 CP1.6 CP1.8 CP2.2 CP2.4 CP2.6 CP2.8 CP3.2 CP3.4 CP3.6 CP3.8 CP4.2 CP4.4 CP4.6 CP4.8 CP5.2 CP5.4 CP5.6 CP5.8 CP6.2 CP6.4 CP6.6 CP6.8 D2.2 D3.2 D4.2 D5.2 D6.2 D21.2 D22.2 D23.1 D24.2 D25.2 D26.2 D27.2 D28.1 D33.2 D34.2 HOLE1.1 HOLE2.1(PIN1) HOLE3.1 HOLE4.1(PIN1) HOLE5.1(PIN1) HOLE6.1 HOLE7.1 HOLE9.1(PIN1) HOLE11.1(PIN1) HOLE12.1(PIN1) HOLE16.1(TP-1) HOLE17.1(PIN1) HOLE18.1(PIN1) HOLE19.1(PIN1) HOLE20.1(TP-1) HOLE21.1(TP-1) HOLE22.1 HOLE23.1(PIN1) J1.2 JDIM1.2 JDIM1.3 JDIM1.8 JDIM1.9 JDIM1.11 JDIM1.13 JDIM1.14 JDIM1.19 JDIM1.20 JDIM1.25 JDIM1.26 JDIM1.28 JDIM1.31 JDIM1.32 JDIM1.37 JDIM1.38 JDIM1.43 JDIM1.44 JDIM1.46 JDIM1.48 JDIM1.49 JDIM1.54 JDIM1.55 JDIM1.60 JDIM1.61 JDIM1.63 JDIM1.65 JDIM1.66 JDIM1.71 JDIM1.72 JDIM1.127 JDIM1.128 JDIM1.133 JDIM1.134 JDIM1.136 JDIM1.138 JDIM1.139 JDIM1.144 JDIM1.145 JDIM1.150 JDIM1.151 JDIM1.153 JDIM1.155 JDIM1.156 JDIM1.161 JDIM1.162 JDIM1.167 JDIM1.168 JDIM1.170 JDIM1.172 JDIM1.173 JDIM1.178 JDIM1.179 JDIM1.184 JDIM1.185 JDIM1.187 JDIM1.189 JDIM1.190 JDIM1.195 JDIM1.196 JDIM1.205 JDIM1.206 JDIM2.2 JDIM2.3 JDIM2.8 JDIM2.9 JDIM2.11 JDIM2.13 JDIM2.14 JDIM2.19 JDIM2.20 JDIM2.25 JDIM2.26 JDIM2.28 JDIM2.31 JDIM2.32 JDIM2.37 JDIM2.38 JDIM2.43 JDIM2.44 JDIM2.46 JDIM2.48 JDIM2.49 JDIM2.54 JDIM2.55 JDIM2.60 JDIM2.61 JDIM2.63 JDIM2.65 JDIM2.66 JDIM2.71 JDIM2.72 JDIM2.127 JDIM2.128 JDIM2.133 JDIM2.134 JDIM2.136 JDIM2.138 JDIM2.139 JDIM2.144 JDIM2.145 JDIM2.150 JDIM2.151 JDIM2.153 JDIM2.155 JDIM2.156 JDIM2.161 JDIM2.162 JDIM2.167 JDIM2.168 JDIM2.170 JDIM2.172 JDIM2.173 JDIM2.178 JDIM2.179 JDIM2.184 JDIM2.185 JDIM2.187 JDIM2.189 JDIM2.190 JDIM2.195 JDIM2.196 JDIM2.205 JDIM2.206 MR1.3 PC2.2 PC3.1 PC4.2 PC6.1 PC7.1 PC8.2 PC9.2 PC10.2 PC11.2 PC13.1 PC14.2 PC15.2 PC21.1 PC22.2 PC23.2 PC24.1 PC25.1 PC28.2 PC29.1 PC32.2 PC33.2 PC35.2 PC36.2 PC37.1 PC41.2 PC43.2 PC45.1 PC46.1 PC47.1 PC48.2 PC49.1 PC50.2 PC51.2 PC52.1 PC53.2 PC54.1 PC55.2 PC56.2 PC57.2 PC58.2 PC59.2 PC60.2 PC62.2 PC64.2 PC65.2 PC66.2 PC67.2 PC68.2 PC69.2 PC72.1 PC73.1 PC79.2 PC92.1 PC93.1 PC95.2 PC96.2 PC99.2 PC100.1 PC101.1 PC102.1 PC103.1 PC104.1 PC109.1 PC113.1 PC115.1 PC116.1 PC117.1 PC118.2 PC120.2 PC121.1 PC122.2 PC123.1 PC124.1 PC125.1 PC126.2 PC127.2 PC128.1 PC129.2 PC130.1 PC132.1 PC135.2 PC138.2 PC139.2 PC140.1 PC141.2 PC146.1 PC147.1 PC148.1 PC149.1 PC150.2 PC151.1 PC152.1 PC153.2 PC154.2 PC155.1 PC156.2 PC157.1 PC158.2 PC159.2 PC160.2 PC161.2 PC162.2 PC163.2 PC164.2 PC165.2 PC166.2 PC167.2 PC168.2 PC169.2 PC170.2 PC171.2 PC172.2 PC173.2 PC174.1 PC175.1 PC176.1 PC177.2 PC178.2 PC179.1 PC180.2 PC181.2 PC182.1 PC183.2 PC184.2 PC185.2 PC186.1 PC187.1 PC189.2 PC193.1 PC194.1 PC200.1 PC202.2 PC203.1 PC204.1 PC205.2 PC206.1 PC207.2 PC208.2 PC209.2 PC210.2 PC211.2 PC212.2 PC213.1 PC214.2 PC219.1 PC222.2 PC223.2 PC225.2 PC226.2 PC228.2 PC229.2 PC232.2 PC233.1 PC234.2 PC235.1 PC236.2 PC240.1 PC241.1 PC242.1 PC245.2 PC246.2 PC247.1 PC248.1 PC249.2 PC250.2 PC252.1 PC259.2 PC261.2 PC265.1 PC268.1 PC271.1 PC275.2 PC278.2 PC282.1 PC6097.1 PC6098.2 PC6100.1 PC6209.1 PC6212.2 PC6214.2 PC6216.2 PC6218.2 PC6219.1 PC6220.2 PC6221.2 PC6222.2 PC6224.2 PC6225.1 PC6226.1 PC6227.2 PC6228.2 PC6229.2 PC6230.1 PC6231.1 PD1.2 PD2.2 PD3.2 PJ1.1 PJ1.2 PJ1.9 PJ1.10 PJ2.3 PJ2.4 PQ2.1 PQ3.1 PQ4.1 PQ5.1 PQ6.1 PQ7.1 PQ8.1 PQ9.1 PQ10.1 PQ11.1 PQ13.1 PQ14.1 PQ15.1 PQ16.1 PQ17.1 PQ21.1 PQ21.2 PQ21.3 PQ24.1 PQ24.2 PQ24.3 PQ27.1 PQ27.2 PQ27.3 PQ30.5 PQ30.6 PQ30.7 PQ31.1 PQ31.2 PQ31.3 PQ33.1 PQ35.1 PQ36.1 PQ39.1 PQ40.1 PQ6053.1 PQ6053.2 PQ6053.3 PQ6055.1 PQ6055.2 PQ6055.3 PQ6057.1 PQ6058.1 PQ6059.1 PQ6060.1 PR3.1 PR4.2 PR10.1 PR11.1 PR13.1 PR15.1 PR39.2 PR49.2 PR63.1 PR66.2 PR69.2 PR71.1 PR72.1 PR74.1 PR120.2 PR122.2 PR134.2 PR135.1 PR140.2 PR145.2 PR147.2 PR149.1 PR150.2 PR157.2 PR158.2 PR180.2 PR198.2 PR202.2 PR203.2 PR206.2 PR207.2 PR224.2 PR225.2 PR248.1 PR267.1 PR274.2 PR289.1 PR294.2 PR309.2 PR331.1 PR337.2 PR342.1 PR6125.2 PU1.41 PU3.21 PU4.4 PU4.5 PU4.6 PU5.22 PU5.29 PU5.30 PU5.31 PU5.32 PU5.33 PU5.34 PU5.35 PU5.36 PU5.37 PU5.38 PU6.9 PU6.21 PU7.9 PU7.21 PU8.9 PU8.21 PU9.9 PU9.21 PU10.2 PU11.2 PU12.11 PU12.12 PU12.13 PU12.14 PU12.15 PU12.16 PU14.2 PU15.4 PU15.10 PU16.11 PU19.2 PU6010.21 PU6010.22 PU6010.23 PU6010.24 PU6010.25 PU6010.26 Q3.1 Q3.4 Q4.1 Q6.1 Q7.1 Q8.1 Q12.1 Q17.1 Q19.1 Q21.2 Q26.2 Q27.1 Q30.1 Q36.1 Q37.1 Q37.4 Q40.1 Q56.1 Q56.4 R18.1 R21.1 R22.1 R24.1 R27.1 R30.1 R31.1 R34.1 R35.1 R38.1 R40.1 R41.1 R43.1 R44.2 R45.1 R47.2 R49.1 R50.1 R54.1 R55.1 R59.2 R60.1 R62.1 R64.1 R65.1 R69.2 R70.2 R71.1 R73.1 R77.1 R78.2 R79.2 R88.1 R98.2 R105.1 R109.2 R114.1 R121.1 R124.2 R126.1 R127.1 R130.1 R142.1 R145.1 R156.1 R158.1 R161.2 R162.1 R174.1 R176.2 R178.2 R196.2 R199.1 R202.1 R206.1 R213.2 R214.2 R219.2 R222.2 R256.2 R261.2 R284.1 R287.2 R294.1 R295.2 R296.2 R301.1 R310.1 R313.1 R320.2 R323.2 R325.1 R331.1 R332.2 R335.2 R337.1 R346.1 R350.1 R354.1 R357.1 R364.2 R369.2 R375.2 R376.1 R377.2 R380.1 R389.2 R393.2 R394.2 R396.2 R398.2 R399.2 R400.2 R401.1 R445.1 R447.2 R450.2 R451.1 R453.2 R455.1 R458.1 R461.1 R463.2 R464.2 R467.1 R469.1 R471.2 R473.1 R486.2 R487.2 R490.2 R491.2 R492.2 R493.2 R497.2 R502.2 R503.2 R504.2 R505.1 R510.1 R519.2 R520.2 R521.2 R522.2 R523.1 R524.2 R525.2 R526.2 R527.2 R528.1 R532.2 R534.1 R535.1 R537.1 R548.2 R553.1 R554.2 R555.2 R558.1 R563.1 R564.1 R566.2 R569.2 R587.2 R592.1 R595.1 R598.1 R605.1 R606.1 R610.1 R612.1 R614.1 R616.1 R621.1 R624.2 R635.1 R642.2 R646.1 R648.2 R675.2 R678.1 R681.1 R685.1 R692.2 R701.1 R706.1 R707.1 R720.2 R728.1 R729.1 R735.2 R736.2 R739.2 R750.2 R759.2 R760.2 R764.1 R766.1 R768.2 R778.2 R782.2 R783.2 R784.2 R785.2 R786.2 R787.2 SPAD1.1 SPAD2.1 SPAD3.1 SPAD4.1 SPAD5.1 SPAD6.1 SPAD7.1 SPAD8.1 SPAD9.1 SPAD10.1 SPAD11.1 SPAD12.1 SW1.1 SW1.2 SW1.5 SW1.6 SW2.3 SW2.4 SW2.5 SW2.6 U1.2 U1.5 U2.A9 U2.B1 U2.B3 U2.B9 U2.D1 U2.D8 U2.E1 U2.E2 U2.E8 U2.F9 U2.G1 U2.G8 U2.G9 U2.J2 U2.J8 U2.M1 U2.M9 U2.P1 U2.P9 U2.T1 U2.T9 U3.A9 U3.B1 U3.B3 U3.B9 U3.D1 U3.D8 U3.E1 U3.E2 U3.E8 U3.F9 U3.G1 U3.G8 U3.G9 U3.J2 U3.J8 U3.M1 U3.M9 U3.P1 U3.P9 U3.T1 U3.T9 U4.A9 U4.B1 U4.B3 U4.B9 U4.D1 U4.D8 U4.E1 U4.E2 U4.E8 U4.F9 U4.G1 U4.G8 U4.G9 U4.J2 U4.J8 U4.M1 U4.M9 U4.P1 U4.P9 U4.T1 U4.T9 U5.A9 U5.B1 U5.B3 U5.B9 U5.D1 U5.D8 U5.E1 U5.E2 U5.E8 U5.F9 U5.G1 U5.G8 U5.G9 U5.J2 U5.J8 U5.M1 U5.M9 U5.P1 U5.P9 U5.T1 U5.T9 U6.3 U7.3 U8.3 U9.3 U10.3 U12.5 U12.6 U12.7 U12.8 U13.15 U13.41 U14.3 U15.33 U16.2 U16.3 U17.3 U18.15 U18.35 U18.41 U18.42 U18.43 U18.44 U18.45 U18.46 U18.47 U18.48 U18.49 U18.50 U19.5 U19.10 U19.12 U19.13 U19.15 U19.16 U20.2 U21.3 U21.8 U21.9 U21.11 U22.14 U22.17 U23.49 U24.3 U24.8 U24.9 U24.11 U25.2 U26.25 U28.A9 U28.B1 U28.B3 U28.B9 U28.D1 U28.D8 U28.E1 U28.E2 U28.E8 U28.F9 U28.G1 U28.G8 U28.G9 U28.J2 U28.J8 U28.M1 U28.M9 U28.P1 U28.P9 U28.T1 U28.T9 U29.A9 U29.B1 U29.B3 U29.B9 U29.D1 U29.D8 U29.E1 U29.E2 U29.E8 U29.F9 U29.G1 U29.G8 U29.G9 U29.J2 U29.J8 U29.M1 U29.M9 U29.P1 U29.P9 U29.T1 U29.T9 U31.A9 U31.B1 U31.B3 U31.B9 U31.D1 U31.D8 U31.E1 U31.E2 U31.E8 U31.F9 U31.G1 U31.G8 U31.G9 U31.J2 U31.J8 U31.M1 U31.M9 U31.P1 U31.P9 U31.T1 U31.T9 U32.A9 U32.B1 U32.B3 U32.B9 U32.D1 U32.D8 U32.E1 U32.E2 U32.E8 U32.F9 U32.G1 U32.G8 U32.G9 U32.J2 U32.J8 U32.M1 U32.M9 U32.P1 U32.P9 U32.T1 U32.T9 U33.3 U34.A2 U34.A26 U34.AA7 U34.AB7 U34.AB11 U34.AB14 U34.AB17 U34.AB20 U34.AB24 U34.AC2 U34.AC5 U34.AC8 U34.AC22 U34.AC26 U34.AD12 U34.AD13 U34.AD15 U34.AD16 U34.AD18 U34.AD19 U34.AD21 U34.AD22 U34.AE11 U34.AE14 U34.AE17 U34.AE20 U34.AF1 U34.AF5 U34.AF8 U34.AF11 U34.AF14 U34.AF17 U34.AF20 U34.AF23 U34.AG2 U34.AG26 U34.B1 U34.B5 U34.B8 U34.B11 U34.B14 U34.B17 U34.B20 U34.B23 U34.B27 U34.E2 U34.E5 U34.E8 U34.E11 U34.E14 U34.E17 U34.E20 U34.E22 U34.E25 U34.H2 U34.H5 U34.H23 U34.H25 U34.K11 U34.K13 U34.K15 U34.K17 U34.L2 U34.L5 U34.L10 U34.L12 U34.L14 U34.L16 U34.L18 U34.L23 U34.L25 U34.M11 U34.M13 U34.M15 U34.M17 U34.N10 U34.N12 U34.N14 U34.N16 U34.N18 U34.P2 U34.P5 U34.P11 U34.P13 U34.P15 U34.P17 U34.P23 U34.P26 U34.R10 U34.R12 U34.R14 U34.R16 U34.R18 U34.T11 U34.T13 U34.T15 U34.T17 U34.U2 U34.U5 U34.U10 U34.U12 U34.U14 U34.U16 U34.U18 U34.U23 U34.U26 U34.V11 U34.V13 U34.V15 U34.V17 U34.Y2 U34.Y5 U34.Y23 U34.Y26 U35.A5 U35.A67 U35.A70 U35.AA2 U35.AA4 U35.AA65 U35.AA68 U35.AB8 U35.AB15 U35.AB16 U35.AB18 U35.AB21 U35.AD8 U35.AD13 U35.AD16 U35.AD19 U35.AD20 U35.AD21 U35.AD62 U35.AE64 U35.AE65 U35.AE66 U35.AE67 U35.AE68 U35.AE69 U35.AF1 U35.AF2 U35.AF4 U35.AF10 U35.AF15 U35.AF17 U35.AF63 U35.AG16 U35.AG17 U35.AG18 U35.AG19 U35.AG20 U35.AG21 U35.AG71 U35.AH6 U35.AH13 U35.AH63 U35.AH64 U35.AH67 U35.AJ4 U35.AJ15 U35.AJ18 U35.AJ20 U35.AK8 U35.AK11 U35.AK16 U35.AK18 U35.AK21 U35.AK22 U35.AK27 U35.AK63 U35.AK68 U35.AK69 U35.AL2 U35.AL4 U35.AL28 U35.AL32 U35.AL35 U35.AL38 U35.AL45 U35.AL48 U35.AL52 U35.AL55 U35.AL58 U35.AL64 U35.AL65 U35.AL66 U35.AM8 U35.AM13 U35.AM21 U35.AM25 U35.AM27 U35.AM43 U35.AM45 U35.AM46 U35.AM55 U35.AM60 U35.AM61 U35.AM68 U35.AM71 U35.AN20 U35.AN23 U35.AN28 U35.AN30 U35.AN32 U35.AN33 U35.AN35 U35.AN37 U35.AN38 U35.AN40 U35.AN42 U35.AN43 U35.AN58 U35.AN63 U35.AP10 U35.AP18 U35.AP20 U35.AP23 U35.AP28 U35.AP32 U35.AP35 U35.AP38 U35.AP42 U35.AP58 U35.AP63 U35.AP68 U35.AP70 U35.AR5 U35.AR8 U35.AR11 U35.AR15 U35.AR16 U35.AR20 U35.AR23 U35.AR28 U35.AR35 U35.AR42 U35.AR43 U35.AR45 U35.AR46 U35.AR48 U35.AR50 U35.AR52 U35.AR53 U35.AR55 U35.AR58 U35.AR63 U35.AT2 U35.AT4 U35.AT20 U35.AT23 U35.AT28 U35.AT35 U35.AT42 U35.AT56 U35.AT58 U35.AT63 U35.AT68 U35.AT71 U35.AU10 U35.AU15 U35.AU20 U35.AU32 U35.AU38 U35.AV1 U35.AV68 U35.AV69 U35.AV70 U35.AV71 U35.AW6 U35.AW8 U35.AW10 U35.AW12 U35.AW14 U35.AW16 U35.AW18 U35.AW21 U35.AW23 U35.AW26 U35.AW28 U35.AW30 U35.AW32 U35.AW34 U35.AW36 U35.AW38 U35.AW41 U35.AW43 U35.AW45 U35.AW47 U35.AW49 U35.AW50 U35.AW51 U35.AW53 U35.AW55 U35.AW57 U35.AW60 U35.AW62 U35.AW64 U35.AW66 U35.AY66 U35.B10 U35.B14 U35.B18 U35.B22 U35.B30 U35.B34 U35.B39 U35.B44 U35.B48 U35.B53 U35.B58 U35.B62 U35.B66 U35.B71 U35.BA1 U35.BA2 U35.BA6 U35.BA10 U35.BA14 U35.BA18 U35.BA23 U35.BA28 U35.BA32 U35.BA36 U35.BA41 U35.BA45 U35.BA49 U35.BA53 U35.BA57 U35.BA62 U35.BA66 U35.BA71 U35.BB6 U35.BB18 U35.BB26 U35.BB30 U35.BB34 U35.BB38 U35.BB43 U35.BB55 U35.BB60 U35.BB64 U35.BB67 U35.BB70 U35.C1 U35.C5 U35.C25 U35.D6 U35.D10 U35.D11 U35.D14 U35.D18 U35.D22 U35.D25 U35.D26 U35.D30 U35.D34 U35.D39 U35.D44 U35.D45 U35.D47 U35.D48 U35.D53 U35.D58 U35.D62 U35.D66 U35.D69 U35.E6 U35.E11 U35.E15 U35.E18 U35.E21 U35.E46 U35.E50 U35.E53 U35.E56 U35.E65 U35.E71 U35.F1 U35.F2 U35.F4 U35.F8 U35.F13 U35.F22 U35.F23 U35.F27 U35.F28 U35.F32 U35.F33 U35.F35 U35.F37 U35.F38 U35.F40 U35.F42 U35.F68 U35.G5 U35.G6 U35.G10 U35.G22 U35.G43 U35.G45 U35.G48 U35.G52 U35.G55 U35.G58 U35.G60 U35.G63 U35.G66 U35.H15 U35.H18 U35.H71 U35.J8 U35.J11 U35.J13 U35.J25 U35.J28 U35.J32 U35.J35 U35.J38 U35.J42 U35.K16 U35.K18 U35.K22 U35.K61 U35.K63 U35.K64 U35.K65 U35.K66 U35.K67 U35.K68 U35.K70 U35.K71 U35.L2 U35.L4 U35.L8 U35.L11 U35.L16 U35.L17 U35.L18 U35.L20 U35.N6 U35.N10 U35.N13 U35.N19 U35.N21 U35.N65 U35.N68 U35.P17 U35.P19 U35.P20 U35.P21 U35.R6 U35.R13 U35.T2 U35.T4 U35.T15 U35.T17 U35.T18 U35.T21 U35.U10 U35.U63 U35.U64 U35.U66 U35.U67 U35.U69 U35.U70 U35.V16 U35.V17 U35.V18 U35.W6 U35.W9 U35.W13 U35.Y17 U35.Y19 U35.Y20 U35.Y21 U36.3 U37.1 U37.3 U38.3 U39.4 U40.1 U40.3 U41.4 U42.25 U43.3 U44.4 U44.11 U44.18 U44.25 U46.2 U47.3 U48.3 U49.3 U50.3 Y1.2 Y1.4 Y3.2 Y3.4 Y4.2 Y4.4
PVDD: L13.1 Q28.1 R338.1
V0P85A_VID0: TP31.1 U35.AN11
V0P85A_VID1: TP16.1 U35.AN13
V18: C544.2 U26.24
VCC_XD: C533.2 C542.2 C543.1 CN4.4 R396.1 U26.5
VCCGT_SENSE: PR191.1 R155.2 U35.J70
VCCOPC_VID0: PR287.2 R707.2 R708.1
VCCOPC_VID0_C: PR287.1 PU14.4
VCCOPC_VID1: PR286.2 R705.1 R706.2
VCCOPC_VID1_C: PR286.1 PU14.3
VCCRTC_2: BT1.1 R308.1
VCCST_PWRGD: C136.2 R89.1 U35.B65
VCCST_PWRGD_EN: R102.1 R103.1 R777.2 U47.1
VCCST_PWRGD_EN_L: R777.1 U6.2 U47.4
VCCST_PWRGD_R: R85.1 R89.2 U6.4
VDD10: C355.1 C757.1 C758.1 C760.1 C761.1 C762.1 R246.2 U15.3 U15.8 U15.22 U15.30
VIN: C7.1 C9.2 JP16.1 PC47.2 PC48.1 PC49.2 PC50.1 PC51.1 PC52.2 PC53.1 PC54.2 PC67.1 PC68.1 PC69.1 PC72.2 PC73.2 PC117.2 PC118.1 PC138.1 PC140.2 PC141.1 PC148.2 PC150.1 PC152.2 PC153.1 PC154.1 PC155.2 PC156.1 PC157.2 PC200.2 PC202.1 PC203.2 PC204.2 PC205.1 PC206.2 PC207.1 PC208.1 PC209.1 PC210.1 PC211.1 PC245.1 PC248.2 PC6212.1 PC6214.1 PC6216.1 PC6218.1 PC6220.1 PC6229.1 PD4.2 PQ1.5 PQ20.5 PQ25.5 PQ29.5 PQ30.2 PQ32.5 PQ6054.5 PQ6056.5 PR75.1 PR141.1 PR142.1 PR151.1 PR159.1 PR209.2 PR212.1 PR213.2 PR272.1 PR335.1 PR336.1 PR6130.1 PU6.6 PU6.22 PU7.6 PU7.22 PU8.6 PU8.22 PU9.6 PU9.22 PU11.1 R14.1 R15.1
VSSGT_SENSE: PR181.1 R161.1 U35.J69
2ND_MBCLK: Q13.6 R171.1 R733.1 U45.115
2ND_MBDATA: Q13.3 R175.1 R734.1 U45.116
27M_XTAL_IN_R: C639.2 U34.C11 Y3.3
27M_XTAL_OUT: C644.2 U34.B10 Y3.1
554EN_0.95V: PC240.2 PR307.1 PU16.5
554FB_0.95V: PC244.1 PR309.1 PR310.2 PU16.6
554FB_0.95V_S: PC244.2 PR310.1 PR311.1
554LX_0.95V: PL14.1 PR306.1 PU16.1 PU16.2 PU16.3
554NC_0.95V: PC247.2 PU16.7
554PG_0.95V: PR302.2 PU16.4
554SVIN_0.95V: PC252.2 PR312.2 PU16.8
681_AGND: PC230.1 PR294.1 PU14.11 R632.1 R636.1
1658R-BOOT1: PR108.2 PU3.1
1658R-BOOT2: PR107.2 PU3.15
1658R-COMP: PC89.1 PC214.1 PU3.12
1658R-EN: PR111.2 PR267.2 PR343.2 PU3.3
1658R-FB: PC94.1 PR129.1 PU3.11
1658R-FBRTN: PR128.1 PU3.10
1658R-LGATE1: PQ24.4 PU3.19
1658R-LGATE2: PQ27.4 PU3.17
1658R-OCS/CB: PR269.2 PR273.2 PR274.1 PU3.9
1658R-PG: PR110.1 PR266.1 PU3.13
1658R-PHASE1: PC82.2 PL7.1 PQ24.5 PQ25.1 PQ25.2 PQ25.3 PR65.1 PU3.20
1658R-PHASE2: PC81.2 PL8.1 PQ27.5 PQ29.1 PQ29.2 PQ29.3 PR67.1 PU3.16
1658R-PSI: PR116.2 PU3.4
1658R-PVCC: PC79.1 PR99.2 PU3.18
1658R-REFADJ: PR126.1 PU3.6
1658R-REFIN: PC92.2 PR131.2 PR132.1 PU3.7
1658R-UGATE1: PQ25.4 PU3.2
1658R-UGATE2: PQ29.4 PU3.14
1658R-VID: PR123.2 PU3.5
1658R-VREF: PC93.2 PR127.1 PR269.1 PU3.8
8002LX1.05V: PL16.1 PU19.3
24780_ACDET: PR3.2 PR168.2 PU5.6
24780_ACDRV: PR165.2 PU5.4
24780_ACN: PC2.1 PC5.2 PR209.1 PU5.1
24780_ACP: PC5.1 PC115.2 PR210.1 PU5.2
24780_BATDRV: PR185.2 PU5.18
24780_BATSRC: PR186.2 PU5.17
24780_BM#: PR16.1 PU5.16
24780_BST: PR173.2 PU5.25
24780_CMPIN: PR11.2 PU5.13
24780_CMPOUT: PQ40.2 PR179.1 PU5.14
24780_CMSRC: PR166.2 PU5.3
24780_DH: PQ20.4 PU5.26
24780_DL: PQ21.4 PU5.23
24780_ILIM: PC123.2 PR14.1 PR15.2 PU5.21
24780_LX: PC119.1 PL1.2 PQ20.1 PQ20.2 PQ20.3 PQ21.5 PR2.1 PU5.27
24780_SRN: PC131.1 PC132.2 PR175.1 PR184.1
24780_SRP: PC130.2 PC131.2 PR176.1 PR183.1
24780_VCC: PC116.2 PR5.1 PU5.28
51216_DRVH: PQ32.4 PU15.14
51216_DRVL: PQ31.4 PU15.11
51216_MODE: PR296.2 PU15.19
51216_REF: PC238.1 PR297.1 PU15.6
51216_REFIN: PC239.1 PR297.2 PR300.1 PU15.8
51216_S3: PR298.2 PR301.2 PR303.2 PU15.17
51216_S5: PR303.1 PR305.2 PU15.16
51216_SW: PC243.2 PL15.1 PQ31.5 PQ32.1 PQ32.2 PQ32.3 PR313.1 PU15.13
51216_TRIP: PR299.2 PU15.18
51216_VBST: PR308.1 PU15.15
51225_CS1: PR6124.1 PU6010.1
51225_CS2: PR6122.2 PU6010.5
51225_DH1: PQ6056.4 PU6010.16
51225_DH2: PQ6054.4 PU6010.10
51225_DL1: PQ6055.4 PU6010.15
51225_DL2: PQ6053.4 PU6010.11
51225_EN1: PR6278.1 PU6010.20
51225_FB1: PR6120.1 PR6281.1 PU6010.2
51225_FB2: PR6121.1 PR6279.2 PU6010.4
51225_SW1: PC6215.2 PL6013.2 PQ6055.5 PQ6056.1 PQ6056.2 PQ6056.3 PR6288.1 PU6010.18
51225_SW2: PC6213.1 PL6012.1 PQ6053.5 PQ6054.1 PQ6054.2 PQ6054.3 PR6289.1 PU6010.8
51225_VBST1: PR6287.2 PU6010.17
51225_VBST2: PR6286.1 PU6010.9
51225_VCLK: PR6285.1 PU6010.19
51225_VIN: PC6100.2 PR6130.2 PU6010.12
+AZA_VDD: C484.1 C485.1 C527.1 R367.1 R372.1 U23.1 U23.36
+FB_PLLAVDD: C76.2 C77.1 C79.1 C89.2 L1.1 U34.F16 U34.H22 U34.P22
+G_SEN_PW: C412.1 C428.1 R318.2 R333.2 R334.2 U19.1 U19.8 U19.14
+SMDDR_VREF_DIMM: C422.1 C423.1 C473.1 C479.2 C480.1 JDIM1.126 JDIM2.126 R346.2 R358.1 R363.2
+SMDDR_VREF_DQ0: C440.2 C441.1 C443.1 JDIM2.1 R328.2 R330.1 R331.2
+SMDDR_VREF_DQ1: C391.2 C392.1 C393.1 JDIM1.1 R307.2 R309.1 R310.2
+TPVDD: C783.1 C790.1 CN17.8 Q42.3 R409.2 R410.2 R752.2
+VGPU_CORE: C85.1 C86.2 C88.2 C93.2 C109.2 C112.2 C113.2 C116.2 C118.2 C120.2 C123.2 C125.2 C126.2 C128.2 C130.2 C140.2 C146.2 C149.2 C153.2 C159.2 C160.2 C163.2 PC60.1 PC177.1 PC178.1 PC180.1 PC181.1 PC185.1 PC189.1 PL7.2 PL8.2 PR64.1 R123.1 U34.K10 U34.K12 U34.K14 U34.K16 U34.K18 U34.L11 U34.L13 U34.L15 U34.L17 U34.M10 U34.M12 U34.M14 U34.M16 U34.M18 U34.N11 U34.N13 U34.N15 U34.N17 U34.P10 U34.P12 U34.P14 U34.P16 U34.P18 U34.R11 U34.R13 U34.R15 U34.R17 U34.T10 U34.T12 U34.T14 U34.T16 U34.T18 U34.U11 U34.U13 U34.U15 U34.U17 U34.V10 U34.V12 U34.V14 U34.V16 U34.V18
+VREF_CA_CPU: R362.2 U35.AY67
+VREFDQ_SA_M3: R327.2 U35.AY68
+VREFDQ_SB_M3: R302.2 U35.BA67
+WL_VDD: C338.2 C339.2 C340.1 C346.2 C347.1 C731.1 C735.1 C753.1 C755.1 CN10.2 CN10.4 CN10.72 CN10.74 Q23.2 R221.2 R237.1 R241.2 R242.2 R714.2
ACCEL_INT2: D35.1 R326.1
ACCEL_INT2_R: D35.2 U19.9
ACCEL_INTA: C425.2 D8.1 U35.AB1
ACCEL_INTA_R: D8.2 U19.11
ACIN: PR1.2 PR4.1 PR167.1 U45.72
ACPRESENT: R676.1 U45.84
ACZ_SDIN: R359.1 U23.8
ADOGND: C519.2 C520.2 C523.1 C524.2 C526.2 C529.1 C532.2 C534.2 C535.1 C536.2 C537.1 C538.1 C547.2 C550.2 C553.2 C554.2 CN21.5 CN21.7 R375.1 R390.1 R393.1 R394.1 R397.1 R399.1 R400.1 R401.2 R417.2 R423.2 R750.1 U23.25 U23.38
ALERT: R511.1 U34.F8
AMP_MUTE#: D16.1 U45.108
APS1: CN2.1 R289.2 R291.2
APS3: CN2.3 R272.2 R278.1 R289.1
APS7: CN2.7 R271.1 R272.1
APW8824_1.8V: PL6.1 PU10.3
BAT-V: PC120.1 PC121.2 PC125.2 PC126.1 PC127.1 PJ1.7 PJ1.8 PR169.2 PR175.2
BATLED0#: R428.1 R430.1 U45.29
BATLED1#: R429.1 R431.1 U45.25
BEEP_1: C476.2 C477.1 R352.1 R354.2
BI: PJ1.6 PR10.2 Q40.3
BI_GATE: C765.1 Q40.2 Q56.5 R719.2 SW1.3 SW1.4
BL#: Q3.2 Q3.3 R52.1
BL_ON: CN5.26 D1.2 Q3.6 Q4.3 R58.1
BOARD_ID0: R595.2 R600.1 U35.AN3
BOARD_ID1: R598.2 R599.1 U35.AN1
BOARD_ID2: R605.2 R608.1 U35.AN2
BOARD_ID3: R590.1 R592.2 U35.AM4
BOARD_ID4: C803.2 R441.1 R593.1 U35.AM1
BOARD_ID4_TOUCH_S: CN5.2 R441.2
BOARD_ID5: R606.2 R607.1 U35.AM2
BOARD_ID6: R764.2 R765.1 U35.AM3
BOARD_ID7: R766.2 R767.1 U35.AP4
BT_EN: CN10.54 U45.82
BXTALOUT: R504.1 U34.C10
C_PEG_TX0: C652.2 U35.A17
C_PEG_TX1: C655.2 U35.C16
C_PEG_TX2: C662.2 U35.C17
C_PEG_TX3: C660.2 U35.A19
C_PEG_TX#0: C653.1 U35.B17
C_PEG_TX#1: C656.2 U35.D16
C_PEG_TX#2: C661.2 U35.D17
C_PEG_TX#3: C654.2 U35.B19
CATERR#: R788.2 TP65.1 U35.D63
CCD_PWR: C16.2 C27.2 CN5.32 CN5.33 R11.2
CFG4: R548.1 U35.E70
CFG_RCOMP: R156.2 U35.E60
CL_CLK: TP68.1 U35.G3
CL_DAT: TP66.1 U35.G2
CL_RST#: TP67.1 U35.G1
CLK_PCI_EC: R373.2 R623.1 U45.13
CLK_PCI_LPC: R627.1 R694.2
CLK_PCI_LPC_C: CN10.71 R694.1
CLK_PCIE_LAN_REQ#: Q25.3 R229.1 R276.2 R281.2
CLK_PCIE_LANN: U15.16 U35.B40
CLK_PCIE_LANP: U15.15 U35.A40
CLK_PCIE_REQ0#: R234.1 R235.2 U35.AR10
CLK_PCIE_REQ1#: R215.1 TP22.1 U35.AT7
CLK_PCIE_REQ2#: R227.1 TP25.1 U35.AT8
CLK_PCIE_REQ3#: R618.1 TP73.1 U35.AT10
CLK_PCIE_REQ4#: R228.1 R229.2 U35.AU8
CLK_PCIE_REQ5#: R223.1 R224.2 U35.AU7
CLK_PCIE_VGA: U34.AE8 U35.C42
CLK_PCIE_VGA#: U34.AD8 U35.D42
CLK_PCIE_WLANN: CN10.49 U35.E40
CLK_PCIE_WLANP: CN10.47 U35.E38
CLK_PCIE_XDPN: TP93.1 U35.F43
CLK_PCIE_XDPP: TP94.1 U35.E43
CLK_PEGA_REQ#: Q10.3 R92.2 R235.1
CLK_SCLK: JDIM1.202 JDIM2.202 Q32.1 R329.1 R572.1
CLK_SDATA: JDIM1.200 JDIM2.200 Q32.4 R336.1 R576.1
CLKRUN#: C807.2 R630.2 R743.2 U35.AW11 U45.93
CODEC_VREF: C535.2 U23.28
CPU_DRAMRST#: R670.2 R679.2 U35.AT13
CPU_THRMTRIP#: R529.2 R530.2 U35.C63
CPUFAN#: U12.4 U45.81
CRT_11: CN7.11 TP75.1
CRT_AUX#_C: C671.1 U35.E48
CRT_AUX_C: C670.1 U35.F48
CRT_AUXN: C343.2 C671.2 R533.2
CRT_AUXN_C: C343.1 U13.18
CRT_AUXP: C341.2 C670.2 R532.1
CRT_AUXP_C: C341.1 U13.19
CRT_B1: C319.2 CN7.3 L5.2 U38.5 U38.6
CRT_BLU: C320.2 L5.1 R213.1 U13.7
CRT_CLK: R577.1 U35.N7
CRT_DATA: R152.1 U35.N8
CRT_G1: C333.2 CN7.2 L6.2 U38.2 U38.9
CRT_GRE: C334.2 L6.1 R219.1 U13.8
CRT_HPD: R564.2 U13.33 U35.L7
CRT_R1: C336.2 CN7.1 L7.2 U38.1 U38.10
CRT_RED: C337.2 L7.1 R222.1 U13.9
CRT_TXN0: C331.2 U35.C50
CRT_TXN0_C: C331.1 U13.23
CRT_TXN1: C315.2 U35.C52
CRT_TXN1_C: C315.1 U13.26
CRT_TXP0: C335.2 U35.D50
CRT_TXP0_C: C335.1 U13.22
CRT_TXP1: C329.2 U35.D52
CRT_TXP1_C: C329.1 U13.25
CRTHSYNC: C718.2 CN7.13 U36.1 U36.10 U40.4
CRTVDD5: C300.2 C301.1 C304.2 C305.1 CN7.9 Q21.1 R203.2 R601.2 R620.2 U36.2 U36.9
CRTVSYNC: C716.2 CN7.14 U36.4 U36.7 U37.4
CTL2: R360.2 U22.7
CTL3: R356.2 U22.8
DAC_VDDC: C725.2 C729.2 C734.1 L21.2 U13.5 U13.6
DC-DET: R344.1 R350.2 U23.4
DCPRTC: C732.1 U35.BB10
DDCCLK: C714.2 CN7.15 R225.1 R601.1 U36.5 U36.6
DDCCLK_R: R225.2 U13.12 U13.17
DDCDAT: C724.1 CN7.12 R226.1 R620.1 U38.4 U38.7
DDCDAT_R: R226.2 U13.13 U13.16
DDR3_DRAMRST#: C415.2 C465.2 C750.1 JDIM1.30 JDIM2.30 R670.1
DDR_VTT_CTRL: Q35.1 R621.2 U35.AW67
DDR_VTTT_PG_CTRL: PR298.1 Q35.3 R682.2
DEVSLP0: R351.1 R573.1 U35.J1
DEVSLP0_R: CN14.9 R351.2
DGPU_D: PC113.2 PQ16.3 PQ19.2 PR161.2
DGPU_EDIDCLK: R505.2 U34.A9
DGPU_EDIDDATA: R523.2 U34.B9
DGPU_EVENT#: R106.2 U35.AP5
DGPU_HOLD_RST#: R208.1 U10.1 U35.AP7
DGPU_OPP#: Q9.3 R382.1 U45.68
DGPU_OTP#: Q16.3 R740.1 U45.124
DGPU_PGOK-1: C141.1 Q7.3 Q12.2 R82.1
DGPU_POK2: C139.1 Q7.2 R83.1
DGPU_PSI: PR116.1 PR120.1 PR124.2 PR125.2 R518.1 U34.B4
DGPU_PW_CTRL#: R115.1 R127.2 U35.BA5
DGPU_PWR_EN: PR160.1 R256.1 R257.2 U35.AP8
DGPU_PWROK: Q12.3 R105.2 R108.1 R110.1 U35.AM5
DIMM0_SA0: JDIM2.197 R332.1
DIMM0_SA1: JDIM2.201 R335.1
DIMM1_SA0: JDIM1.197 R323.1
DIMM1_SA1: JDIM1.201 R305.1
DMIC_CLK: R370.2 U23.3
DMIC_CLK0_L: R769.1 R772.1
DMIC_CLK0_R: R769.2 U35.H5
DMIC_CLK_L: C488.1 R266.1 R270.1 R370.1
DMIC_CLK_L1: C378.1 D4.1 R270.2 U16.4
DMIC_CLK_L2: C374.1 D3.1 R266.2 R772.2 U17.4
DMIC_CS: R286.2 R287.1 R288.1 U17.2
DMIC_DAT: R371.2 U23.2
DMIC_DAT_L: R254.1 R371.1
DMIC_DAT_L1: C379.1 D5.1 R288.2 U16.5
DMIC_DAT_L2: C357.1 D2.1 R254.2 R771.2 U17.5
DMIC_DATA0_L: R770.1 R771.1
DMIC_DATA0_R: R770.2 U35.D7
DNBSWON#: R677.1 U45.123
DP_UTIL: R546.2 R553.2 U35.B52
DPWROK_C: R674.2 R675.1 U45.76
DPWROK_R: R661.1 R674.1 U35.BB20
EC_FB_CLAMP: R129.2 R140.1 U45.77
EC_FPBACK#: Q4.2 U45.86
EC_GND: L11.1 R782.1 R783.1 R784.1 R785.1 U45.1 U45.27 U45.49 U45.91 U45.104
EC_ODD_EJ: CN9.11 R209.1 R746.1
EC_ODD_EJ_R: C799.1 R746.2 U45.94
EC_PECR_R: R738.1 U45.117
EC_PWROK: R130.2 R131.2 R560.2 U8.2 U45.33
EC_PWROK_R: R643.2 R647.1 U35.BA20
EC_RCIN#: R639.2 R652.2 U35.AW13
EC_RTCRST: PQ6059.2 PQ6060.2 R786.1 U45.3
EC_SCI#: R571.1 R781.1 U45.23
ECAGND: C495.2 C516.1 L11.2 U45.75
EDP_AUX#_C: C2.2 CN5.22 R449.2 R450.1
EDP_AUX_C: C4.2 CN5.23 R447.1 R448.2
EDP_AUXN: C2.1 U35.E45
EDP_AUXP: C4.1 U35.F45
EDP_HPD: C804.2 R457.1 R563.2 U35.L10
EDP_HPD_R: CN5.25 R457.2
EDP_RCOMP: R154.1 U35.E52
EDP_TXN0: C12.1 U35.C47
EDP_TXN0_C: C12.2 CN5.16
EDP_TXN1: C8.1 U35.D46
EDP_TXN1_C: C8.2 CN5.19
EDP_TXP0: C13.1 U35.C46
EDP_TXP0_C: C13.2 CN5.17
EDP_TXP1: C10.1 U35.C45
EDP_TXP1_C: C10.2 CN5.20
EDP_VDD_EN: R37.1 U35.U13
EDP_VDD_EN_R: R37.2 R38.2 U1.3
ESPI_RST#: R748.2 R749.2 U45.22
FANSIG: C719.2 CN8.2 R609.2 U45.47
FB_CAL_PD_VDDQ: R84.2 U34.D22
FB_CAL_PU_GND: R73.2 U34.C24
FB_CAL_TERM_GND: R71.2 U34.B25
FB_CLAMP_MON: Q14.1 R120.1 U34.C6
FB_CLAMP_REQ#: R125.2 R379.1 U45.20
FBA_CMD0: R60.2 U4.K1 U5.K1 U31.K1 U32.K1 U34.C27
FBA_CMD1: U4.L2 U5.L2 U34.C26
FBA_CMD2: U31.L2 U32.L2 U34.E24
FBA_CMD3: R59.1 U4.K9 U5.K9 U31.K9 U32.K9 U34.F24
FBA_CMD4: R458.2 R459.1 U2.R7 U3.R7 U4.R7 U5.R7 U28.R3 U29.R3 U31.R3 U32.R3 U34.D27
FBA_CMD5: R461.2 R462.1 U2.R2 U3.R2 U4.R2 U5.R2 U28.R8 U29.R8 U31.R8 U32.R8 U34.D26
FBA_CMD6: R45.2 R46.1 U2.N8 U3.N8 U4.N8 U5.N8 U28.N2 U29.N2 U31.N2 U32.N2 U34.F25
FBA_CMD7: R50.2 R51.1 U2.N7 U3.N7 U4.N7 U5.N7 U28.N3 U29.N3 U31.N3 U32.N3 U34.F26
FBA_CMD8: R445.2 R446.1 U2.T8 U3.T8 U4.T8 U5.T8 U28.T8 U29.T8 U31.T8 U32.T8 U34.F23
FBA_CMD9: R41.2 R42.1 U2.N3 U3.N3 U4.N3 U5.N3 U28.N7 U29.N7 U31.N7 U32.N7 U34.G22
FBA_CMD10: R22.2 R23.1 U2.P3 U3.P3 U4.P3 U5.P3 U28.P7 U29.P7 U31.P7 U32.P7 U34.G23
FBA_CMD11: R61.1 R62.2 U2.J3 U3.J3 U4.J3 U5.J3 U28.J3 U29.J3 U31.J3 U32.J3 U34.G24
FBA_CMD12: R455.2 R456.1 U2.T7 U3.T7 U4.T7 U5.T7 U28.T3 U29.T3 U31.T3 U32.T3 U34.F27
FBA_CMD13: R24.2 R25.1 U2.N2 U3.N2 U4.N2 U5.N2 U28.N8 U29.N8 U31.N8 U32.N8 U34.G25
FBA_CMD14: R451.2 R452.1 U2.T3 U3.T3 U4.T3 U5.T3 U28.T7 U29.T7 U31.T7 U32.T7 U34.G27
FBA_CMD15: R63.1 R64.2 U2.K3 U3.K3 U4.K3 U5.K3 U28.K3 U29.K3 U31.K3 U32.K3 U34.G26
FBA_CMD16: R47.1 U2.K1 U3.K1 U28.K1 U29.K1 U34.M24
FBA_CMD17: U2.L2 U3.L2 U34.M23
FBA_CMD18: U28.L2 U29.L2 U34.K24
FBA_CMD19: R43.2 U2.K9 U3.K9 U28.K9 U29.K9 U34.K23
FBA_CMD20: R453.1 U2.T2 U3.T2 U4.T2 U5.T2 U28.T2 U29.T2 U31.T2 U32.T2 U34.M27
FBA_CMD21: R20.1 R21.2 U2.R8 U3.R8 U4.R8 U5.R8 U28.R2 U29.R2 U31.R2 U32.R2 U34.M26
FBA_CMD22: R29.1 R30.2 U2.P2 U3.P2 U4.P2 U5.P2 U28.P8 U29.P8 U31.P8 U32.P8 U34.M25
FBA_CMD23: R17.1 R18.2 U2.R3 U3.R3 U4.R3 U5.R3 U28.R7 U29.R7 U31.R7 U32.R7 U34.K26
FBA_CMD24: R39.1 R40.2 U2.P7 U3.P7 U4.P7 U5.P7 U28.P3 U29.P3 U31.P3 U32.P3 U34.K22
FBA_CMD25: R55.2 R56.1 U2.L3 U3.L3 U4.L3 U5.L3 U28.L7 U29.L7 U31.L7 U32.L7 U34.J23
FBA_CMD26: R26.1 R27.2 U2.P8 U3.P8 U4.P8 U5.P8 U28.P2 U29.P2 U31.P2 U32.P2 U34.J25
FBA_CMD27: R31.2 R32.1 U28.M3 U29.M3 U31.M3 U32.M3 U34.J24
FBA_CMD28: R54.2 R57.1 U2.L7 U3.L7 U4.L7 U5.L7 U28.L3 U29.L3 U31.L3 U32.L3 U34.K27
FBA_CMD29: R48.1 R49.2 U2.M2 U3.M2 U4.M2 U5.M2 U28.M2 U29.M2 U31.M2 U32.M2 U34.K25
FBA_CMD30: R35.2 R36.1 U2.M3 U3.M3 U4.M3 U5.M3 U34.J27
FBA_ZQ0: R487.1 U32.L8
FBA_ZQ1: R486.1 U31.L8
FBA_ZQ2: R78.1 U5.L8
FBA_ZQ3: R70.1 U4.L8
FBA_ZQ4: R464.1 U29.L8
FBA_ZQ5: R471.1 U28.L8
FBA_ZQ6: R69.1 U3.L8
FBA_ZQ7: R44.1 U2.L8
FBVDDQ_EN: PR73.1 R126.2 R137.1 U9.4
FCCM_A: PR42.1 PR238.2
FCCM_B: PR26.2 PR229.2 PR234.2
FCCM_C: PR46.1 PR240.2
G_MBCLK_R: C431.1 R329.2 R333.1 U19.4
G_MBDATA_R: C454.1 R334.1 R336.2 U19.6
GC6_FB_EN: R128.2 R139.1 R199.2 R204.1 U35.AN7
GPIO0: TP41.1 U26.17
GPIO12_ACIN: Q9.1 R94.1 R758.2 U34.D7
GPU_EVENT#: Q15.1 R107.1 R516.1 U34.A4
GPU_GPIO16: TP58.1 U34.D5
GPU_PEX_RST_HOLD#: R501.1 U7.1 U34.C4
GPU_PWR_GD: PR110.2 R137.2 U9.1
GPU_THROTTING#: PQ40.3 R758.1
GPUT_CLK_L: Q13.1 R100.2 U34.D9
GPUT_DATA_L: Q13.4 R101.2 U34.D8
GPX: R727.2 U44.6
GSPI0_MOSI: R619.2 U35.AR7
GSPI1_MOSI: R207.2 U35.AN5
H_CPU_SVIDART#: R552.1 U35.B63
H_CPU_SVIDCLK: PR35.1 PR341.2 U35.A63
H_CPU_SVIDDAT: PR40.2 PR340.2 R138.2 U35.D64
H_PECI: R738.2 U35.A54
H_PROCHOT#: PR32.2 PR174.1 PR200.2 PU5.10 Q30.3 R465.1 R531.1
H_PROCHOT#_R: R531.2 U35.C65
HDA_BCLK_R: R644.2 U35.AY22
HDA_RST#_R: R660.2 U35.AW22
HDA_SDO_R: R645.2 R737.2 U35.BB22
HDA_SYNC_R: C742.2 R667.2 U35.BA22
HDMI4K2K_CFG: R311.2 U18.23
HDMI4K2K_DDCBUF: R297.2 U18.14
HDMI4K2K_EN: R298.2 U18.13
HDMI4K2K_EQ: R292.2 R295.1 U18.17
HDMI4K2K_ISET: R320.1 R321.2 U18.34
HDMI4K2K_PRE: R293.2 R296.1 U18.16
HDMI_5V: C383.1 CN12.18 D6.1 Q26.1
HDMI_DDCCLK_MB: CN12.15 R316.2 U18.32
HDMI_DDCCLK_SW: R322.1 U18.38 U35.L13
HDMI_DDCDATA_MB: CN12.16 R317.2 U18.33
HDMI_DDCDATA_SW: R319.1 U18.39 U35.L12
HDMI_MB_HPD: R720.1 R721.1 U18.28
HDMI_MB_HPD_R: Q41.3 R718.1 U18.3
HP-L2: C552.2 R421.1 R422.2 R423.1 U23.32
HP-L3: C553.1 CN21.1 R422.1
HP-R2: C549.2 R417.1 R418.1 R420.2 U23.33
HP-R3: C550.1 CN21.2 R420.1
HP_DET_CN: CN12.19 R721.2
HP_JD#: CN21.6 D33.1 R383.1
HSYNC: U13.2 U40.2
HWPG: D11.2 D14.2 D17.2 D18.2 D19.2 D20.2 R102.2 R374.1 U45.21
HWPG_1.5V: D18.1 PR332.2
HWPG_1.5VGFX: PR252.1 PR255.1 PR346.1 R83.2
HWPG_1.05VGFX: PR302.1 PR304.1 TP76.1
HWPG_1.8VS5: D11.1 PR245.2
HWPG_1VS5: D17.1 PR257.1 PU12.1
HWPG_+VCCOPC: D14.1 PR290.1 PR293.1
HWPG_VDDR: D20.1 PR295.1 PU15.20
I2C0_SCL: Q43.4 R166.2 R403.1 U35.U6
I2C0_SDA: Q43.1 R167.2 R405.1 U35.U7
I2C1_SCL: Q2.3 R13.2 R169.1 U35.U9
I2C1_SCL_C: Q2.4 R6.1 R12.1 R13.1
I2C1_SDA: Q2.6 R10.2 R165.1 U35.U8
I2C1_SDA_C: Q2.1 R5.1 R9.1 R10.1
I2C_TP_SCL_R: CN17.3 Q43.3 R403.2 R410.1
I2C_TP_SDA_R: CN17.4 Q43.6 R405.2 R409.1
I2CA_SCL: R521.1 U34.B7
I2CA_SDA: R502.1 U34.A7
ICMNT: C516.2 PC3.2 PR170.1 U45.67
IDCHG: PC6.2 PR171.1 U45.70
ILIM_HI: R377.1 U22.16
ILIM_LO: R376.2 U22.15
IMVP_PWRGD: PR30.2 PR197.2 R478.1 U33.2
IMVP_PWRGD_3V: Q31.2 R113.2 R478.2 R485.2 U8.1 U33.4
INT_AMIC-VREFO: C534.1 R397.2 U23.27
INT_HDMI_HPD: Q41.1 R718.2 R722.2 U35.L9
INT_HDMICLK+: C389.1 U35.G56
INT_HDMICLK+_C: CN12.10 R303.1 U18.22
INT_HDMICLK+_C_R: C389.2 U18.9
INT_HDMICLK-: C387.1 U35.F56
INT_HDMICLK-_C: CN12.12 R303.2 U18.21
INT_HDMICLK-_C_R: C387.2 U18.10
INT_HDMITX0N: C398.1 U35.F53
INT_HDMITX0N_C: CN12.9 R312.2 U18.24
INT_HDMITX0N_C_R: C398.2 U18.7
INT_HDMITX0P: C405.1 U35.G53
INT_HDMITX0P_C: CN12.7 R312.1 U18.25
INT_HDMITX0P_C_R: C405.2 U18.6
INT_HDMITX1N: C406.1 U35.E58
INT_HDMITX1N_C: CN12.6 R314.2 U18.26
INT_HDMITX1N_C_R: C406.2 U18.5
INT_HDMITX1P: C407.1 U35.F58
INT_HDMITX1P_C: CN12.4 R314.1 U18.27
INT_HDMITX1P_C_R: C407.2 U18.4
INT_HDMITX2N: C408.1 U35.E55
INT_HDMITX2N_C: CN12.3 R315.2 U18.29
INT_HDMITX2N_C_R: C408.2 U18.2

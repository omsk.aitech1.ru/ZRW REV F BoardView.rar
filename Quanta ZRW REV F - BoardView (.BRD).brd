# Allegro board Quanta ZRW REV F - BoardView (.BRD).brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
M_A_DQ56: length 77.6
  IN1 w0.127: v1(161.38,52.32) 162.14,52.32 162.34,52.52 162.34,52.88 162.22,53 162.01,53 161.89,53.13 161.89,56.43 162.01,56.56 162.22,56.56 162.34,56.69 162.34,58.4 164.46,60.52 164.46,62.93 164.65,63.11 164.65,70.54 161.96,73.23 161.96,78.66 159.77,80.86 159.77,84.7 159.23,85.24 159.23,85.8 155.77,89.26 155.77,95.14 155.54,95.37 154.68,95.37 154.55,95.49 154.55,95.75 154.68,95.88 155.32,95.88 155.44,96 155.44,96.22 150.46,101.2 150.46,101.55 147.87,104.14 145.87,104.14 145.45,104.55 142.53,104.55 v1(142.41,104.42)
  BOTTOM w0.076: v1(142.41,104.42) 142.97,104.98 142.97,106.21 142.15,107.02 142.15,108.05 142.26,108.16 142.26,108.42 142.23,108.51 142.23,108.52 142.23,108.77 142.26,108.86 142.26,109.07 142.23,109.15 142.23,109.15 142.2,109.25 142.2,109.51 U35.AY27
  BOTTOM w0.114: v1(161.38,52.32) 160.64,53.05 JDIM2.191
M_A_DQ57: length 78.1
  IN1 w0.127: v1(161.38,53.82) 161.56,54 161.56,56.82 162.01,57.28 162.01,58.53 164.11,60.63 164.11,63.06 164.29,63.24 164.29,70.37 161.63,73.02 161.63,78.53 159.44,80.72 159.44,84.56 158.79,85.2 158.79,85.38 158.9,85.49 158.9,85.67 158.72,85.84 158.54,85.84 158.44,85.74 158.26,85.74 158.08,85.92 158.08,86.1 158.18,86.2 158.18,86.38 158,86.56 157.82,86.56 157.72,86.46 157.54,86.46 154.04,89.95 154.04,90.88 154.17,91.01 154.74,91.01 154.87,91.14 154.87,91.39 154.74,91.52 154.17,91.52 154.04,91.65 154.04,91.9 154.17,92.03 154.74,92.03 154.87,92.15 154.87,92.41 154.74,92.53 154.17,92.53 154.04,92.66 154.04,92.92 154.17,93.04 154.74,93.04 154.87,93.17 154.87,93.42 154.74,93.55 154.17,93.55 154.04,93.68 154.04,93.93 154.17,94.06 154.74,94.06 154.87,94.19 154.87,94.44 154.74,94.57 154.17,94.57 154.04,94.69 154.04,96.52 146.75,103.81 145.3,103.81 144.89,104.22 142.85,104.22 v1(142.41,103.77)
  BOTTOM w0.076: U35.AW27 142.1,110.08 141.77,109.75 141.77,109.21 141.57,109 141.57,108.09 141.66,108 141.66,106.81 141.98,106.48 141.98,104.2 v1(142.41,103.77)
  BOTTOM w0.114: v1(161.38,53.82) 161.24,53.95 JDIM2.193
M_A_DQ58: length 77.7
  IN1 w0.127: v1(159.02,53.59) 159.02,58.47 161.02,60.47 161.02,64.54 161.75,65.27 162.04,65.27 162.44,65.67 162.44,67.38 160.3,69.53 160.3,71.61 159.4,72.51 159.4,78.16 157.59,79.96 157.59,83.75 151.17,90.18 151.17,91.17 151.29,91.3 152.01,91.3 152.13,91.43 152.13,91.68 152.01,91.81 151.29,91.81 151.17,91.94 151.17,92.19 151.29,92.32 152.01,92.32 152.13,92.44 152.13,92.7 152.01,92.83 151.29,92.83 151.17,92.95 151.17,93.21 151.29,93.33 152.01,93.33 152.13,93.46 152.13,93.71 152.01,93.84 151.29,93.84 151.17,93.97 151.17,94.22 151.29,94.35 152.01,94.35 152.13,94.48 152.13,94.73 152.01,94.86 151.29,94.86 151.17,94.98 151.17,95.31 151.29,95.44 151.66,95.44 151.79,95.57 151.79,95.82 151.66,95.95 151.29,95.95 151.17,96.08 151.17,96.79 147.88,100.07 144.51,100.07 v1(144.36,99.92)
  BOTTOM w0.076: v1(144.36,99.92) 144.36,99.94 144.78,100.37 144.78,106.13 143.77,107.14 143.77,108.44 143.64,108.69 143.6,108.8 143.6,109.14 143.32,109.41 U35.AY25
  BOTTOM w0.114: JDIM2.183 158.24,54.12 158.78,53.59 v1(159.02,53.59)
M_A_DQ59: length 78.5
  IN1 w0.127: v1(144.36,100.55) 147.87,100.55 152.16,96.26 152.16,95.31 152.48,94.99 152.48,89.33 157.92,83.88 157.92,80.1 159.73,78.29 159.73,72.64 160.74,71.63 160.74,69.6 162.78,67.56 162.78,65.4 162.29,64.92 161.92,64.92 161.38,64.38 161.38,60.36 160.05,59.03 160.05,56.71 159.92,56.59 159.62,56.59 159.49,56.46 159.49,56.21 159.62,56.08 159.92,56.08 160.05,55.95 160.05,55.7 159.92,55.57 159.62,55.57 159.49,55.44 159.49,55.19 159.62,55.06 159.92,55.06 160.05,54.94 160.05,54.68 159.92,54.56 159.62,54.56 159.49,54.43 159.49,54.17 159.62,54.05 159.92,54.05 160.05,53.92 160.05,53.67 159.92,53.54 159.62,53.54 159.49,53.41 159.49,53.16 159.62,53.03 159.92,53.03 160.05,52.9 160.05,52.57 159.67,52.19 v1(159.09,52.19)
  BOTTOM w0.076: v1(144.36,100.55) 143.13,101.78 143.13,106.28 142.32,107.09 142.32,107.98 142.43,108.09 142.43,108.45 142.43,108.45 142.39,108.54 142.39,108.74 142.43,108.83 142.43,108.83 142.43,108.83 142.44,108.84 142.44,109.07 142.39,109.2 142.39,109.45 142.47,109.55 142.47,110.06 142.67,110.27 U35.AW25
  BOTTOM w0.114: JDIM2.181 157.64,53.95 158.46,53.13 158.46,52.7 158.97,52.19 v1(159.09,52.19)
M_A_DQ60: length 75.8
  IN1 w0.127: v1(161.56,50.08) 162.68,51.2 162.68,58.26 164.79,60.38 164.79,62.68 164.98,62.86 164.98,70.7 162.29,73.39 162.29,78.8 160.1,81 160.1,84.84 159.56,85.37 159.56,85.94 156.1,89.4 156.1,96.03 150.96,101.16 150.96,101.64 148.14,104.47 146,104.47 145.59,104.88 142.6,104.88 v1(142.41,105.07)
  BOTTOM w0.076: v1(142.41,105.07) 142.8,105.47 142.8,106.14 141.99,106.96 141.99,108.31 U35.BB27
  BOTTOM w0.114: JDIM2.192 160.94,48.89 161.1,49.05 161.1,49.63 v1(161.56,50.08)
M_A_DQ61: length 76.2
  IN1 w0.127: v1(161.56,48.56) 162.14,49.14 162.14,49.4 163.01,50.26 163.01,58.12 165.12,60.24 165.12,62.47 165.31,62.65 165.31,70.99 163.21,73.1 163.21,78.35 160.43,81.13 160.43,84.97 159.89,85.51 159.89,86.08 156.43,89.54 156.43,96.17 151.35,101.25 151.35,101.72 148.27,104.8 146.14,104.8 145.73,105.21 142.92,105.21 v1(142.41,105.72)
  BOTTOM w0.076: v1(142.41,105.72) 142.41,106.3 141.82,106.89 141.82,108.07 141.73,108.16 141.73,108.48 142,108.74 U35.BA27
  BOTTOM w0.114: v1(161.56,48.56) 161.54,48.55 JDIM2.194
M_A_DQ62: length 76.3
  IN1 w0.076: v1(144.39,103.77) 143.76,103.15 143.76,99.73 144.13,99.36 146.98,99.36
  IN1 w0.127: v1(157.75,49.81) 157.98,49.81 158.46,50.29 158.46,51.44 158.22,51.68 158.22,58.68 160.36,60.83 160.36,64.89 160.54,65.07 160.54,67.99 159.38,69.14 159.38,71.59 158.74,72.23 158.74,77.88 156.93,79.68 156.93,80.2 156.81,80.32 156.42,80.32 156.32,80.43 156.32,80.76 156.4,80.83 156.81,80.83 156.93,80.96 156.93,81.29 156.81,81.42 156.36,81.42 156.29,81.49 156.29,81.82 156.39,81.92 156.81,81.92 156.93,82.05 156.93,82.31 156.81,82.43 156.46,82.43 156.34,82.56 156.34,82.81 156.46,82.94 156.81,82.94 156.93,83.07 156.93,83.45 156.75,83.63 156.48,83.63 156.32,83.8 156.32,84.09 150.51,89.9 150.51,96.51 147.66,99.36 146.98,99.36
  BOTTOM w0.076: U35.BA25 143.32,108.82 143.47,108.67 143.6,108.4 143.6,106.93 144.39,106.14 v1(144.39,103.77)
  BOTTOM w0.114: v1(157.75,49.81) 157.34,49.4 JDIM2.180
M_A_DQ63: length 75.5
  IN1 w0.076: 146.65,99.69 145.75,99.69 145.59,99.53 144.2,99.53 143.94,99.78 143.94,102.68 v1(144.39,103.12)
  IN1 w0.127: v1(157.79,48.48) 157.79,47.79 157.95,47.62 158.58,47.62 158.84,47.87 158.84,51.81 158.55,52.1 158.55,58.55 160.69,60.69 160.69,64.68 161.54,65.53 161.54,67.5 159.85,69.19 159.85,71.58 159.07,72.37 159.07,78.02 157.26,79.82 157.26,83.61 150.84,90.04 150.84,96.65 147.8,99.69 146.65,99.69
  BOTTOM w0.076: U35.BB25 143.32,108.18 143.43,108.07 143.43,106.84 143.99,106.28 143.99,103.51 v1(144.39,103.12)
  BOTTOM w0.114: JDIM2.182 157.94,48.32 v1(157.79,48.48)
M_A_DQS0: length 89.8
  IN1 w0.127: v1(104.62,49.55) 104.46,49.72 104.46,50.13 103.91,50.67 103.72,50.67 102.7,51.68 102.7,53.8 101.03,55.48 100.52,55.48 100.03,55.98 100.03,60.61 99.62,61.02 98.44,61.02 98.31,61.15 98.31,61.53 98.44,61.65 99.66,61.65 99.92,61.92 99.92,62.5 99.66,62.77 98.38,62.77 98.23,62.92 98.23,65.24 99.01,66.02 99.01,105.78 102.45,109.23 102.45,109.71 107.65,114.91 110.32,114.91 110.57,115.15 110.57,115.47 v1(110.72,115.62)
  BOTTOM w0.076: 113.81,114.97 113.85,114.93 115.73,114.93 115.8,114.87 116.28,114.87 116.44,114.93 116.59,114.93 116.81,114.83 117.27,114.83 117.53,114.57 U35.AM69
  BOTTOM w0.114: JDIM2.12 104.54,48.08 104.41,48.22 104.41,49.34 v1(104.62,49.55) ; 113.81,114.97 111.01,114.97 110.72,115.26 v1(110.72,115.62)
M_A_DQS1: length 79.5
  IN1 w0.127: v1(109.31,52.58) 109.16,52.73 109.16,53.47 106.18,56.45 106.18,59.03 105.07,60.15 105.07,63.88 104.86,64.08 104.86,67.31 105.19,67.63 105.19,91.8 105.75,92.36 105.75,93.85 105.48,94.12 104.36,94.12 104.23,94.24 104.23,94.63 104.36,94.75 105.48,94.75 105.75,95.02 105.75,95.6 105.48,95.87 103.95,95.87 103.82,96 103.82,104.61 106.8,107.6 106.8,107.76 109.52,110.49 111.94,110.49 112.44,110.99 114.13,110.99 114.3,111.16 114.3,111.75 v5(114.69,112.15)
  BOTTOM w0.076: U35.AT70 117.16,111.96 117.1,111.9 116.75,111.9 116.6,111.85 116.41,111.85 116.28,111.9 115.81,111.9 115.64,111.74 114.46,111.74 114.4,111.8 114.4,111.96 114.59,112.15 v5(114.69,112.15)
  BOTTOM w0.114: JDIM2.29 109.64,54.43 109.1,53.88 109.1,52.79 v1(109.31,52.58)
M_A_DQS2: length 75.6
  IN1 w0.127: v1(114.13,52.07) 113.45,52.75 113.45,55.44 112.29,56.59 112.29,59.79 110.43,61.66 110.43,66.69 111.11,67.37 111.11,80.65 111.38,80.92 112.5,80.92 112.62,81.05 112.62,81.43 112.5,81.56 111.38,81.56 111.11,81.82 111.11,82.41 111.38,82.67 112.75,82.67 112.88,82.8 112.88,83.18 112.75,83.31 111.38,83.31 111.11,83.58 111.11,84.16 111.38,84.43 112.7,84.43 112.88,84.6 112.88,85.11 112.61,85.38 112.61,98.04 113.98,99.41 113.98,102.71 114.29,103.02 114.47,103.02 v1(114.67,103.22)
  BOTTOM w0.076: v1(114.67,103.22) 115.4,103.22 115.66,103.48 115.66,105.51 116.33,106.19 118.23,106.19 120.2,108.16 120.2,108.42 120.15,108.53 120.15,108.75 120.2,108.86 120.2,109.07 120.17,109.15 120.17,109.44 120.26,109.62 120.5,109.87 U35.AY64
  BOTTOM w0.114: JDIM2.47 115.04,52.62 114.67,52.24 114.31,52.24 v1(114.13,52.07)
M_A_DQS3: length 68.1
  IN1 w0.127: v1(118.87,49.81) 119.14,49.54 119.26,49.54 119.36,49.65 119.36,50.5 118.74,51.13 118.74,56.22 118.41,56.55 118.41,63.42 118,63.83 118,67.7 118.1,67.81 118.1,99.85 118.75,100.49 118.75,102.33 119.51,103.1 119.51,103.79 120.08,104.36 120.48,104.36 v5(120.64,104.52)
  BOTTOM w0.076: U35.BA60 122.95,109.5 123,109.54 123.15,109.54 123.16,109.53 123.22,109.4 123.22,109.18 123.19,109.1 123.19,108.83 123.24,108.7 123.24,108.59 123.19,108.45 123.19,108.09 123.31,107.97 123.31,107.56 122.86,107.11 122.86,106.87 121.21,105.22 121.21,104.48 121.01,104.28 120.88,104.28 v5(120.64,104.52)
  BOTTOM w0.114: JDIM2.64 120.14,48.1 119.97,48.27 119.97,48.97 119.44,49.5 119.18,49.5 v1(118.87,49.81)
M_A_DQS4: length 68.1
  IN1 w0.076: 138.37,97.02 138.37,97.04 138.4,97.08 138.4,97.2 138.24,97.36 137.67,97.36 135.93,99.1 135.93,103.17 135.71,103.39 135.51,103.39 135.37,103.25 v1(135.37,103.12)
  IN1 w0.127: 138.37,97.02 138.37,86.05 143.53,80.89 143.53,80.5 144.28,79.75 144.28,68.3 144.65,67.93 144.65,66.47 144.92,66.19 144.92,64.52 144.64,64.24 144.64,63.75 144.9,63.49 144.9,63.1 144.64,62.83 144.64,62.25 144.92,61.97 144.92,61.59 144.64,61.31 144.64,54.49 144.82,54.31 144.82,52.84 144.72,52.74 144.57,52.74 v1(144.27,53.03)
  BOTTOM w0.076: v1(135.37,103.12) 135.37,103.26 135.27,103.36 135.01,103.36 134.79,103.58 134.79,106.04 134.97,106.22 134.97,107.26 134.75,107.48 134.75,107.99 134.93,108.16 134.93,108.42 134.87,108.53 134.87,108.75 134.93,108.86 134.93,109.07 134.89,109.15 134.89,109.43 134.94,109.54 135.02,109.68 135.15,109.73 135.21,109.73 135.23,109.75 U35.AY38
  BOTTOM w0.114: JDIM2.137 144.44,53.87 144.32,53.74 143.94,53.74 143.6,53.4 143.6,53.02 143.87,52.75 144.13,52.75 144.27,52.89 v1(144.27,53.03)
M_A_DQS5: length 72.8
  IN1 w0.076: v1(138.93,101.27) 138.93,101.39 138.8,101.52 138.55,101.52 138.49,101.46 138.49,99.68 138.63,99.54 139.83,99.54 140.94,98.42 141.41,98.42 142.78,97.05 142.78,97.02
  IN1 w0.127: v1(149.84,49.17) 150.06,49.4 150.34,49.4 150.57,49.63 150.57,50.48 149.72,51.33 149.72,55.27 150.36,55.9 150.36,61.21 150.71,61.56 150.71,63.18 151.14,63.62 151.14,67.32 150.9,67.56 150.9,71.39 149.56,72.73 149.56,76.67 148.67,77.55 148.67,82.02 142.78,87.92 142.78,97.02
  BOTTOM w0.076: U35.BA34 137.68,109.29 137.68,109.5 137.74,109.56 137.82,109.56 137.87,109.54 137.92,109.46 137.95,109.4 137.95,109.18 137.91,109.1 137.91,108.83 137.96,108.7 137.96,108.59 137.91,108.45 137.91,107.34 138.1,107.15 138.1,101.76 138.39,101.47 138.73,101.47 v1(138.93,101.27)
  BOTTOM w0.114: v1(149.84,49.17) 149.61,49.4 149.51,49.4 149.39,49.28 149.39,48.37 149.54,48.22 JDIM2.154
M_A_DQS6: length 72.4
  IN1 w0.076: 146.82,97.02 146.82,97.13 145.58,98.37 143.72,98.37 141.47,100.62 141.47,103.24 141.32,103.39 140.91,103.39 140.8,103.29 v5(140.8,103.12)
  IN1 w0.127: 146.82,97.02 146.82,96.66 147.37,96.11 147.37,92.94 146.75,92.32 146.75,91.08 147.4,90.43 147.4,89.25 153.2,83.45 153.2,79.44 155.79,76.85 155.79,68.67 155.96,68.5 155.96,65.39 156.43,64.93 156.43,60.71 155.17,59.46 155.17,53.87 155.45,53.59 155.45,52.5 155.31,52.36 155.14,52.36 v1(154.81,52.69)
  BOTTOM w0.076: v5(140.8,103.12) 140.8,103.25 140.7,103.35 140.38,103.35 140.23,103.5 140.23,106.89 139.88,107.24 139.88,107.78 139.91,107.81 139.91,108.42 139.86,108.53 139.86,108.73 139.91,108.86 139.91,109.07 139.87,109.15 139.87,109.43 139.92,109.54 139.95,109.59 140,109.68 140.13,109.73 140.19,109.73 140.21,109.75 U35.AY30
  BOTTOM w0.114: v1(154.81,52.69) 154.81,52.59 154.57,52.35 154.34,52.35 154.27,52.41 154.27,54.02 154.35,54.09 154.53,54.09 154.64,54.21 JDIM2.171
M_A_DQS7: length 77.5
  IN1 w0.127: v1(144.39,101.2) 144.64,101.44 147.88,101.44 153.11,96.21 153.11,89.65 158.56,84.2 158.56,80.36 160.46,78.46 160.46,72.81 161.37,71.9 161.37,70.79 163.41,68.75 163.41,64.6 162.92,64.1 162.92,60.68 160.68,58.44 160.68,51.84 159.74,50.9 159.74,49.83 160.05,49.53 160.31,49.53 v1(160.52,49.32)
  BOTTOM w0.076: U35.BA26 142.66,109.5 142.72,109.56 142.8,109.56 142.85,109.54 142.9,109.46 142.93,109.4 142.93,109.18 142.89,109.1 142.89,108.83 142.94,108.7 142.94,108.59 142.89,108.45 142.89,108.09 143.1,107.88 143.1,106.64 143.43,106.31 143.43,101.87 143.84,101.46 144.27,101.46 144.39,101.34 v1(144.39,101.2)
  BOTTOM w0.114: JDIM2.188 159.74,48.24 159.6,48.38 159.6,49.53 159.73,49.65 160.19,49.65 v1(160.52,49.32)
M_A_DQS#0: length 89.7
  IN1 w0.127: v1(103.96,49.55) 104.02,49.55 104.19,49.72 104.19,50.05 103.81,50.43 103.62,50.43 102.46,51.58 102.46,53.7 100.93,55.24 100.42,55.24 99.78,55.88 99.78,60.51 99.52,60.78 98.34,60.78 98.07,61.05 98.07,61.63 98.34,61.9 99.56,61.9 99.68,62.02 99.68,62.4 99.56,62.53 98.28,62.53 97.99,62.82 97.99,65.35 98.77,66.12 98.77,105.88 102.21,109.33 102.21,109.81 107.55,115.15 110.22,115.15 110.33,115.25 110.33,115.36 v1(110.07,115.62)
  BOTTOM w0.076: U35.AM70 116.96,114.67 116.77,114.67 116.55,114.77 116.47,114.77 116.31,114.7 115.73,114.7 115.66,114.77 113.78,114.77 113.78,114.76 113.76,114.76
  BOTTOM w0.114: JDIM2.10 103.94,48.09 104.18,48.32 104.18,49.34 v1(103.96,49.55) ; v1(110.07,115.62) 110.93,114.76 113.76,114.76
M_A_DQS#1: length 79.6
  IN1 w0.127: v1(114.06,112.16) 114.06,111.26 114.01,111.21 112.32,111.21 111.84,110.73 109.42,110.73 106.56,107.86 106.56,107.7 103.58,104.71 103.58,95.9 103.85,95.63 105.38,95.63 105.51,95.5 105.51,95.12 105.38,94.99 104.26,94.99 103.99,94.73 103.99,94.14 104.26,93.88 105.38,93.88 105.51,93.75 105.51,92.46 104.95,91.9 104.95,67.73 104.62,67.41 104.62,63.98 104.83,63.78 104.83,60.05 105.94,58.93 105.94,56.35 108.92,53.37 108.92,53.09 v1(108.65,52.83)
  BOTTOM w0.076: v1(114.06,112.16) 114.24,111.98 114.24,111.73 114.39,111.58 115.71,111.58 115.88,111.74 116.25,111.74 116.38,111.69 116.63,111.69 116.65,111.7 116.78,111.74 117.42,111.74 U35.AT69
  BOTTOM w0.114: JDIM2.27 109.04,54.16 108.87,53.98 108.87,53.05 v1(108.65,52.83)
M_A_DQS#2: length 75.7
  IN1 w0.127: v1(114.85,102.41) 114.77,102.48 114.77,102.61 114.6,102.78 114.39,102.78 114.19,102.58 114.19,99.32 112.85,97.98 112.85,85.48 113.12,85.21 113.12,84.5 112.8,84.19 111.48,84.19 111.35,84.06 111.35,83.68 111.48,83.55 112.85,83.55 113.12,83.28 113.12,82.7 112.85,82.43 111.48,82.43 111.35,82.31 111.35,81.92 111.48,81.8 112.6,81.8 112.86,81.53 112.86,80.95 112.6,80.68 111.48,80.68 111.35,80.55 111.35,67.27 110.67,66.59 110.67,61.76 112.53,59.89 112.53,56.69 113.69,55.54 113.69,52.85 113.83,52.71 113.94,52.71 v1(114.13,52.9)
  BOTTOM w0.076: v1(114.85,102.41) 114.85,102.84 115.06,103.06 115.47,103.06 115.82,103.41 115.82,105.44 116.4,106.02 118.3,106.02 120.37,108.09 120.37,108.45 120.32,108.59 120.32,108.7 120.37,108.83 120.37,109.1 120.33,109.18 120.33,109.4 120.39,109.53 120.43,109.57 120.53,109.57 120.6,109.5 U35.BA64
  BOTTOM w0.114: JDIM2.45 114.44,54.3 114.82,53.92 114.82,52.71 114.57,52.47 114.26,52.47 114.13,52.6 v1(114.13,52.9)
M_A_DQS#3: length 68
  IN1 w0.127: v1(120.64,103.86) 120.36,104.15 120.17,104.15 119.72,103.7 119.72,103.01 118.96,102.25 118.96,100.4 118.34,99.79 118.34,67.71 118.24,67.6 118.24,63.97 118.65,63.56 118.65,56.65 118.98,56.32 118.98,51.23 119.61,50.6 119.61,49.55 119.36,49.3 119,49.3 v1(118.87,49.17)
  BOTTOM w0.076: v1(120.64,103.86) 120.9,104.11 121.08,104.11 121.37,104.41 121.37,105.15 123.02,106.8 123.02,107.05 123.47,107.49 123.47,108.04 123.35,108.16 123.35,108.42 123.4,108.53 123.4,108.75 123.35,108.86 123.35,109.07 123.39,109.15 123.39,109.44 123.3,109.62 123.21,109.71 123.14,109.71 123.05,109.79 U35.AY60
  BOTTOM w0.114: JDIM2.62 119.54,48.16 119.74,48.35 119.74,48.87 119.34,49.27 118.97,49.27 v1(118.87,49.17)
M_A_DQS#4: length 68
  IN1 w0.076: 138.61,97.02 138.61,97.04 138.57,97.08 138.57,97.27 138.31,97.53 137.74,97.53 136.09,99.17 136.09,103.24 135.78,103.55 135.57,103.55 v5(135.37,103.75)
  IN1 w0.127: 138.61,97.02 138.61,86.15 143.77,80.99 143.77,80.6 144.52,79.85 144.52,68.4 144.89,68.03 144.89,66.57 145.16,66.29 145.16,64.42 144.88,64.14 144.88,63.85 145.14,63.59 145.14,63 144.88,62.73 144.88,62.35 145.16,62.07 145.16,61.49 144.88,61.21 144.88,54.59 145.06,54.41 145.06,52.74 144.82,52.5 144.42,52.5 v1(144.27,52.35)
  BOTTOM w0.076: U35.BA38 135.33,109.29 135.33,109.5 135.26,109.56 135.18,109.56 135.14,109.54 135.08,109.46 135.06,109.4 135.06,109.18 135.09,109.1 135.09,108.83 135.04,108.7 135.04,108.59 135.09,108.45 135.09,108.09 134.92,107.92 134.92,107.54 135.14,107.32 135.14,106.16 134.95,105.97 134.95,103.64 135.06,103.53 135.15,103.53 v5(135.37,103.75)
  BOTTOM w0.114: JDIM2.135 143.84,53.97 143.37,53.5 143.37,52.93 143.77,52.52 144.09,52.52 v1(144.27,52.35)
M_A_DQS#5: length 72.8
  IN1 w0.076: v5(138.93,101.9) 138.71,101.69 138.48,101.69 138.32,101.53 138.32,99.61 138.56,99.37 139.76,99.37 140.88,98.26 141.34,98.26 142.53,97.06 142.53,97.02
  IN1 w0.127: v1(149.81,49.81) 149.96,49.65 150.26,49.65 150.33,49.73 150.33,50.38 149.48,51.23 149.48,55.37 150.11,56 150.11,61.31 150.47,61.66 150.47,63.28 150.9,63.72 150.9,67.22 150.66,67.46 150.66,71.29 149.31,72.63 149.31,76.57 148.43,77.45 148.43,81.92 142.53,87.82 142.53,97.02
  BOTTOM w0.076: U35.AY34 137.78,109.75 137.8,109.73 137.86,109.73 137.98,109.68 138.07,109.54 138.11,109.43 138.11,109.15 138.08,109.07 138.08,108.86 138.13,108.75 138.13,108.53 138.08,108.42 138.08,107.41 138.26,107.22 138.26,101.83 138.46,101.63 138.66,101.63 v5(138.93,101.9)
  BOTTOM w0.114: v1(149.81,49.81) 149.63,49.63 149.42,49.63 149.16,49.37 149.16,48.35 148.94,48.13 JDIM2.152
M_A_DQS#6: length 72.4
  IN1 w0.076: v1(140.81,103.77) 141.02,103.55 141.39,103.55 141.63,103.31 141.63,100.69 143.79,98.54 145.65,98.54 147.06,97.12 147.06,97.02
  IN1 w0.127: v1(154.81,51.99) 154.94,52.12 155.41,52.12 155.69,52.4 155.69,53.69 155.41,53.97 155.41,59.36 156.67,60.61 156.67,65.03 156.21,65.49 156.21,68.6 156.04,68.77 156.04,76.95 153.44,79.54 153.44,83.55 147.64,89.35 147.64,90.53 146.99,91.18 146.99,92.22 147.61,92.84 147.61,96.21 147.06,96.76 147.06,97.02
  BOTTOM w0.076: U35.BA30 140.31,109.29 140.31,109.5 140.24,109.56 140.16,109.56 140.12,109.54 140.09,109.5 140.05,109.41 140.04,109.4 140.04,109.18 140.07,109.1 140.07,108.82 140.05,108.78 140.02,108.7 140.02,108.59 140.07,108.45 140.07,107.74 140.04,107.71 140.04,107.31 140.4,106.96 140.4,103.57 140.45,103.51 140.55,103.51 v1(140.81,103.77)
  BOTTOM w0.114: v1(154.81,51.99) 154.69,52.12 154.24,52.12 154.04,52.31 JDIM2.169
M_A_DQS#7: length 77.5
  IN1 w0.127: v5(144.36,101.85) 144.53,101.68 147.98,101.68 153.35,96.31 153.35,89.75 158.8,84.3 158.8,80.46 160.7,78.56 160.7,72.91 161.61,72 161.61,70.89 163.65,68.85 163.65,64.5 163.16,64 163.16,60.57 160.92,58.34 160.92,51.74 159.98,50.8 159.98,49.93 160.1,49.81 160.31,49.81 v1(160.53,50.04)
  BOTTOM w0.076: U35.AY26 142.76,109.89 142.94,109.71 143.05,109.54 143.09,109.43 143.09,109.15 143.06,109.07 143.06,108.86 143.11,108.75 143.11,108.53 143.06,108.42 143.06,108.16 143.27,107.95 143.27,106.71 143.6,106.38 143.6,101.94 143.91,101.63 144.13,101.63 144.24,101.73 144.24,101.73 v5(144.36,101.85)
  BOTTOM w0.114: JDIM2.186 159.14,48.23 159.37,48.46 159.37,49.62 159.63,49.88 160.37,49.88 v1(160.53,50.04)
M_A_ODT0_DIMM: length 71.8
  IN1 w0.076: v2(131.77,112.43) 131.77,112.41 132.17,112.01 132.17,110.99 134.75,108.41 134.75,106.21 134.33,105.79 134.33,98.42 135.46,97.28 135.46,97.02
  IN1 w0.216: v1(138.71,49.1) 141.59,51.98 141.59,54 141.31,54.28 141.31,76.53 140.68,77.16 140.68,79.81 135.43,85.06 135.43,96.99 135.46,97.02
  BOTTOM w0.165: v2(131.77,112.43) U35.AT45 ; JDIM2.116 138.14,48.53 v1(138.71,49.1)
M_A_ODT1_DIMM: length 71.7
  IN1 w0.076: v2(132.68,111.76) 133.18,111.25 133.18,111.03 133.73,110.49 134.1,110.49 135.72,108.87 135.72,106.79 134.51,105.58 134.51,98.62 135.93,97.2 135.93,97.02
  IN1 w0.216: 135.93,97.02 135.93,85.22 141.15,80.01 141.15,77.75 141.78,77.11 141.78,54.51 142.09,54.2 142.09,51.52 140.01,49.43 v1(140.01,49.12)
  BOTTOM w0.165: v2(132.68,111.76) 132.53,111.76 U35.AT43 ; JDIM2.120 139.34,48.7 139.77,49.12 v1(140.01,49.12)
M_A_RAS#: length 68.8
  IN1 w0.216: v1(136.17,50.52) 136.17,60.72 136.65,61.21 136.65,67.08 135.52,68.21 135.52,79.95 131.8,83.67 131.8,104.5 131.41,104.9 131.41,107.56 130,108.96 129.51,108.96 128.81,109.66 128.81,110.93 v2(128.98,111.11)
  BOTTOM w0.165: JDIM2.110 136.34,47.99 136.74,48.38 136.74,49.95 v1(136.17,50.52) ; U35.AU50 v2(128.98,111.11)
M_A_WE#: length 69.1
  IN1 w0.216: v1(137.41,51.71) 138.35,52.65 138.35,59.05 138.06,59.34 138.06,64.56 138.67,65.17 138.67,67.19 137.66,68.2 137.66,75.69 137.47,75.87 137.47,80 133.27,84.2 133.27,101.15 133.39,101.27 133.39,105.71 133.24,105.86 133.24,107.9 130.39,110.74 130.39,111.3 v2(130.84,111.76)
  BOTTOM w0.165: JDIM2.113 137.24,54.22 136.74,53.72 136.74,52.39 v1(137.41,51.71) ; v2(130.84,111.76) U35.AT46
M_B_A0: length 56.2
  IN2 w0.216: v1(128.67,100.18) 128.74,100.12 128.74,96.37 128.7,96.33 128.7,75.39 129.81,74.28 129.81,72.58 129.32,72.1 129.32,69.61 131.09,67.84 131.09,66.57 131.53,66.13 131.53,65.71 131.28,65.46 131.28,64.92 132.28,63.92 v1(132.28,63.88)
  BOTTOM w0.076: 130.86,104.52 131.2,104.86 131.2,106.75 131.3,106.84 131.3,108.52 131.03,108.79 U35.BA46
  BOTTOM w0.102: v1(128.67,100.18) 129.12,100.18 130.62,101.68 130.62,104.27 130.86,104.52
  BOTTOM w0.165: JDIM1.98 132.74,61.37 132.91,61.54 133.27,61.54 133.43,61.7 133.43,62.29 133.27,62.45 132.36,62.45 132.19,62.62 132.19,62.95 132.36,63.11 133.41,63.11 133.57,63.28 133.57,63.66 133.35,63.88 v1(132.28,63.88)
M_B_A1: length 57.2
  IN2 w0.216: v5(128.69,101.49) 129.68,100.5 129.68,95.98 129.67,95.96 129.67,75.75 130.77,74.65 130.77,72.09 130.26,71.58 130.26,70.1 132.82,67.55 132.82,65.19 132.52,64.89 v1(132.27,64.89)
  BOTTOM w0.076: 130.36,104.7 130.87,105.21 130.87,106.88 130.97,106.98 130.97,107.96 130.77,108.16 130.77,108.42 130.82,108.54 130.82,108.68 130.76,108.91 130.76,109.04 130.83,109.26 130.93,109.36 U35.AY46
  BOTTOM w0.102: v5(128.69,101.49) 129.27,101.49 130.2,102.42 130.2,104.53 130.36,104.7
  BOTTOM w0.165: v1(132.27,64.89) 132.27,64.67 132.65,64.3 133.53,64.3 133.82,64 134.15,64 134.33,64.18 134.33,64.74 134.1,64.97 132.98,64.97 132.73,65.22 132.73,65.83 133,66.1 133,66.8 132.73,67.07 132.73,67.08 132.44,67.36 JDIM1.97
M_B_A2: length 58.5
  IN2 w0.216: v1(133.18,58.16) 133.18,58.16 132.65,58.69 132.65,60.32 132.85,60.52 132.85,64.56 133.29,65 133.29,67.74 130.82,70.21 130.82,71.48 131.28,71.93 131.28,74.8 130.15,75.93 130.15,100.71 128.72,102.14 v1(128.67,102.14)
  BOTTOM w0.076: 129.95,104.68 130.7,105.43 130.7,106.95 130.8,107.05 130.8,107.89 130.6,108.09 130.6,108.46 130.61,108.49 130.65,108.57 130.65,108.69 130.58,108.91 130.58,109.05 130.64,109.21 130.64,109.64 U35.AY47
  BOTTOM w0.102: v1(128.67,102.14) 129.95,103.41 129.95,104.68
  BOTTOM w0.165: v1(133.18,58.16) 132.8,58.16 132.14,58.82 JDIM1.96
M_B_A3: length 55.3
  IN2 w0.216: v1(128.67,100.84) 128.68,100.84 129.21,100.3 129.21,96.17 129.2,96.16 129.2,75.56 130.28,74.48 130.28,72.39 129.79,71.9 129.79,69.91 131.56,68.14 131.56,66.77 132.13,66.21 v1(132.28,66.21)
  BOTTOM w0.076: 130.59,104.52 131.03,104.96 131.03,106.81 131.13,106.91 131.13,108.21 U35.BB46
  BOTTOM w0.102: 130.59,104.52 130.43,104.35 130.43,101.76 129.5,100.84 v1(128.67,100.84)
  BOTTOM w0.165: v1(132.28,66.21) 132.25,66.18 132.25,66.18 131.39,65.32 131.39,65.04 131.86,64.57 131.86,64.21 131.5,63.84 131.06,63.84 130.88,64.02 130.88,64.32 130.65,64.54 130.26,64.54 130.16,64.64 130.16,65.07 130.32,65.24 130.65,65.24 131.83,66.42 131.83,67.26 131.84,67.27 JDIM1.95
M_B_A4: length 56
  IN2 w0.076: 128.27,99.56 128.27,102.52 128.53,102.79 v1(128.67,102.79)
  IN2 w0.216: 128.27,99.56 128.27,96.56 128.23,96.52 128.23,75.19 129.34,74.09 129.34,72.78 128.85,72.29 128.85,69.42 130.62,67.65 130.62,64.91 131.66,63.88 131.66,63.5 131.46,63.29 131.1,63.29 130.48,63.92 v1(130.32,63.92)
  BOTTOM w0.076: 129.27,104.24 129.92,104.89 129.92,107.83 130.14,108.05 130.14,108.45 130.14,108.45 130.1,108.54 130.1,108.74 130.14,108.83 130.14,108.83 130.14,108.83 130.15,108.84 130.15,109.07 U35.BA47
  BOTTOM w0.102: v1(128.67,102.79) 129.27,103.38 129.27,104.24
  BOTTOM w0.165: JDIM1.92 130.94,61.37 131.14,61.56 131.14,61.93 130.82,62.26 130.82,62.51 131.01,62.7 131.64,62.7 131.77,62.83 131.77,63.2 131.64,63.32 130.92,63.32 130.33,63.92 v1(130.32,63.92)
M_B_A5: length 58
  IN2 w0.076: v1(128.67,104.09) 128.31,104.09 127.98,103.75 127.98,99.69 127.8,99.51 127.8,99.44
  IN2 w0.216: v1(129.6,65.09) 130.15,65.64 130.15,67.44 128.38,69.21 128.38,72.49 128.87,72.97 128.87,73.89 127.76,75 127.76,96.72 127.8,96.76 127.8,99.44
  BOTTOM w0.076: v1(128.67,104.09) 129.75,105.17 129.75,107.94 129.97,108.16 129.97,108.42 129.94,108.51 129.94,108.52 129.94,108.77 129.97,108.86 129.97,109.07 129.94,109.15 129.94,109.15 129.91,109.25 129.91,109.42 U35.AY48
  BOTTOM w0.165: v1(129.6,65.09) 129.74,64.95 129.74,63.53 129.54,63.32 128.49,63.32 128.29,63.53 128.29,64.81 129.1,65.62 130.03,65.62 130.12,65.71 130.45,65.71 131.31,66.57 131.31,66.97 131.03,67.25 130.78,67.25 130.64,67.38 JDIM1.91
M_B_A6: length 54.5
  IN2 w0.076: 127.09,100.17 127.34,100.43 127.34,104.06 v1(128.67,105.39)
  IN2 w0.216: 127.09,100.17 126.86,99.94 126.86,97.15 126.31,96.6 126.31,73.86 127.41,72.76 127.41,68.66 128.89,67.18 128.89,65.07 129.34,64.62 129.34,62.38 129.5,62.23 129.84,62.23 130.23,62.62 v1(130.32,62.62)
  BOTTOM w0.076: v1(128.67,105.39) 129.31,106.02 129.31,106.92 129.42,107.03 129.42,108.45 129.71,108.74 U35.BA48
  BOTTOM w0.165: JDIM1.90 130.34,61.38 130.19,61.53 129.82,61.53 129.61,61.73 129.61,62.27 129.45,62.43 129.45,62.73 129.55,62.83 130.12,62.83 130.32,62.62 v1(130.32,62.62)
M_B_A7: length 57.8
  IN2 w0.076: 125.87,98.88 125.92,98.93 125.92,99.03 126.07,99.18 126.07,105.2 128.49,107.62 128.49,112.14 128.68,112.33 128.68,112.96 128.82,113.11 v2(129.02,113.11)
  IN2 w0.216: v1(127.67,62.94) 128.18,62.94 128.4,63.16 128.4,64.21 127.93,64.69 127.93,66.81 126.47,68.27 126.47,72.36 125.37,73.46 125.37,97.21 125.87,97.71 125.87,98.88
  BOTTOM w0.165: U35.AP48 v2(129.02,113.11) ; JDIM1.86 129.14,62.07 128.28,62.94 v1(127.67,62.94)
M_B_A8: length 53.6
  IN2 w0.076: 127.33,99.68 127.72,100.07 127.72,103.88 128.58,104.74 v1(128.67,104.74)
  IN2 w0.216: v1(129.67,66.92) 129.67,67.07 127.91,68.82 127.91,73.34 128.2,73.62 128.2,73.9 127.91,74.18 127.59,74.18 127.25,73.85 127,73.85 126.78,74.06 126.78,75 127.09,75.31 127.09,76.45 126.78,76.75 126.78,77.37 127,77.58 127.03,77.58 127.24,77.8 127.24,78.23 127.03,78.45 127,78.45 126.78,78.66 126.78,79.1 127,79.31 127.03,79.31 127.24,79.53 127.24,79.96 127.03,80.18 127,80.18 126.78,80.39 126.78,80.82 127,81.04 127.03,81.04 127.24,81.25 127.24,81.69 127.03,81.9 127,81.9 126.78,82.12 126.78,82.55 127,82.77 127.03,82.77 127.24,82.98 127.24,83.41 127.03,83.63 127,83.63 126.78,83.85 126.78,84.28 127,84.49 127.03,84.49 127.24,84.71 127.24,85.14 127.03,85.36 127,85.36 126.78,85.57 126.78,86 127,86.22 127.03,86.22 127.24,86.44 127.24,86.87 127.03,87.08 127,87.08 126.78,87.3 126.78,87.73 127,87.95 127.03,87.95 127.24,88.16 127.24,88.6 127.03,88.81 127,88.81 126.78,89.03 126.78,89.46 127,89.67 127.03,89.67 127.24,89.89 127.24,90.32 127.03,90.54 127,90.54 126.78,90.75 126.78,91.19 127,91.4 127.03,91.4 127.24,91.62 127.24,92.05 127.03,92.27 127,92.27 126.78,92.48 126.78,92.91 127,93.13 127.03,93.13 127.24,93.34 127.24,93.78 127.03,93.99 127,93.99 126.78,94.21 126.78,94.64 127,94.86 127.03,94.86 127.24,95.07 127.24,95.5 127.03,95.72 127,95.72 126.78,95.94 126.78,96.41 127.33,96.95 127.33,99.68
  BOTTOM w0.076: U35.BB48 129.71,108.13 129.59,108.01 129.59,106.96 129.47,106.85 129.47,105.25 128.96,104.74 v1(128.67,104.74)
  BOTTOM w0.165: v1(129.67,66.92) 129.67,66.74 130.15,66.26 130.33,66.26 130.63,66.55 130.63,66.71 130.04,67.3 JDIM1.89
M_B_A9: length 54.1
  IN2 w0.076: v5(128.09,113.03) 127.98,112.92 127.98,109.6 127.09,108.71 127.09,107.18 124.93,105.02 124.93,98.88
  IN2 w0.216: v1(125.22,71.15) 125.03,71.15 124.68,71.51 124.68,72.83 124.43,73.07 124.43,98.03 124.93,98.53 124.93,98.88
  BOTTOM w0.165: U35.AP50 v5(128.09,113.03) ; v1(125.22,71.15) 125.85,71.15 126.02,71.32 126.02,72.09 126.18,72.26 126.51,72.26 126.68,72.09 126.68,71.32 126.84,71.15 127.17,71.15 127.34,71.32 127.34,72.09 127.5,72.26 127.83,72.26 128,72.09 128,71.32 128.16,71.15 128.36,71.15 128.84,70.67 JDIM1.85
M_B_A10: length 57.5
  IN2 w0.076: v1(131.34,101.55) 131.34,101.13 132.57,99.91 132.57,98.88
  IN2 w0.216: 132.57,98.88 132.57,77.09 135.73,73.93 135.73,69.2 136.07,68.86 136.07,67.45 136.69,66.84 136.69,64.93 135.68,63.92 135.68,63.24 135.5,63.06 135.14,63.06 134.99,63.22 134.99,64.54 136.17,65.71 v1(136.17,65.91)
  BOTTOM w0.076: U35.AW46 130.93,110.08 131.12,109.89 131.23,109.69 131.23,109.19 131.46,108.96 131.46,106.78 131.36,106.68 131.36,104.75 131.13,104.52
  BOTTOM w0.102: 131.13,104.52 130.81,104.19 130.81,102.08 v1(131.34,101.55)
  BOTTOM w0.165: JDIM1.107 135.44,66.06 135.6,65.91 v1(136.17,65.91)
M_B_A11: length 58.3
  IN2 w0.076: 126.79,100.54 127.02,100.77 127.02,104.74 128.78,106.51 128.78,109.99 129.4,110.61 129.4,113.35 v2(129.02,113.73)
  IN2 w0.216: v1(127.67,61.67) 127.93,61.67 128.87,62.61 128.87,64.42 128.42,64.87 128.42,66.98 126.94,68.46 126.94,72.56 125.84,73.66 125.84,96.8 126.39,97.34 126.39,100.14 126.79,100.54
  BOTTOM w0.165: v2(129.02,113.73) U35.AN48 ; v1(127.67,61.67) 128.28,61.67 128.54,61.41 JDIM1.84
M_B_A12: length 57.3
  IN2 w0.076: 125.4,98.88 125.45,98.93 125.45,99.2 125.82,99.56 125.82,105.53 127.47,107.18 127.47,108.2 128.23,108.96 128.23,112.26 128.51,112.54 128.51,113.56 128.39,113.68 v2(128.09,113.68)
  IN2 w0.216: 125.4,98.88 125.4,98.33 124.9,97.84 124.9,73.27 126.01,72.17 126.01,67.48 126.22,67.26 126.22,66.27 126.5,65.99 126.96,65.99 v1(127.18,66.22)
  BOTTOM w0.165: v1(127.18,66.22) 127.6,66.22 127.8,66.01 127.8,65.53 127.92,65.4 128.29,65.4 128.52,65.63 128.52,65.68 129.1,66.27 129.1,66.81 128.84,67.08 128.41,67.08 128.24,67.24 JDIM1.83 ; v2(128.09,113.68) U35.AN50
M_B_A13: length 52.8
  IN2 w0.076: v1(132.91,102.85) 133.77,102 133.77,100.12 135.39,98.51 135.39,98.42
  IN2 w0.216: 135.39,98.42 135.39,97.79 135.66,97.52 135.66,77.98 139.38,74.26 139.38,72.97 139.6,72.75 139.83,72.75 140.04,72.54 140.04,72.1 139.83,71.89 139.6,71.89 139.38,71.67 139.38,71.2 139.6,70.99 139.88,70.99 140.09,70.77 140.09,70.34 139.88,70.12 139.6,70.12 139.38,69.91 139.38,69.47 139.6,69.26 140.16,69.26 140.37,69.04 140.37,68.61 140.16,68.4 139.6,68.4 139.38,68.18 139.38,67.71 139.6,67.49 140.17,67.49 140.37,67.29 140.37,66.87 140.14,66.64 v1(139.64,66.64)
  BOTTOM w0.076: U35.BA43 132.94,109.07 132.94,108.85 133.01,108.7 133.01,108.59 132.95,108.45 132.95,108.2 132.96,108.19 132.96,108.07 133.12,107.9 133.12,107.46 132.56,106.9 132.56,106.47 132.36,106.27 132.36,105.94 132.51,105.79 132.51,104.52
  BOTTOM w0.102: 132.51,104.52 132.51,103.26 v1(132.91,102.85)
  BOTTOM w0.165: JDIM1.119 139.04,67.24 139.26,67.02 139.26,66.76 139.39,66.64 v1(139.64,66.64)
M_B_A14: length 57.9
  IN2 w0.076: 124.38,98.88 124.38,99.01 124.55,99.18 124.55,105.02 126.71,107.18 126.71,109.09 127.6,109.98 127.6,113.41 127.29,113.71 v2(127.17,113.71)
  IN2 w0.216: 124.38,98.88 124.38,98.64 123.96,98.23 123.96,72.88 124.21,72.64 124.21,70.84 125.54,69.51 125.54,67.23 125.75,67.01 125.75,65.72 127.25,64.22 v1(127.66,64.22)
  BOTTOM w0.165: JDIM1.80 127.34,61.31 127.2,61.46 127.2,63.99 127.44,64.22 v1(127.66,64.22) ; v2(127.17,113.71) U35.AN52
M_B_A15: length 57
  IN2 w0.076: 123.08,98.88 123.1,98.88 123.81,99.59 123.81,102.32 123.98,102.48 123.98,105.85 125.06,106.93 125.06,110.1 125.82,110.87 125.82,113.25 v5(126.25,113.69)
  IN2 w0.216: v1(125.26,65.37) 124.3,66.33 124.3,69.41 123.24,70.47 123.24,72.27 123.02,72.49 123.02,98.82 123.08,98.88
  BOTTOM w0.165: v1(125.26,65.37) 125.47,65.37 125.82,65.02 125.82,63.6 126.74,62.68 JDIM1.78 ; v5(126.25,113.69) U35.AN53
M_B_BS#0: length 57.6
  IN2 w0.076: v1(131.34,102.2) 131.44,102.2 131.91,101.72 131.91,100.79 133.04,99.67 133.04,98.88
  IN2 w0.216: 133.04,98.88 133.04,77.28 136.23,74.09 136.23,71.45 v1(136.66,71.01)
  BOTTOM w0.076: U35.BB44 131.96,108.21 131.96,106.57 131.86,106.47 131.86,105.65 131.94,105.57 131.94,104.52
  BOTTOM w0.102: v1(131.34,102.2) 131.94,102.8 131.94,104.52
  BOTTOM w0.165: v1(136.66,71.01) 136.79,71.14 138.54,71.14 138.98,71.57 138.98,72.82 138.77,73.02 138.14,73.02 137.99,72.87 137.99,71.95 137.82,71.79 137.49,71.79 137.33,71.95 137.33,72.82 137.12,73.02 136.74,73.02 136.59,72.87 136.59,71.92 136.42,71.75 135.85,71.75 135.6,72 135.6,72.77 135.38,72.98 134.61,72.98 134.33,72.7 134.33,71.37 136.04,69.65 JDIM1.109
M_B_BS#1: length 55.7
  IN2 w0.076: 133.51,98.88 133.51,99.43 132.22,100.72 132.22,102.43 131.8,102.85 v1(131.34,102.85)
  IN2 w0.216: 133.51,98.88 133.51,77.48 137.41,73.57 137.41,73.02 136.97,72.58 136.97,71.9 137.41,71.46 137.41,70.13 136.61,69.33 136.61,68.19 137.16,67.65 137.16,65.49 137.83,64.82 137.83,63.45 137.53,63.14 136.84,63.14 136.27,63.72 v1(136.17,63.72)
  BOTTOM w0.076: U35.BA44 131.79,108.7 131.79,106.64 131.7,106.54 131.7,105.55 131.75,105.5 131.75,104.52
  BOTTOM w0.102: v1(131.34,102.85) 131.75,103.26 131.75,104.52
  BOTTOM w0.165: JDIM1.108 135.74,61.43 135.65,61.53 135.65,63.29 136.07,63.72 v1(136.17,63.72)
M_B_BS#2: length 56.7
  IN2 w0.076: v2(127.17,113.06) 126.87,113.06 126.71,112.9 126.71,110.87 126.29,110.45 126.29,107.27 124.31,105.29 124.31,99.77
  IN2 w0.216: 124.31,99.77 124.31,99.48 123.49,98.66 123.49,72.68 123.71,72.47 123.71,70.67 124.77,69.61 124.77,66.56 125.26,66.08 v1(125.26,66.08)
  BOTTOM w0.165: U35.AP52 v2(127.17,113.06) ; v1(125.26,66.08) 125.35,66.08 126.23,65.2 126.53,65.2 126.71,65.38 126.71,66.16 126.57,66.3 126.29,66.3 125.93,66.3 125.74,66.49 125.74,66.85 125.91,67.02 126.69,67.02 127.04,67.37 JDIM1.79
M_B_CAS#: length 59.3
  IN2 w0.076: 134.75,98.63 134.75,98.89 133.52,100.13 133.52,101.6 v1(132.91,102.2)
  IN2 w0.216: 134.75,98.63 134.92,98.47 134.92,97.6 135.19,97.32 135.19,77.79 138.9,74.08 138.9,66.02 v1(139.63,65.29)
  BOTTOM w0.076: U35.AY43 132.53,109.65 132.53,109.55 132.45,109.39 132.45,109.21 132.51,109.05 132.51,108.91 132.45,108.69 132.45,108.57 132.49,108.46 132.49,108.08 132.3,107.89 132.3,106.44 132.19,106.33 132.19,105.84 132.32,105.71 132.32,104.52
  BOTTOM w0.102: v1(132.91,102.2) 132.58,102.2 132.32,102.46 132.32,104.52
  BOTTOM w0.165: v1(139.63,65.29) 138.77,64.44 138.77,64.19 137.31,62.73 136.99,62.73 136.61,63.11 136.61,63.5 138.26,65.15 138.26,65.5 138.76,65.99 138.76,66.75 138.28,67.22 138.02,67.22 137.84,67.4 JDIM1.115
M_B_CKE0: length 56.8
  IN2 w0.076: 124.55,110.49 124.55,110.61 124.86,110.93 124.86,113.29 v2(124.45,113.7)
  IN2 w0.216: 124.55,110.49 124.55,108.07 122.85,106.37 122.85,100.43 122.09,99.67 122.09,72.4 122.52,71.97 122.52,70.17 123.58,69.11 123.58,66.03 124.97,64.64 v1(125.26,64.64)
  BOTTOM w0.165: JDIM1.73 125.24,67.4 124.68,66.83 124.68,65.02 125.06,64.64 v1(125.26,64.64) ; v2(124.45,113.7) U35.AN56
M_B_CKE1: length 57.1
  IN2 w0.076: 124.05,110.85 124.05,112.02 v2(124.46,112.42)
  IN2 w0.216: v1(125.26,63.21) 123.11,65.36 123.11,68.92 122.05,69.98 122.05,71.78 121.62,72.21 121.62,99.89 122.26,100.54 122.26,106.37 124.05,108.16 124.05,110.85
  BOTTOM w0.127: v2(124.46,112.42) 124.46,112.8 124.72,113.06 125.48,113.06 U35.AP55
  BOTTOM w0.165: JDIM1.74 125.54,61.43 125.71,61.6 125.71,62.76 v1(125.26,63.21)
M_B_CLK0: length 58.5
  IN2 w0.076: v2(131.77,113.73) 131.39,113.35 131.39,106.05 130.77,105.43 130.77,101.47 131.84,100.4 131.84,98.94 131.89,98.9 131.89,98.88
  IN2 w0.127: v1(134.69,65.62) 134.9,65.83 135.19,65.83 135.39,66.03 135.39,68.19 134.71,68.88 134.71,70.02 134.43,70.3 133.77,70.3 133.65,70.42 133.65,70.8 133.77,70.93 134.43,70.93 134.71,71.21 134.71,71.8 134.43,72.07 133.77,72.07 133.64,72.2 133.64,72.58 133.77,72.71 134.43,72.71 134.71,72.98 134.71,73.99 131.89,76.81 131.89,98.88
  BOTTOM w0.114: v1(134.69,65.62) 133.95,65.62 133.64,65.93 JDIM1.101 ; U35.AP45 v2(131.77,113.73)
M_B_CLK0#: length 58.4
  IN2 w0.076: v2(130.81,113.71) 131.13,113.71 131.23,113.61 131.23,106.11 130.61,105.49 130.61,101.4 131.68,100.33 131.68,98.93 131.63,98.89 131.63,98.88
  IN2 w0.127: 131.63,98.88 131.63,76.7 134.45,73.88 134.45,73.09 134.33,72.96 133.66,72.96 133.39,72.69 133.39,72.1 133.66,71.82 134.33,71.82 134.45,71.69 134.45,71.31 134.33,71.18 133.67,71.18 133.39,70.91 133.39,70.32 133.67,70.04 134.33,70.04 134.45,69.91 134.45,68.77 135.14,68.09 135.14,66.14 135.09,66.08 134.99,66.08 134.94,66.14 v1(134.69,66.38)
  BOTTOM w0.114: JDIM1.103 134.24,67.27 134.15,67.18 133.97,67.18 133.89,67.09 133.89,66.03 134.05,65.86 134.3,65.86 134.69,66.26 v1(134.69,66.38) ; v2(130.81,113.71) U35.AN45
M_B_CLK1: length 57.7
  IN2 w0.076: v5(129.92,113.06) 130.13,113.28 130.24,113.28 130.33,113.19 130.33,112.84 130.3,112.81 130.3,110.88 129.83,110.41 129.83,101.41 130.87,100.37 130.87,98.94 130.83,98.9 130.83,98.88
  IN2 w0.127: 130.83,98.88 130.83,76.39 132.37,74.85 132.37,69.74 133.97,68.14 133.97,64.68 133.53,64.24 133.53,63.28 v1(134.22,62.59)
  BOTTOM w0.114: v1(134.22,62.59) 134.44,62.8 134.55,62.8 134.75,62.61 134.75,61.87 134.29,61.4 134.04,61.4 133.94,61.3 JDIM1.102 ; v5(129.92,113.06) U35.AP46
M_B_CLK1#: length 57.6
  IN2 w0.076: v2(129.92,113.71) 129.92,113.57 130.04,113.44 130.31,113.44 130.49,113.25 130.49,112.77 130.46,112.74 130.46,110.81 130,110.35 130,101.48 131.04,100.44 131.04,98.93 131.08,98.89 131.08,98.88
  IN2 w0.127: 131.08,98.88 131.08,76.5 132.63,74.96 132.63,69.85 134.22,68.25 134.22,64.57 133.78,64.13 133.78,63.39 133.91,63.26 134.18,63.26 v1(134.22,63.3)
  BOTTOM w0.114: v2(129.92,113.71) U35.AN46 ; JDIM1.104 134.54,61.32 134.99,61.77 134.99,62.71 134.65,63.04 134.4,63.04 134.22,63.22 v1(134.22,63.3)
M_B_CS#0: length 56.2
  IN2 w0.076: v1(132.91,105.45) 133.27,105.45 134.63,104.09 134.63,100.4 135.22,99.82 135.47,99.82 136.61,98.67
  IN2 w0.216: v1(140.03,63.59) 140.3,63.59 140.64,63.24 141.28,63.24 141.57,63.53 141.57,69.65 142,70.08 142,74 141.03,74.97 137.55,78.44 137.55,97.88 136.76,98.67 136.61,98.67
  BOTTOM w0.076: v1(132.91,105.45) 133.14,105.68 133.14,106.79 133.29,106.94 133.29,107.16 133.49,107.36 133.49,108.21 U35.BB42
  BOTTOM w0.165: v1(140.03,63.59) 139.12,63.59 137.54,62.01 JDIM1.114
M_B_CS#1: length 59.3
  IN2 w0.076: 136.16,98.12 134.05,100.22 134.05,102.38 132.93,103.5 v5(132.92,103.5)
  IN2 w0.216: 136.16,98.12 136.18,98.09 136.18,98.04 136.39,97.83 136.39,78.28 140.8,73.86 v1(140.8,72.26)
  BOTTOM w0.076: v5(132.92,103.5) 133.31,103.88 133.31,103.88 133.47,104.04 133.47,106.66 133.62,106.8 133.62,107.02 133.82,107.23 133.82,108.46 133.8,108.49 133.65,108.86 133.65,109.35 U35.AY42
  BOTTOM w0.165: v1(140.8,72.26) 142.2,72.26 142.58,71.88 142.58,69.97 142.71,69.85 143.47,69.85 143.73,70.1 143.73,70.99 144.23,71.5 144.74,71.5 145.1,71.85 145.1,72.42 144.63,72.89 140.17,72.89 139.98,72.7 139.98,71.81 139.64,71.48 JDIM1.121
M_B_DQ0: length 75.9
  IN2 w0.127: v1(107.45,66.26) 107.27,66.26 103.62,69.91 103.62,71.39 104.49,72.26 104.49,87.11 104.36,87.24 103.72,87.24 103.59,87.37 103.59,87.62 103.72,87.75 104.36,87.75 104.49,87.88 104.49,88.13 104.36,88.26 103.72,88.26 103.59,88.38 103.59,88.64 103.72,88.77 104.36,88.77 104.49,88.89 104.49,89.15 104.36,89.27 103.72,89.27 103.59,89.4 103.59,89.65 103.72,89.78 104.36,89.78 104.49,89.91 104.49,90.16 104.36,90.29 103.72,90.29 103.59,90.42 103.59,94.61 102.13,96.07 102.13,106.44 107.8,112.1 107.8,113.36 109.61,115.17 111.52,115.17 111.76,115.41 115.03,115.41 115.4,115.78 115.4,116.35 116.93,117.88 117.5,117.88 118.36,118.73 119.61,118.73 v1(120.41,117.94)
  BOTTOM w0.114: JDIM1.23 107.84,67.17 107.92,67.09 107.92,66.54 107.64,66.26 v1(107.45,66.26) ; v1(120.41,117.94) U35.AF65
M_B_DQ1: length 75.2
  IN2 w0.127: v1(121.06,117.94) 119.91,119.08 118.2,119.08 117.34,118.23 116.82,118.23 115,116.41 110.27,116.41 107.47,113.61 107.47,112.24 101.8,106.57 101.8,95.89 103.26,94.43 103.26,69.8 107.01,66.06 107.01,64.47 107.51,63.96 v1(107.51,63.21)
  BOTTOM w0.114: v1(121.06,117.94) U35.AF64 ; v1(107.51,63.21) 108.14,62.58 JDIM1.24
M_B_DQ2: length 74.7
  IN2 w0.127: v1(111.45,61.84) 111.45,60.56 111.21,60.32 109.42,60.32 109.29,60.45 109.29,62.94 110.55,64.2 110.55,66.4 107.39,69.56 107.39,95.79 104.33,98.85 104.33,105.56 109.97,111.2 109.97,112.46 110.48,112.96 115.4,112.96 117.46,115.03 117.76,115.03 118.58,115.85 119.6,115.85 v2(119.85,116.1)
  BOTTOM w0.114: v1(111.45,61.84) 111.4,61.84 111.14,61.59 JDIM1.34 ; U35.AK65 v2(119.85,116.1)
M_B_DQ3: length 76.1
  IN2 w0.127: v1(111.32,65.11) 111.77,65.56 111.77,66.65 109.31,69.11 109.31,70.9 109.18,71.03 109.11,71.03 108.98,71.16 108.98,71.41 109.11,71.54 109.18,71.54 109.31,71.67 109.31,71.92 109.18,72.05 109.11,72.05 108.98,72.17 108.98,72.43 109.11,72.55 109.18,72.55 109.31,72.68 109.31,72.94 109.18,73.06 109.11,73.06 108.98,73.19 108.98,73.44 109.11,73.57 109.18,73.57 109.31,73.7 109.31,73.95 109.18,74.08 109.11,74.08 108.98,74.21 108.98,74.46 109.11,74.59 109.18,74.59 109.31,74.71 109.31,74.97 109.18,75.09 109.11,75.09 108.98,75.22 108.98,75.48 109.11,75.6 109.18,75.6 109.31,75.73 109.31,75.98 109.18,76.11 109.11,76.11 108.98,76.24 108.98,76.49 109.11,76.62 109.18,76.62 109.31,76.75 109.31,77 109.18,77.13 109.11,77.13 108.98,77.25 108.98,77.51 109.11,77.63 109.18,77.63 109.31,77.76 109.31,78.02 109.18,78.14 109.11,78.14 108.98,78.27 108.98,78.52 109.11,78.65 109.18,78.65 109.31,78.78 109.31,79.03 109.18,79.16 109.11,79.16 108.98,79.29 108.98,79.54 109.11,79.67 109.18,79.67 109.31,79.79 109.31,80.05 109.18,80.17 109.11,80.17 108.98,80.3 108.98,80.56 109.11,80.68 109.18,80.68 109.31,80.81 109.31,81.06 109.18,81.19 109.11,81.19 108.98,81.32 108.98,81.57 109.11,81.7 109.18,81.7 109.31,81.83 109.31,82.08 109.18,82.21 109.11,82.21 108.98,82.33 108.98,82.59 109.11,82.71 109.18,82.71 109.31,82.84 109.31,83.1 109.18,83.22 109.11,83.22 108.98,83.35 108.98,83.6 109.11,83.73 109.18,83.73 109.31,83.86 109.31,84.11 109.18,84.24 109.11,84.24 108.98,84.37 108.98,84.62 109.11,84.75 109.18,84.75 109.31,84.87 109.31,85.13 109.18,85.25 109.11,85.25 108.98,85.38 108.98,85.64 109.11,85.76 109.18,85.76 109.31,85.89 109.31,86.14 109.18,86.27 109.11,86.27 108.98,86.4 108.98,86.65 109.11,86.78 109.18,86.78 109.31,86.91 109.31,87.16 109.18,87.29 109.11,87.29 108.98,87.41 108.98,87.67 109.11,87.79 109.18,87.79 109.31,87.92 109.31,88.18 109.18,88.3 109.11,88.3 108.98,88.43 108.98,88.68 109.11,88.81 109.18,88.81 109.31,88.94 109.31,89.19 109.18,89.32 109.11,89.32 108.98,89.45 108.98,89.7 109.11,89.83 109.18,89.83 109.31,89.95 109.31,90.21 109.18,90.33 109.11,90.33 108.98,90.46 108.98,90.72 109.11,90.84 109.18,90.84 109.31,90.97 109.31,91.22 109.18,91.35 109.11,91.35 108.98,91.48 108.98,91.73 109.11,91.86 109.18,91.86 109.31,91.99 109.31,92.24 109.18,92.37 109.11,92.37 108.98,92.49 108.98,92.75 109.11,92.87 109.18,92.87 109.31,93 109.31,93.26 109.18,93.38 109.11,93.38 108.98,93.51 108.98,93.76 109.11,93.89 109.18,93.89 109.31,94.02 109.31,94.27 109.18,94.4 109.11,94.4 108.98,94.53 108.98,94.78 109.11,94.91 109.18,94.91 109.31,95.03 109.31,95.36 105.32,99.35 105.32,105.15 111.55,111.37 115.58,111.37 116.42,112.21 116.42,112.94 117.6,114.13 118.09,114.13 118.71,114.75 120.64,114.75 121.06,115.17 v2(121.06,115.27)
  BOTTOM w0.114: JDIM1.33 110.84,65.64 111.32,65.16 v1(111.32,65.11) ; U35.AK64 v2(121.06,115.27)
M_B_DQ4: length 75.8
  IN2 w0.127: v1(119.76,117.94) 119.31,118.39 118.48,118.39 117.61,117.52 117.05,117.52 115.76,116.24 115.76,115.67 115.17,115.08 111.79,115.08 111.56,114.84 109.75,114.84 108.13,113.22 108.13,111.96 102.46,106.3 102.46,96.29 104.69,94.06 104.69,93.68 104.56,93.56 104.48,93.56 104.36,93.43 104.36,93.18 104.48,93.05 104.56,93.05 104.69,92.92 104.69,92.67 104.56,92.54 104.1,92.54 103.97,92.41 103.97,92.16 104.1,92.03 104.56,92.03 104.69,91.91 104.69,91.65 104.56,91.52 104.1,91.52 103.97,91.4 103.97,91.14 104.1,91.02 104.64,91.02 104.82,90.84 104.82,69.52 108.09,66.24 108.09,64.53 107.97,64.4 107.58,64.4 107.45,64.53 v1(107.45,64.96)
  BOTTOM w0.114: JDIM1.21 107.24,67.26 107.02,67.03 107.02,65.41 107.45,64.99 v1(107.45,64.96) ; v1(119.76,117.94) U35.AF66
M_B_DQ5: length 74.9
  IN2 w0.127: v1(119.11,117.94) 118.5,117.94 117.75,117.19 117.18,117.19 116.17,116.18 116.17,115.6 115.31,114.75 111.93,114.75 111.7,114.51 109.89,114.51 108.46,113.08 108.46,111.83 102.79,106.16 102.79,96.43 105.37,93.85 105.37,69.43 108.42,66.38 108.42,60.42 108.17,60.16 107.77,60.16 107.51,60.41 v1(107.51,61.79)
  BOTTOM w0.114: v1(107.51,61.79) 107.54,61.75 JDIM1.22 ; v1(119.11,117.94) U35.AF67
M_B_DQ6: length 73.4
  IN2 w0.127: v1(111.32,66.41) 111.32,66.63 108.65,69.3 108.65,69.9 108.52,70.03 108.31,70.03 108.18,70.15 108.18,70.41 108.31,70.53 108.52,70.53 108.65,70.66 108.65,70.92 108.52,71.04 108.31,71.04 108.18,71.17 108.18,71.42 108.31,71.55 108.52,71.55 108.65,71.68 108.65,71.93 108.52,72.06 108.44,72.06 108.29,72.21 108.29,72.42 108.44,72.57 108.52,72.57 108.65,72.69 108.65,72.95 108.52,73.07 108.44,73.07 108.29,73.22 108.29,73.43 108.44,73.58 108.52,73.58 108.65,73.71 108.65,73.96 108.52,74.09 108.44,74.09 108.29,74.24 108.29,74.45 108.44,74.6 108.52,74.6 108.65,74.73 108.65,75.16 108.52,75.29 108.45,75.29 108.32,75.41 108.32,75.67 108.45,75.8 108.52,75.8 108.65,75.92 108.65,76.18 108.52,76.3 108.45,76.3 108.32,76.43 108.32,76.68 108.45,76.81 108.52,76.81 108.65,76.94 108.65,77.19 108.52,77.32 108.45,77.32 108.32,77.45 108.32,77.7 108.45,77.83 108.52,77.83 108.65,77.95 108.65,78.21 108.52,78.34 108.45,78.34 108.32,78.46 108.32,78.72 108.45,78.84 108.52,78.84 108.65,78.97 108.65,79.22 108.52,79.35 108.45,79.35 108.32,79.48 108.32,79.73 108.45,79.86 108.52,79.86 108.65,79.99 108.65,80.24 108.52,80.37 108.45,80.37 108.32,80.49 108.32,80.75 108.45,80.88 108.52,80.88 108.65,81 108.65,81.26 108.52,81.38 108.45,81.38 108.32,81.51 108.32,81.76 108.45,81.89 108.52,81.89 108.65,82.02 108.65,82.27 108.52,82.4 108.45,82.4 108.32,82.53 108.32,82.78 108.45,82.91 108.52,82.91 108.65,83.03 108.65,83.29 108.52,83.42 108.45,83.42 108.32,83.54 108.32,83.8 108.45,83.92 108.52,83.92 108.65,84.05 108.65,84.3 108.52,84.43 108.45,84.43 108.32,84.56 108.32,84.81 108.45,84.94 108.52,84.94 108.65,85.07 108.65,85.32 108.52,85.45 108.45,85.45 108.32,85.57 108.32,85.83 108.45,85.96 108.52,85.96 108.65,86.08 108.65,86.34 108.52,86.46 108.45,86.46 108.32,86.59 108.32,86.84 108.45,86.97 108.52,86.97 108.65,87.1 108.65,87.35 108.52,87.48 108.45,87.48 108.32,87.61 108.32,87.86 108.45,87.99 108.52,87.99 108.65,88.11 108.65,88.37 108.52,88.5 108.45,88.5 108.32,88.62 108.32,88.88 108.45,89 108.52,89 108.65,89.13 108.65,89.38 108.52,89.51 108.45,89.51 108.32,89.64 108.32,89.89 108.45,90.02 108.52,90.02 108.65,90.15 108.65,90.4 108.52,90.53 108.45,90.53 108.32,90.65 108.32,90.91 108.45,91.04 108.52,91.04 108.65,91.16 108.65,91.42 108.52,91.54 108.45,91.54 108.32,91.67 108.32,91.92 108.45,92.05 108.52,92.05 108.65,92.18 108.65,92.43 108.52,92.56 108.45,92.56 108.32,92.69 108.32,92.94 108.45,93.07 108.52,93.07 108.65,93.19 108.65,93.45 108.52,93.58 108.45,93.58 108.32,93.7 108.32,93.96 108.45,94.08 108.52,94.08 108.65,94.21 108.65,94.46 108.52,94.59 108.45,94.59 108.32,94.72 108.32,94.97 108.45,95.1 108.52,95.1 108.65,95.23 108.65,95.56 104.99,99.21 104.99,105.29 111.41,111.71 115.56,111.71 116.04,112.18 116.04,112.89 117.57,114.42 117.96,114.42 118.71,115.17 v2(119.06,115.17)
  BOTTOM w0.114: v2(119.06,115.17) 119.03,115.17 U35.AK67 ; JDIM1.35 111.44,67.32 111.57,67.2 111.8,67.2 112,66.99 112,66.53 111.81,66.33 111.4,66.33 v1(111.32,66.41)
M_B_DQ7: length 74.1
  IN2 w0.127: v1(111.45,63.21) 110.82,62.57 110.82,61.8 110.58,61.56 109.9,61.56 109.62,61.84 109.62,62.78 110.88,64.03 110.88,66.6 107.72,69.76 107.72,74.86 107.99,75.13 107.99,95.75 104.66,99.08 104.66,105.42 110.3,111.06 110.3,112.32 110.61,112.63 115.4,112.63 117.51,114.74 117.86,114.74 118.71,115.59 119.31,115.59 119.73,115.17 v2(119.76,115.17)
  BOTTOM w0.114: JDIM1.36 111.74,61.43 111.98,61.66 111.98,62.68 v1(111.45,63.21) ; U35.AK66 v2(119.76,115.17)
M_B_DQ8: length 76.8
  IN2 w0.127: v1(115.29,118.78) 115.29,119.09 113.88,120.49 108.71,120.49 103.96,115.75 103.96,113.65 98.13,107.82 98.13,69.08 101.75,65.46 101.75,64.22 101.87,64.1 102.3,64.1 102.41,64.22 v1(102.41,64.96)
  BOTTOM w0.076: v1(115.29,118.78) 115.39,118.78 115.98,118.19 116.43,118.19 U35.AF70
  BOTTOM w0.114: JDIM1.7 103.04,65.6 v1(102.41,64.96)
M_B_DQ9: length 78.7
  IN2 w0.127: v1(116.59,118.79) 116.59,118.83 114.26,121.15 108.43,121.15 103.3,116.02 103.3,113.93 97.47,108.1 97.47,68.35 101.08,64.74 101.08,62.96 v1(102.38,61.66)
  BOTTOM w0.076: U35.AF68 117.82,118 117.38,118 v1(116.59,118.79)
  BOTTOM w0.114: JDIM1.4 102.14,61.42 v1(102.38,61.66)
M_B_DQ10: length 77.2
  IN2 w0.127: v1(105.38,65.69) 105.38,65.77 101.77,69.39 101.77,74.09 101.41,74.44 101.41,92.04 101.28,92.17 100.58,92.17 100.46,92.3 100.46,92.55 100.58,92.68 101.28,92.68 101.41,92.81 101.41,93.14 100.51,94.04 100.51,107.11 106.17,112.77 106.17,114.42 109.6,117.85 112.96,117.85 v1(113.43,117.37)
  BOTTOM w0.076: v1(113.43,117.37) 114.05,116.76 114.74,116.76 114.85,116.65 115.41,116.65 115.59,116.46 U35.AH71
  BOTTOM w0.114: JDIM1.17 106.04,67.34 106.39,67 106.39,66.44 106.24,66.29 106.24,66.04 106.39,65.9 106.39,65.15 107.39,64.15 107.39,63.84 107.06,63.52 105.86,63.52 105.74,63.65 105.74,63.86 105.86,63.99 106.37,63.99 106.5,64.11 106.5,64.37 106.37,64.49 106.02,64.49 105.88,64.64 105.88,65.27 105.46,65.69 v1(105.38,65.69)

# Allegro board Quanta ZRW REV F - BoardView (.BRD).brd (continued)
## Footprints (pads in the part's own frame, mm; a bottom-side part is the same pattern mirrored in y, then rotated) (continued)
BGA1356-INTEL-SKYLAKE-U
  round 0.356 smd: A3(-11.314,-19.349) A70(-11.314,19.852) B2(-10.832,-19.832) B71(-10.852,20.314) BA1(10.852,-20.314) BA71(10.852,20.314) BB2(11.314,-19.852) BB70(11.314,19.852) C1(-10.349,-20.314)
  round 0.33 smd: A4(-11.314,-18.699) A69(-11.314,19.202) AY1(10.202,-20.314) AY71(10.202,20.314) B3(-10.679,-19.197) B70(-10.685,19.685) BA2(10.685,-19.685) BA70(10.685,19.685) BB3(11.314,-19.202) BB69(11.314,19.202) C2(-10.197,-19.679) C71(-10.202,20.314) D1(-9.699,-20.314)
  round 0.305 smd: A5(-11.314,-18.048) A68(-11.314,18.552) AA2(-0.511,-19.339) AA4(-0.511,-18.363) AA63(-0.596,15.112) AA64(-0.596,15.763) AA65(-0.596,16.413) AA66(-0.596,17.063) AA67(-0.596,17.713) AA68(-0.596,18.364) AA69(-0.596,19.014) AA70(-0.596,19.664) AA71(-0.596,20.314) AB4(0.152,-18.363) AB6(-0.133,-17.585) AB7(-0.133,-16.935) AB8(-0.133,-16.285) AB9(-0.133,-15.635) AB10(-0.133,-14.984) AB11(-0.133,-14.334) AB12(-0.133,-13.684) AB13(-0.133,-13.034) AB15(-0.009,-12.188) AB16(-0.009,-11.538) AB17(-0.009,-10.888) AB18(-0.009,-10.237) AB19(-0.009,-9.587) AB20(-0.009,-8.937) AB21(-0.009,-8.287) AB62(-0.138,14.644) AC3(0.815,-18.689) AC63(0.319,15.112) AC64(0.319,15.763) AC65(0.319,16.413) AC66(0.319,17.063) AC67(0.319,17.713) AC68(0.319,18.364) AC69(0.319,19.014) AC70(0.319,19.664) AC71(0.319,20.314) AD4(1.478,-18.363) AD6(0.934,-17.585) AD7(0.934,-16.935) AD8(0.934,-16.285) AD9(0.934,-15.635) AD10(0.934,-14.984) AD11(0.934,-14.334) AD12(0.934,-13.684) AD13(0.934,-13.034) AD15(0.829,-12.188) AD16(0.829,-11.538) AD17(0.829,-10.888) AD18(0.829,-10.237) AD19(0.829,-9.587) AD20(0.829,-8.937) AD21(0.829,-8.287) AD62(0.776,14.644) AE62(1.69,14.644) AE63(1.233,15.112) AE64(1.233,15.763) AE65(1.233,16.413) AE66(1.233,17.063) AE67(1.233,17.713) AE68(1.233,18.364) AE69(1.233,19.014) AF2(2.141,-19.339) AF4(2.141,-18.363) AF6(2.001,-17.585) AF7(2.001,-16.935) AF8(2.001,-16.285) AF9(2.001,-15.635) AF10(2.001,-14.984) AF11(2.001,-14.334) AF12(2.001,-13.684) AF13(2.001,-13.034) AF15(1.668,-12.188) AF16(1.668,-11.538) AF17(1.668,-10.888) AF18(1.668,-10.237) AF19(1.668,-9.587) AF20(1.668,-8.937) AF21(1.668,-8.287) AF63(2.148,15.112) AF64(2.148,15.763) AF65(2.148,16.413) AF66(2.148,17.063) AF67(2.148,17.713) AF68(1.939,18.364) AF69(1.939,19.014) AG4(2.804,-18.363) AG15(2.506,-12.188) AG16(2.506,-11.538) AG17(2.506,-10.888) AG18(2.506,-10.237) AG19(2.506,-9.587) AG20(2.506,-8.937) AG21(2.506,-8.287) AG62(2.605,14.644) AG69(2.602,18.689) AH3(3.467,-18.689) AH6(3.067,-17.585) AH7(3.067,-16.935) AH8(3.067,-16.285) AH9(3.067,-15.635) AH10(3.067,-14.984) AH11(3.067,-14.334) AH12(3.067,-13.684) AH13(3.067,-13.034) AH63(3.062,15.112) AH64(3.062,15.763) AH65(3.062,16.413) AH66(3.062,17.063) AH67(3.062,17.713) AJ4(4.13,-18.363) AJ15(3.344,-12.188) AJ16(3.344,-11.538) AJ17(3.344,-10.888) AJ18(3.344,-10.237) AJ19(3.344,-9.587) AJ20(3.344,-8.937) AJ21(3.344,-8.287) AJ62(3.519,14.644) AK6(4.007,-17.585) AK7(4.007,-16.935) AK8(4.007,-16.285) AK9(4.007,-15.635) AK10(4.007,-14.984) AK11(4.007,-14.334) AK12(4.007,-13.684) AK13(4.007,-13.034) AK15(4.182,-12.188) AK16(4.182,-11.538) AK17(4.182,-10.888) AK18(4.182,-10.237) AK19(4.182,-9.587) AK20(4.182,-8.937) AK21(4.182,-8.287) AK22(4.009,-7.596) AK23(4.009,-6.681) AK25(4.009,-5.767) AK27(4.009,-4.852) AK28(4.009,-3.938) AK30(4.009,-3.024) AK32(4.009,-2.109) AK33(4.009,-1.195) AK35(4.009,-0.28) AK37(4.009,0.634) AK38(4.009,1.548) AK40(4.009,2.463) AK42(4.009,3.377) AK43(4.009,4.292) AK45(4.009,5.206) AK46(4.009,6.12) AK48(4.009,7.035) AK50(4.009,7.949) AK52(4.009,8.864) AK53(4.009,9.778) AK55(4.009,10.692) AK56(4.009,11.607) AK58(4.009,12.521) AK60(4.009,13.436) AK62(4.144,14.46) AK63(3.976,15.112) AK64(3.976,15.763) AK65(3.976,16.413) AK66(3.976,17.063) AK67(3.976,17.713) AK68(3.829,18.364) AK69(3.829,19.339) AL2(4.793,-19.339) AL4(4.793,-18.363) AL23(4.474,-7.138) AL25(4.474,-6.224) AL27(4.474,-5.31) AL28(4.474,-4.395) AL30(4.474,-3.481) AL32(4.474,-2.566) AL33(4.474,-1.652) AL35(4.474,-0.738) AL37(4.474,0.177) AL38(4.474,1.091) AL40(4.474,2.006) AL42(4.474,2.92) AL43(4.474,3.834) AL45(4.474,4.749) AL46(4.474,5.663) AL48(4.474,6.578) AL50(4.474,7.492) AL52(4.474,8.406) AL53(4.474,9.321) AL55(4.474,10.235) AL56(4.474,11.15) AL58(4.474,12.064) AL60(4.474,12.978) AL61(4.474,13.893) AL63(4.845,15.112) AL64(4.845,15.763) AL65(4.845,16.413) AL66(4.845,17.063) AM4(5.456,-18.363) AM5(4.946,-17.654) AM7(4.946,-16.74) AM8(4.946,-15.825) AM10(4.946,-14.911) AM11(4.946,-13.996) AM13(4.946,-13.082) AM15(4.946,-12.168) AM16(4.946,-11.253) AM18(4.946,-10.339) AM20(4.946,-9.424) AM21(4.946,-8.51) AM22(4.946,-7.596) AM23(4.946,-6.681) AM25(4.946,-5.767) AM27(4.946,-4.852) AM28(4.946,-3.938) AM30(4.946,-3.024) AM32(4.946,-2.109) AM33(4.946,-1.195) AM35(4.946,-0.28) AM37(4.946,0.634) AM38(4.946,1.548) AM40(4.946,2.463) AM42(4.946,3.377) AM43(4.946,4.292) AM45(4.946,5.206) AM46(4.946,6.12) AM48(4.946,7.035) AM50(4.946,7.949) AM52(4.946,8.864) AM53(4.946,9.778) AM55(4.946,10.692) AM56(4.946,11.607) AM58(4.946,12.521) AM60(4.946,13.436) AM61(4.946,14.35) AM68(5.056,18.039) AM69(5.056,18.689) AN3(6.119,-18.689) AN5(5.597,-17.654) AN7(5.597,-16.74) AN8(5.597,-15.825) AN10(5.597,-14.911) AN11(5.597,-13.996) AN13(5.597,-13.082) AN15(5.597,-12.168) AN16(5.597,-11.253) AN18(5.597,-10.339) AN20(5.597,-9.424) AN21(5.597,-8.51) AN22(5.597,-7.596) AN23(5.597,-6.681) AN25(5.597,-5.767) AN27(5.597,-4.852) AN28(5.597,-3.938) AN30(5.597,-3.024) AN32(5.597,-2.109) AN33(5.597,-1.195) AN35(5.597,-0.28) AN37(5.597,0.634) AN38(5.597,1.548) AN40(5.597,2.463) AN42(5.597,3.377) AN43(5.597,4.292) AN45(5.597,5.206) AN46(5.597,6.12) AN48(5.597,7.035) AN50(5.597,7.949) AN52(5.597,8.864) AN53(5.597,9.778) AN55(5.597,10.692) AN56(5.597,11.607) AN58(5.597,12.521) AN60(5.597,13.436) AN61(5.597,14.35) AN63(5.597,15.264) AN65(5.597,16.179) AN66(5.597,17.093) AN68(5.719,18.364) AN69(5.719,19.014) AP4(6.782,-18.363) AP5(6.247,-17.654) AP7(6.247,-16.74) AP8(6.247,-15.825) AP10(6.247,-14.911) AP11(6.247,-13.996) AP13(6.247,-13.082) AP15(6.247,-12.168) AP16(6.247,-11.253) AP18(6.247,-10.339) AP20(6.247,-9.424) AP21(6.247,-8.51) AP22(6.247,-7.596) AP23(6.247,-6.681) AP25(6.247,-5.767) AP27(6.247,-4.852) AP28(6.247,-3.938) AP30(6.247,-3.024) AP32(6.247,-2.109) AP33(6.247,-1.195) AP35(6.247,-0.28) AP37(6.247,0.634) AP38(6.247,1.548) AP40(6.247,2.463) AP42(6.247,3.377) AP43(6.247,4.292) AP45(6.247,5.206) AP46(6.247,6.12) AP48(6.247,7.035) AP50(6.247,7.949) AP52(6.247,8.864) AP53(6.247,9.778) AP55(6.247,10.692) AP56(6.247,11.607) AP58(6.247,12.521) AP60(6.247,13.436) AP61(6.247,14.35) AP63(6.247,15.264) AP65(6.247,16.179) AP66(6.247,17.093) AP68(6.332,18.039) AP70(6.332,19.258) AR5(6.897,-17.654) AR7(6.897,-16.74) AR8(6.897,-15.825) AR10(6.897,-14.911) AR11(6.897,-13.996) AR13(6.897,-13.082) AR15(6.897,-12.168) AR16(6.897,-11.253) AR18(6.897,-10.339) AR20(6.897,-9.424) AR21(6.897,-8.51) AR22(6.897,-7.596) AR23(6.897,-6.681) AR25(6.897,-5.767) AR27(6.897,-4.852) AR28(6.897,-3.938) AR30(6.897,-3.024) AR32(6.897,-2.109) AR33(6.897,-1.195) AR35(6.897,-0.28) AR37(6.897,0.634) AR38(6.897,1.548) AR40(6.897,2.463) AR42(6.897,3.377) AR43(6.897,4.292) AR45(6.897,5.206) AR46(6.897,6.12) AR48(6.897,7.035) AR50(6.897,7.949) AR52(6.897,8.864) AR53(6.897,9.778) AR55(6.897,10.692) AR56(6.897,11.607) AR58(6.897,12.521) AR60(6.897,13.436) AR61(6.897,14.35) AR63(6.897,15.264) AR65(6.897,16.179) AR66(6.897,17.093) AR68(6.945,18.364) AR69(6.945,19.014) AT2(7.445,-19.339) AT4(7.445,-18.363) AT5(7.547,-17.654) AT7(7.547,-16.74) AT8(7.547,-15.825) AT10(7.547,-14.911) AT11(7.547,-13.996) AT13(7.547,-13.082) AT15(7.547,-12.168) AT16(7.547,-11.253) AT18(7.547,-10.339) AT20(7.547,-9.424) AT21(7.547,-8.51) AT22(7.547,-7.596) AT23(7.547,-6.681) AT25(7.547,-5.767) AT27(7.547,-4.852) AT28(7.547,-3.938) AT30(7.547,-3.024) AT32(7.547,-2.109) AT33(7.547,-1.195) AT35(7.547,-0.28) AT37(7.547,0.634) AT38(7.547,1.548) AT40(7.547,2.463) AT42(7.547,3.377) AT43(7.547,4.292) AT45(7.547,5.206) AT46(7.547,6.12) AT48(7.547,7.035) AT50(7.547,7.949) AT52(7.547,8.864) AT53(7.547,9.778) AT55(7.547,10.692) AT56(7.547,11.607) AT58(7.547,12.521) AT60(7.547,13.436) AT61(7.547,14.35) AT63(7.547,15.264) AT65(7.547,16.179) AT66(7.547,17.093) AT68(7.509,18.039) AT69(7.509,18.689) AU4(8.108,-18.363) AU5(8.198,-17.654) AU7(8.198,-16.74) AU8(8.198,-15.825) AU10(8.198,-14.911) AU11(8.198,-13.996) AU13(8.198,-13.082) AU15(8.198,-12.168) AU16(8.198,-11.253) AU18(8.198,-10.339) AU20(8.198,-9.424) AU21(8.198,-8.51) AU22(8.198,-7.596) AU23(8.198,-6.681) AU25(8.198,-5.767) AU27(8.198,-4.852) AU28(8.198,-3.938) AU30(8.198,-3.024) AU32(8.198,-2.109) AU33(8.198,-1.195) AU35(8.198,-0.28) AU37(8.198,0.634) AU38(8.198,1.548) AU40(8.198,2.463) AU42(8.198,3.377) AU43(8.198,4.292) AU45(8.198,5.206) AU46(8.198,6.12) AU48(8.198,7.035) AU50(8.198,7.949) AU52(8.198,8.864) AU53(8.198,9.778) AU55(8.198,10.692) AU56(8.198,11.607) AU58(8.198,12.521) AU60(8.198,13.436) AU61(8.198,14.35) AU63(8.198,15.264) AU65(8.198,16.179) AU66(8.198,17.093) AV3(8.799,-18.689) AV68(8.711,18.029) AV69(8.901,19.014) AV70(8.901,19.664) AW1(9.551,-20.314) AW5(8.911,-17.781) AW6(9.038,-17.13) AW7(9.363,-16.564) AW8(9.038,-15.986) AW9(9.363,-15.416) AW10(9.038,-14.753) AW11(9.363,-14.143) AW12(9.038,-13.565) AW13(9.363,-12.995) AW14(9.038,-12.332) AW15(9.363,-11.723) AW16(9.038,-11.145) AW17(9.363,-10.575) AW18(9.038,-9.912) AW20(9.363,-9.302) AW21(9.038,-8.724) AW22(9.363,-8.154) AW23(9.038,-7.466) AW25(9.363,-6.828) AW26(9.038,-6.264) AW27(9.363,-5.601) AW28(9.038,-4.988) AW29(9.363,-4.374) AW30(9.038,-3.711) AW31(9.363,-3.148) AW32(9.038,-2.485) AW33(9.363,-1.847) AW34(9.038,-1.283) AW35(9.363,-0.62) AW36(9.038,-0.007) AW37(9.363,0.607) AW38(9.038,1.269) AW39(9.363,1.833) AW41(9.038,2.471) AW42(9.363,3.108) AW43(9.038,3.672) AW44(9.363,4.335) AW45(9.038,4.949) AW46(9.363,5.562) AW47(9.038,6.163) AW48(9.363,6.727) AW49(9.038,7.355) AW50(9.363,7.984) AW51(9.038,8.548) AW52(9.363,9.149) AW53(9.038,9.762) AW54(9.363,10.375) AW55(9.038,11.038) AW56(9.363,11.602) AW57(9.038,12.24) AW59(9.363,12.877) AW60(9.038,13.441) AW61(9.363,14.104) AW62(9.038,14.718) AW63(9.363,15.331) AW64(9.038,15.994) AW65(9.363,16.558) AW66(8.9,17.093) AW67(9.371,18.018) AW68(9.622,18.622) AW69(9.536,19.267) AW70(10.035,19.685) AW71(9.551,20.314) AY2(10.034,-19.685) AY3(10.028,-19.028) AY4(10.043,-18.274) AY5(9.689,-17.665) AY8(9.689,-15.986) AY12(9.689,-13.565) AY16(9.689,-11.145) AY21(9.689,-8.724) AY26(9.689,-6.264) AY27(10.014,-5.601) AY29(10.014,-4.374) AY30(9.689,-3.711) AY34(9.689,-1.283) AY35(10.014,-0.62) AY37(10.014,0.607) AY38(9.689,1.269) AY43(9.689,3.672) AY44(10.014,4.335) AY46(10.014,5.562) AY47(9.689,6.163) AY51(9.689,8.548) AY52(10.014,9.149) AY54(10.014,10.375) AY55(9.689,11.038) AY60(9.689,13.441) AY61(10.014,14.104) AY63(10.014,15.331) AY64(9.689,15.994) AY66(9.689,17.221) AY68(10.267,18.535) B5(-10.664,-18.048) B6(-10.339,-17.467) B10(-10.339,-14.989) B14(-10.339,-12.511) B18(-10.339,-10.033) B22(-10.339,-7.555) B26(-10.339,-5.077) B30(-10.339,-2.599) B34(-10.339,-0.121) B39(-10.339,2.357) B44(-10.339,4.835) B48(-10.339,7.313) B53(-10.339,9.791) B58(-10.339,12.269) B62(-10.339,14.747) B66(-10.339,17.226) B69(-10.685,19.035) BA3(10.685,-19.035) BA5(10.626,-17.715) BA8(10.339,-15.986) BA12(10.339,-13.565) BA16(10.339,-11.145) BA21(10.339,-8.724) BA23(10.258,-7.466) BA28(10.258,-4.988) BA32(10.258,-2.485) BA36(10.258,-0.007) BA41(10.258,2.471) BA45(10.258,4.949) BA49(10.339,7.355) BA53(10.258,9.762) BA57(10.258,12.24) BA62(10.258,14.718) BA68(10.685,19.035) BB4(11.314,-18.551) BB68(11.314,18.552) C4(-10.336,-18.615) C5(-10.014,-18.048) C7(-10.014,-16.791) C8(-10.339,-16.228) C9(-10.014,-15.664) C11(-10.014,-14.313) C12(-10.339,-13.75) C13(-10.014,-13.186) C15(-10.014,-11.835) C16(-10.339,-11.272) C17(-10.014,-10.708) C19(-10.014,-9.357) C20(-10.339,-8.794) C21(-10.014,-8.23) C23(-10.014,-6.879) C24(-10.339,-6.316) C25(-10.014,-5.752) C27(-10.014,-4.401) C28(-10.339,-3.838) C29(-10.014,-3.274) C31(-10.014,-1.923) C32(-10.339,-1.36) C33(-10.014,-0.796) C36(-10.014,0.555) C37(-10.339,1.118) C38(-10.014,1.682) C40(-10.014,3.033) C41(-10.339,3.596) C42(-10.014,4.16) C45(-10.014,5.511) C46(-10.339,6.074) C47(-10.014,6.638) C50(-10.014,7.989) C51(-10.339,8.552) C52(-10.014,9.116) C54(-10.014,10.467) C55(-10.339,11.03) C56(-10.014,11.594) C59(-10.014,12.945) C60(-10.339,13.508) C61(-10.014,14.072) C63(-10.014,15.423) C64(-10.339,15.987) C65(-10.014,16.55) C67(-10.299,18.485) C68(-9.622,18.622) C70(-10.034,19.685) D3(-9.608,-19.339) D4(-9.669,-18.691) D5(-9.363,-18.09) D6(-9.323,-17.441) D7(-9.363,-16.791) D8(-9.689,-16.228) D9(-9.363,-15.664) D10(-9.323,-14.989) D11(-9.363,-14.313) D12(-9.689,-13.75) D13(-9.363,-13.186) D14(-9.323,-12.511) D15(-9.363,-11.835) D16(-9.689,-11.272) D17(-9.363,-10.708) D18(-9.323,-10.033) D19(-9.363,-9.357) D20(-9.689,-8.794) D21(-9.363,-8.23) D22(-9.323,-7.555) D23(-9.363,-6.879) D24(-9.689,-6.316) D25(-9.363,-5.752) D26(-9.323,-5.077) D27(-9.363,-4.401) D28(-9.689,-3.838) D29(-9.363,-3.274) D30(-9.323,-2.599) D31(-9.363,-1.923) D32(-9.689,-1.36) D33(-9.363,-0.796) D34(-9.323,-0.121) D36(-9.363,0.555) D37(-9.689,1.118) D38(-9.363,1.682) D39(-9.323,2.357) D40(-9.363,3.033) D41(-9.689,3.596) D42(-9.363,4.16) D44(-9.323,4.835) D45(-9.363,5.511) D46(-9.689,6.074) D47(-9.363,6.638) D48(-9.323,7.313) D50(-9.363,7.989) D51(-9.689,8.552) D52(-9.363,9.116) D53(-9.323,9.791) D54(-9.363,10.467) D55(-9.689,11.03) D56(-9.363,11.594) D58(-9.323,12.269) D59(-9.363,12.945) D60(-9.689,13.508) D61(-9.363,14.072) D62(-9.323,14.747) D63(-9.363,15.423) D64(-9.689,15.987) D65(-9.363,16.55) D66(-9.323,17.226) D67(-10.014,17.899) D68(-9.535,19.267) D69(-8.971,18.562) D71(-9.551,20.314) E1(-9.04,-20.314) E2(-9.04,-19.664) E3(-9.04,-19.014) E5(-8.591,-17.654) E6(-8.591,-16.74) E8(-8.591,-15.825) E10(-8.591,-14.911) E11(-8.591,-13.996) E13(-8.591,-13.082) E15(-8.591,-12.168) E16(-8.591,-11.253) E18(-8.591,-10.339) E20(-8.591,-9.424) E21(-8.591,-8.51) E22(-8.591,-7.596) E23(-8.591,-6.681) E25(-8.591,-5.767) E27(-8.591,-4.852) E28(-8.591,-3.938) E30(-8.591,-3.024) E32(-8.591,-2.109) E33(-8.591,-1.195) E35(-8.591,-0.28) E37(-8.591,0.634) E38(-8.591,1.548) E40(-8.591,2.463) E42(-8.591,3.377) E43(-8.591,4.292) E45(-8.591,5.206) E46(-8.591,6.12) E48(-8.591,7.035) E50(-8.591,7.949) E52(-8.591,8.864) E53(-8.591,9.778) E55(-8.591,10.692) E56(-8.591,11.607) E58(-8.591,12.521) E60(-8.591,13.436) E61(-8.591,14.35) E63(-8.655,15.315) E65(-8.655,16.331) E66(-8.655,17.347) E68(-9.363,17.899) F2(-8.466,-19.339) F4(-8.466,-18.363) F5(-7.941,-17.654) F6(-7.941,-16.74) F8(-7.941,-15.825) F10(-7.941,-14.911) F11(-7.941,-13.996) F13(-7.941,-13.082) F15(-7.941,-12.168) F16(-7.941,-11.253) F18(-7.941,-10.339) F20(-7.941,-9.424) F21(-7.941,-8.51) F22(-7.941,-7.596) F23(-7.941,-6.681) F25(-7.941,-5.767) F27(-7.941,-4.852) F28(-7.941,-3.938) F30(-7.941,-3.024) F32(-7.941,-2.109) F33(-7.941,-1.195) F35(-7.941,-0.28) F37(-7.941,0.634) F38(-7.941,1.548) F40(-7.941,2.463) F42(-7.941,3.377) F43(-7.941,4.292) F45(-7.941,5.206) F46(-7.941,6.12) F48(-7.941,7.035) F50(-7.941,7.949) F52(-7.941,8.864) F53(-7.941,9.778) F55(-7.941,10.692) F56(-7.941,11.607) F58(-7.941,12.521) F60(-7.941,13.436) F61(-7.941,14.35) F63(-8.005,15.315) F65(-8.005,16.331) F66(-8.005,17.347) F68(-8.32,18.562) G4(-7.803,-18.363) G5(-7.291,-17.654) G6(-7.291,-16.74) G8(-7.291,-15.825) G10(-7.291,-14.911) G11(-7.291,-13.996) G13(-7.291,-13.082) G15(-7.291,-12.168) G16(-7.291,-11.253) G18(-7.291,-10.339) G20(-7.291,-9.424) G21(-7.291,-8.51) G22(-7.291,-7.596) G23(-7.291,-6.681) G25(-7.291,-5.767) G27(-7.291,-4.852) G28(-7.291,-3.938) G30(-7.291,-3.024) G32(-7.291,-2.109) G33(-7.291,-1.195) G35(-7.291,-0.28) G37(-7.291,0.634) G38(-7.291,1.548) G40(-7.291,2.463) G42(-7.291,3.377) G43(-7.291,4.292) G45(-7.291,5.206) G46(-7.291,6.12) G48(-7.291,7.035) G50(-7.291,7.949) G52(-7.291,8.864) G53(-7.291,9.778) G55(-7.291,10.692) G56(-7.291,11.607) G58(-7.291,12.521) G60(-7.291,13.436) G61(-7.291,14.35) G63(-7.354,15.315) G65(-7.354,16.331) G66(-7.354,17.347) G68(-7.66,18.364) G69(-7.66,19.014) H3(-7.14,-18.689) H5(-6.641,-17.654) H6(-6.641,-16.74) H8(-6.641,-15.825) H10(-6.641,-14.911) H11(-6.641,-13.996) H13(-6.641,-13.082) H15(-6.641,-12.168) H16(-6.641,-11.253) H18(-6.641,-10.339) H20(-6.641,-9.424) H21(-6.641,-8.51) H63(-6.704,15.315) H65(-6.704,16.331) H66(-6.704,17.347) H69(-7.096,18.689) J4(-6.477,-18.363) J5(-5.99,-17.654) J6(-5.99,-16.74) J8(-5.99,-15.825) J10(-5.99,-14.911) J11(-5.99,-13.996) J13(-5.99,-13.082) J22(-6.827,-7.138) J23(-6.827,-6.224) J25(-6.827,-5.31) J27(-6.827,-4.395) J28(-6.827,-3.481) J30(-6.827,-2.566) J32(-6.827,-1.652) J33(-6.827,-0.738) J35(-6.827,0.177) J37(-6.827,1.091) J38(-6.827,2.006) J40(-6.827,2.92) J42(-6.827,3.834) J43(-6.827,4.749) J45(-6.827,5.663) J46(-6.827,6.578) J48(-6.827,7.492) J50(-6.827,8.406) J52(-6.827,9.321) J53(-6.827,10.235) J55(-6.827,11.15) J56(-6.827,12.064) J58(-6.827,12.978) J60(-6.827,13.893) J68(-6.52,18.362) K15(-5.876,-12.188) K16(-5.876,-11.538) K17(-5.876,-10.888) K18(-5.876,-10.237) K19(-5.876,-9.587) K20(-5.876,-8.937) K21(-5.876,-8.287) K22(-6.362,-7.596) K23(-6.362,-6.681) K25(-6.362,-5.767) K27(-6.362,-4.852) K28(-6.362,-3.938) K30(-6.362,-3.024) K32(-6.362,-2.109) K33(-6.362,-1.195) K35(-6.362,-0.28) K37(-6.362,0.634) K38(-6.362,1.548) K40(-6.362,2.463) K42(-6.362,3.377) K43(-6.362,4.292) K45(-6.362,5.206) K46(-6.362,6.12) K48(-6.362,7.035) K50(-6.362,7.949) K52(-6.362,8.864) K53(-6.362,9.778) K55(-6.362,10.692) K56(-6.362,11.607) K58(-6.362,12.521) K60(-6.362,13.436) K61(-6.362,14.35) K63(-6.054,15.133) K64(-6.054,15.783) K65(-6.054,16.433) K66(-6.054,17.084) K67(-6.054,17.734) K68(-5.846,18.352) K70(-5.744,19.339) L2(-5.814,-19.339) L4(-5.814,-18.363) L6(-5.34,-17.585) L7(-5.34,-16.935) L8(-5.34,-16.285) L9(-5.34,-15.635) L10(-5.34,-14.984) L11(-5.34,-14.334) L12(-5.34,-13.684) L13(-5.34,-13.034) L15(-5.038,-12.188) L16(-5.038,-11.538) L17(-5.038,-10.888) L18(-5.038,-10.237) L19(-5.038,-9.587) L20(-5.038,-8.937) L21(-5.038,-8.287) L62(-5.625,14.644) L63(-5.168,15.112) L64(-5.168,15.763) L65(-5.168,16.413) L66(-5.168,17.063) L67(-5.168,17.713) L68(-5.168,18.364) L69(-5.168,19.014) L70(-5.168,19.664) L71(-5.168,20.314) M4(-5.151,-18.363) M62(-4.71,14.644) N3(-4.488,-18.689) N6(-4.4,-17.585) N7(-4.4,-16.935) N8(-4.4,-16.285) N9(-4.4,-15.635) N10(-4.4,-14.984) N11(-4.4,-14.334) N12(-4.4,-13.684) N13(-4.4,-13.034) N15(-4.2,-12.188) N16(-4.2,-11.538) N17(-4.2,-10.888) N18(-4.2,-10.237) N19(-4.2,-9.587) N20(-4.2,-8.937) N21(-4.2,-8.287) N63(-4.253,15.112) N64(-4.253,15.763) N65(-4.253,16.413) N66(-4.253,17.063) N67(-4.253,17.713) N68(-4.253,18.364) N69(-4.253,19.014) N70(-4.253,19.664) N71(-4.253,20.314) P4(-3.825,-18.363) P15(-3.362,-12.188) P16(-3.362,-11.538) P17(-3.362,-10.888) P18(-3.362,-10.237) P19(-3.362,-9.587) P20(-3.362,-8.937) P21(-3.362,-8.287) P62(-3.796,14.644) R6(-3.333,-17.585) R7(-3.333,-16.935) R8(-3.333,-16.285) R9(-3.333,-15.635) R10(-3.333,-14.984) R11(-3.333,-14.334) R12(-3.333,-13.684) R13(-3.333,-13.034) R63(-3.339,15.112) R64(-3.339,15.763) R65(-3.339,16.413) R66(-3.339,17.063) R67(-3.339,17.713) R68(-3.339,18.364) R69(-3.339,19.014) R70(-3.339,19.664) R71(-3.339,20.314) T2(-3.162,-19.339) T4(-3.162,-18.363) T15(-2.523,-12.188) T16(-2.523,-11.538) T17(-2.523,-10.888) T18(-2.523,-10.237) T19(-2.523,-9.587) T20(-2.523,-8.937) T21(-2.523,-8.287) T62(-2.882,14.644) U4(-2.499,-18.363) U6(-2.267,-17.585) U7(-2.267,-16.935) U8(-2.267,-16.285) U9(-2.267,-15.635) U10(-2.267,-14.984) U11(-2.267,-14.334) U12(-2.267,-13.684) U13(-2.267,-13.034) U63(-2.424,15.112) U64(-2.424,15.763) U65(-2.424,16.413) U66(-2.424,17.063) U67(-2.424,17.713) U68(-2.424,18.364) U69(-2.424,19.014) U70(-2.424,19.664) U71(-2.424,20.314) V3(-1.836,-18.689) V15(-1.685,-12.188) V16(-1.685,-11.538) V17(-1.685,-10.888) V18(-1.685,-10.237) V19(-1.685,-9.587) V20(-1.685,-8.937) V21(-1.685,-8.287) V62(-1.967,14.644) W4(-1.173,-18.363) W6(-1.2,-17.585) W7(-1.2,-16.935) W8(-1.2,-16.285) W9(-1.2,-15.635) W10(-1.2,-14.984) W11(-1.2,-14.334) W12(-1.2,-13.684) W13(-1.2,-13.034) W63(-1.51,15.112) W64(-1.51,15.763) W65(-1.51,16.413) W66(-1.51,17.063) W67(-1.51,17.713) W68(-1.51,18.364) W69(-1.51,19.014) W70(-1.51,19.664) W71(-1.51,20.314) Y15(-0.847,-12.188) Y16(-0.847,-11.538) Y17(-0.847,-10.888) Y18(-0.847,-10.237) Y19(-0.847,-9.587) Y20(-0.847,-8.937) Y21(-0.847,-8.287) Y62(-1.053,14.644)
  oval 0.343x0.254 smd: A6(-10.989,-17.467) A7(-11.314,-16.791) A9(-11.314,-15.664) A10(-10.989,-14.989) A11(-11.314,-14.313) A13(-11.314,-13.186) A14(-10.989,-12.511) A15(-11.314,-11.835) A17(-11.314,-10.708) A18(-10.989,-10.033) A19(-11.314,-9.357) A21(-11.314,-8.23) A22(-10.989,-7.555) A23(-11.314,-6.879) A25(-11.314,-5.752) A26(-10.989,-5.077) A27(-11.314,-4.401) A29(-11.314,-3.274) A30(-10.989,-2.599) A31(-11.314,-1.923) A33(-11.314,-0.796) A34(-10.989,-0.121) A36(-11.314,0.555) A38(-11.314,1.682) A39(-10.989,2.357) A40(-11.314,3.033) A42(-11.314,4.16) A44(-10.989,4.835) A45(-11.314,5.511) A47(-11.314,6.638) A48(-10.989,7.313) A50(-11.314,7.989) A52(-11.314,9.116) A53(-10.989,9.791) A54(-11.314,10.467) A56(-11.314,11.594) A58(-10.989,12.269) A59(-11.314,12.945) A61(-11.314,14.072) A62(-10.989,14.747) A63(-11.314,15.423) A65(-11.314,16.55) A66(-10.989,17.226) A67(-11.314,17.901) AY7(10.014,-16.551) AY9(10.014,-15.416) AY11(10.014,-14.13) AY13(10.014,-12.995) AY15(10.014,-11.71) AY17(10.014,-10.574) AY20(10.014,-9.289) AY22(10.014,-8.154) AY25(10.014,-6.828) AY31(10.014,-3.148) AY33(10.014,-1.847) AY39(10.014,1.834) AY42(10.014,3.109) AY48(10.014,6.789) AY50(10.014,7.922) AY56(10.014,11.602) AY59(10.014,12.877) AY65(10.014,16.558) AY67(10.014,17.901) B7(-10.664,-16.791) B9(-10.664,-15.664) B11(-10.664,-14.313) B13(-10.664,-13.186) B15(-10.664,-11.835) B17(-10.664,-10.708) B19(-10.664,-9.357) B21(-10.664,-8.23) B23(-10.664,-6.879) B25(-10.664,-5.752) B27(-10.664,-4.401) B29(-10.664,-3.274) B31(-10.664,-1.923) B33(-10.664,-0.796) B36(-10.664,0.555) B38(-10.664,1.682) B40(-10.664,3.033) B42(-10.664,4.16) B45(-10.664,5.511) B47(-10.664,6.638) B50(-10.664,7.989) B52(-10.664,9.116) B54(-10.664,10.467) B56(-10.664,11.594) B59(-10.664,12.945) B61(-10.664,14.072) B63(-10.664,15.423) B65(-10.664,16.55) B67(-10.664,17.901) BA4(10.689,-18.366) BA6(10.257,-17.173) BA7(10.664,-16.61) BA9(10.664,-15.416) BA10(10.257,-14.753) BA11(10.664,-14.189) BA13(10.664,-12.995) BA14(10.257,-12.332) BA15(10.664,-11.768) BA17(10.664,-10.574) BA18(10.257,-9.912) BA20(10.664,-9.348) BA22(10.664,-8.154) BA25(10.664,-6.828) BA26(10.339,-6.165) BA27(10.664,-5.502) BA29(10.664,-4.473) BA30(10.339,-3.811) BA31(10.664,-3.148) BA33(10.664,-1.847) BA34(10.339,-1.184) BA35(10.664,-0.521) BA37(10.664,0.507) BA38(10.339,1.17) BA39(10.664,1.834) BA42(10.664,3.109) BA43(10.339,3.771) BA44(10.664,4.434) BA46(10.664,5.463) BA47(10.339,6.126) BA48(10.664,6.789) BA50(10.664,7.922) BA51(10.339,8.585) BA52(10.664,9.248) BA54(10.664,10.276) BA55(10.339,10.939) BA56(10.664,11.602) BA59(10.664,12.877) BA60(10.339,13.54) BA61(10.664,14.203) BA63(10.664,15.232) BA64(10.339,15.895) BA65(10.664,16.558) BA66(10.339,17.221) BA67(10.664,17.901) BB5(11.314,-17.786) BB6(10.989,-17.173) BB7(11.314,-16.61) BB9(11.314,-15.416) BB10(10.989,-14.753) BB11(11.314,-14.189) BB13(11.314,-12.995) BB14(10.989,-12.332) BB15(11.314,-11.768) BB17(11.314,-10.574) BB18(10.989,-9.912) BB20(11.314,-9.348) BB22(11.314,-8.154) BB23(10.908,-7.466) BB25(11.314,-6.828) BB26(10.989,-6.165) BB27(11.314,-5.502) BB29(11.314,-4.473) BB30(10.989,-3.811) BB31(11.314,-3.148) BB32(10.908,-2.484) BB33(11.314,-1.847) BB34(10.989,-1.184) BB35(11.314,-0.521) BB37(11.314,0.507) BB38(10.989,1.17) BB39(11.314,1.834) BB41(10.908,2.471) BB42(11.314,3.109) BB43(10.989,3.771) BB44(11.314,4.434) BB46(11.314,5.463) BB47(10.989,6.126) BB48(11.314,6.789) BB50(11.314,7.922) BB51(10.989,8.585) BB52(11.314,9.248) BB54(11.314,10.276) BB55(10.989,10.939) BB56(11.314,11.602) BB57(10.908,12.24) BB59(11.314,12.877) BB60(10.989,13.54) BB61(11.314,14.203) BB63(11.314,15.232) BB64(10.989,15.895) BB65(11.314,16.558) BB66(10.989,17.221) BB67(11.314,17.901)
  oval 0.254x0.343 smd: AA1(-0.51,-19.989) AB1(0.153,-20.314) AB2(0.153,-19.664) AB3(0.153,-19.013) AC1(0.815,-19.989) AC2(0.815,-19.339) AD1(1.479,-20.314) AD2(1.479,-19.664) AD3(1.479,-19.013) AF1(2.141,-19.989) AF70(1.84,19.664) AF71(1.84,20.314) AG1(2.804,-20.314) AG2(2.804,-19.664) AG3(2.804,-19.013) AG70(2.503,19.339) AG71(2.503,19.989) AH1(3.467,-19.989) AH2(3.467,-19.339) AH68(3.166,18.363) AH69(3.166,19.014) AH70(3.166,19.664) AH71(3.166,20.314) AJ1(4.13,-20.314) AJ2(4.13,-19.664) AJ3(4.13,-19.013) AK70(3.829,19.989) AL1(4.793,-19.989) AL68(4.492,18.363) AL69(4.492,19.014) AL70(4.492,19.664) AL71(4.492,20.314) AM1(5.456,-20.314) AM2(5.456,-19.664) AM3(5.456,-19.013) AM70(5.155,19.339) AM71(5.155,19.989) AN1(6.119,-19.989) AN2(6.119,-19.339) AN70(5.818,19.664) AN71(5.818,20.314) AP1(6.782,-20.314) AP2(6.782,-19.664) AP3(6.782,-19.013) AR70(6.846,19.664) AR71(6.846,20.314) AT1(7.445,-19.989) AT70(7.509,19.339) AT71(7.509,19.989) AU1(8.108,-20.314) AU2(8.108,-19.664) AU3(8.108,-19.013) AU68(8.147,18.363) AU69(8.172,19.014) AU70(8.172,19.664) AU71(8.172,20.314) AV1(8.828,-20.314) AV2(8.799,-19.364) AV71(8.901,20.314) AW2(9.363,-19.689) AW3(9.363,-19.039) E70(-9.009,19.664) E71(-8.901,20.314) F1(-8.466,-19.989) F70(-8.32,19.212) F71(-8.384,19.862) G1(-7.803,-20.314) G2(-7.803,-19.664) G3(-7.803,-19.013) G70(-7.759,19.664) G71(-7.759,20.314) H1(-7.14,-19.989) H2(-7.14,-19.339) H70(-7.096,19.339) H71(-7.096,19.989) J1(-6.477,-20.314) J2(-6.477,-19.664) J3(-6.477,-19.013) J69(-6.433,19.014) J70(-6.433,19.664) J71(-6.433,20.314) K71(-5.744,19.989) L1(-5.814,-19.989) M1(-5.151,-20.314) M2(-5.151,-19.664) M3(-5.151,-19.013) N1(-4.488,-19.989) N2(-4.488,-19.339) P1(-3.825,-20.314) P2(-3.825,-19.664) P3(-3.825,-19.013) T1(-3.162,-19.989) U1(-2.499,-20.314) U2(-2.499,-19.664) U3(-2.499,-19.013) V1(-1.836,-19.989) V2(-1.836,-19.339) W1(-1.173,-20.314) W2(-1.173,-19.664) W3(-1.173,-19.013)
CC0201
  rect 0.203x0.381 smd: 1(-0.225,0) 2(0.225,0)
CC0402
  custom 0.12x0.12 smd: 1(0.39,0) 2(-0.39,0)
CC0603
  rect 0.813x0.711 smd: 1(0.737,0) 2(-0.737,0)
CC0805
  rect 0.94x1.346 smd: 1(0.895,0) 2(-0.895,0)
CC1206
  rect 1.6x1.6 smd: 1(1.702,0) 2(-1.702,0)
CC1808
  rect 2.159x2.286 smd: 1(-2.349,0) 2(2.349,0)
CC3528
  rect 2.032x2.413 smd: 1(1.6,0) 2(-1.6,0)
CC7343
  rect 2.413x2.819 smd: 1(-3.2,0) 2(3.2,0)
CHOKE-ETQP4LR36AFM
  rect 2.794x2.591 smd: 1(-3.2,0) 2(3.2,0)
CHOKE-PCMC063T-3R3MN-SMT
  rect 1.854x3.505 smd: 1(-3.275,0) 2(3.275,0)
CHOKE-PCMC063T-R82MN-4P-SMT
  custom 0.591x0.591 smd: 1(-3.596,0) 2(3.596,0)
  rect 1.473x0.305 smd: 3(-2.452,0) 4(2.452,0)
D-DO-214AC
  rect 1.88x2.032 smd: 1(-2.1,0) 2(2.1,0)
D-SOD523-1_2X0_8-0_65H
  rect 0.787x0.61 smd: 1(-0.55,0) 2(0.55,0)
D-TO277_213-6_1X4_3
  rect 1.168x1.397 smd: 1(3.885,1.05) 2(3.885,-1.05)
  rect 4.648x3.505 smd: 3(0,0)
DDR-DDRRK-20401-TP5B-204P-RUV
  round 1.092 hole 1.092 unplated: (-33.4,0)
  round 1.6 hole 1.6 unplated: (33.4,0)
  rect 0.356x2.007 smd: 1(31.65,4.1) 2(31.35,-4.1) 3(31.05,4.1) 4(30.75,-4.1) 5(30.45,4.1) 6(30.15,-4.1) 7(29.85,4.1) 8(29.55,-4.1) 9(29.25,4.1) 10(28.95,-4.1) 11(28.65,4.1) 12(28.35,-4.1) 13(28.05,4.1) 14(27.75,-4.1) 15(27.45,4.1) 16(27.15,-4.1) 17(26.85,4.1) 18(26.55,-4.1) 19(26.25,4.1) 20(25.95,-4.1) 21(25.65,4.1) 22(25.35,-4.1) 23(25.05,4.1) 24(24.75,-4.1) 25(24.45,4.1) 26(24.15,-4.1) 27(23.85,4.1) 28(23.55,-4.1) 29(23.25,4.1) 30(22.95,-4.1) 31(22.65,4.1) 32(22.35,-4.1) 33(22.05,4.1) 34(21.75,-4.1) 35(21.45,4.1) 36(21.15,-4.1) 37(20.85,4.1) 38(20.55,-4.1) 39(20.25,4.1) 40(19.95,-4.1) 41(19.65,4.1) 42(19.35,-4.1) 43(19.05,4.1) 44(18.75,-4.1) 45(18.45,4.1) 46(18.15,-4.1) 47(17.85,4.1) 48(17.55,-4.1) 49(17.25,4.1) 50(16.95,-4.1) 51(16.65,4.1) 52(16.35,-4.1) 53(16.05,4.1) 54(15.75,-4.1) 55(15.45,4.1) 56(15.15,-4.1) 57(14.85,4.1) 58(14.55,-4.1) 59(14.25,4.1) 60(13.95,-4.1) 61(13.65,4.1) 62(13.35,-4.1) 63(13.05,4.1) 64(12.75,-4.1) 65(12.45,4.1) 66(12.15,-4.1) 67(11.85,4.1) 68(11.55,-4.1) 69(11.25,4.1) 70(10.95,-4.1) 71(10.65,4.1) 72(10.35,-4.1) 73(7.65,4.1) 74(7.35,-4.1) 75(7.05,4.1) 76(6.75,-4.1) 77(6.45,4.1) 78(6.15,-4.1) 79(5.85,4.1) 80(5.55,-4.1) 81(5.25,4.1) 82(4.95,-4.1) 83(4.65,4.1) 84(4.35,-4.1) 85(4.05,4.1) 86(3.75,-4.1) 87(3.45,4.1) 88(3.15,-4.1) 89(2.85,4.1) 90(2.55,-4.1) 91(2.25,4.1) 92(1.95,-4.1) 93(1.65,4.1) 94(1.35,-4.1) 95(1.05,4.1) 96(0.75,-4.1) 97(0.45,4.1) 98(0.15,-4.1) 99(-0.15,4.1) 100(-0.45,-4.1) 101(-0.75,4.1) 102(-1.05,-4.1) 103(-1.35,4.1) 104(-1.65,-4.1) 105(-1.95,4.1) 106(-2.25,-4.1) 107(-2.55,4.1) 108(-2.85,-4.1) 109(-3.15,4.1) 110(-3.45,-4.1) 111(-3.75,4.1) 112(-4.05,-4.1) 113(-4.35,4.1) 114(-4.65,-4.1) 115(-4.95,4.1) 116(-5.25,-4.1) 117(-5.55,4.1) 118(-5.85,-4.1) 119(-6.15,4.1) 120(-6.45,-4.1) 121(-6.75,4.1) 122(-7.05,-4.1) 123(-7.35,4.1) 124(-7.65,-4.1) 125(-7.95,4.1) 126(-8.25,-4.1) 127(-8.55,4.1) 128(-8.85,-4.1) 129(-9.15,4.1) 130(-9.45,-4.1) 131(-9.75,4.1) 132(-10.05,-4.1) 133(-10.35,4.1) 134(-10.65,-4.1) 135(-10.95,4.1) 136(-11.25,-4.1) 137(-11.55,4.1) 138(-11.85,-4.1) 139(-12.15,4.1) 140(-12.45,-4.1) 141(-12.75,4.1) 142(-13.05,-4.1) 143(-13.35,4.1) 144(-13.65,-4.1) 145(-13.95,4.1) 146(-14.25,-4.1) 147(-14.55,4.1) 148(-14.85,-4.1) 149(-15.15,4.1) 150(-15.45,-4.1) 151(-15.75,4.1) 152(-16.05,-4.1) 153(-16.35,4.1) 154(-16.65,-4.1) 155(-16.95,4.1) 156(-17.25,-4.1) 157(-17.55,4.1) 158(-17.85,-4.1) 159(-18.15,4.1) 160(-18.45,-4.1) 161(-18.75,4.1) 162(-19.05,-4.1) 163(-19.35,4.1) 164(-19.65,-4.1) 165(-19.95,4.1) 166(-20.25,-4.1) 167(-20.55,4.1) 168(-20.85,-4.1) 169(-21.15,4.1) 170(-21.45,-4.1) 171(-21.75,4.1) 172(-22.05,-4.1) 173(-22.35,4.1) 174(-22.65,-4.1) 175(-22.95,4.1) 176(-23.25,-4.1) 177(-23.55,4.1) 178(-23.85,-4.1) 179(-24.15,4.1) 180(-24.45,-4.1) 181(-24.75,4.1) 182(-25.05,-4.1) 183(-25.35,4.1) 184(-25.65,-4.1) 185(-25.95,4.1) 186(-26.25,-4.1) 187(-26.55,4.1) 188(-26.85,-4.1) 189(-27.15,4.1) 190(-27.45,-4.1) 191(-27.75,4.1) 192(-28.05,-4.1) 193(-28.35,4.1) 194(-28.65,-4.1) 195(-28.95,4.1) 196(-29.25,-4.1) 197(-29.55,4.1) 198(-29.85,-4.1) 199(-30.15,4.1) 200(-30.45,-4.1) 201(-30.75,4.1) 202(-31.05,-4.1) 203(-31.35,4.1) 204(-31.65,-4.1)
  rect 4.496x4.597 smd: 205(32.55,12) 206(-32.55,12)
DDR-DDRSK-20401-TP4B-204P-SMT
  round 1.702 hole 1.702 unplated: (-33.4,0)
  round 1.194 hole 1.194 unplated: (33.4,0)
  rect 0.305x2.007 smd: 1(-31.65,-4.1) 2(-31.35,4.1) 3(-31.05,-4.1) 4(-30.75,4.1) 5(-30.45,-4.1) 6(-30.15,4.1) 7(-29.85,-4.1) 8(-29.55,4.1) 9(-29.25,-4.1) 10(-28.95,4.1) 11(-28.65,-4.1) 12(-28.35,4.1) 13(-28.05,-4.1) 14(-27.75,4.1) 15(-27.45,-4.1) 16(-27.15,4.1) 17(-26.85,-4.1) 18(-26.55,4.1) 19(-26.25,-4.1) 20(-25.95,4.1) 21(-25.65,-4.1) 22(-25.35,4.1) 23(-25.05,-4.1) 24(-24.75,4.1) 25(-24.45,-4.1) 26(-24.15,4.1) 27(-23.85,-4.1) 28(-23.55,4.1) 29(-23.25,-4.1) 30(-22.95,4.1) 31(-22.65,-4.1) 32(-22.35,4.1) 33(-22.05,-4.1) 34(-21.75,4.1) 35(-21.45,-4.1) 36(-21.15,4.1) 37(-20.85,-4.1) 38(-20.55,4.1) 39(-20.25,-4.1) 40(-19.95,4.1) 41(-19.65,-4.1) 42(-19.35,4.1) 43(-19.05,-4.1) 44(-18.75,4.1) 45(-18.45,-4.1) 46(-18.15,4.1) 47(-17.85,-4.1) 48(-17.55,4.1) 49(-17.25,-4.1) 50(-16.95,4.1) 51(-16.65,-4.1) 52(-16.35,4.1) 53(-16.05,-4.1) 54(-15.75,4.1) 55(-15.45,-4.1) 56(-15.15,4.1) 57(-14.85,-4.1) 58(-14.55,4.1) 59(-14.25,-4.1) 60(-13.95,4.1) 61(-13.65,-4.1) 62(-13.35,4.1) 63(-13.05,-4.1) 64(-12.75,4.1) 65(-12.45,-4.1) 66(-12.15,4.1) 67(-11.85,-4.1) 68(-11.55,4.1) 69(-11.25,-4.1) 70(-10.95,4.1) 71(-10.65,-4.1) 72(-10.35,4.1) 73(-7.65,-4.1) 74(-7.35,4.1) 75(-7.05,-4.1) 76(-6.75,4.1) 77(-6.45,-4.1) 78(-6.15,4.1) 79(-5.85,-4.1) 80(-5.55,4.1) 81(-5.25,-4.1) 82(-4.95,4.1) 83(-4.65,-4.1) 84(-4.35,4.1) 85(-4.05,-4.1) 86(-3.75,4.1) 87(-3.45,-4.1) 88(-3.15,4.1) 89(-2.85,-4.1) 90(-2.55,4.1) 91(-2.25,-4.1) 92(-1.95,4.1) 93(-1.65,-4.1) 94(-1.35,4.1) 95(-1.05,-4.1) 96(-0.75,4.1) 97(-0.45,-4.1) 98(-0.15,4.1) 99(0.15,-4.1) 100(0.45,4.1) 101(0.75,-4.1) 102(1.05,4.1) 103(1.35,-4.1) 104(1.65,4.1) 105(1.95,-4.1) 106(2.25,4.1) 107(2.55,-4.1) 108(2.85,4.1) 109(3.15,-4.1) 110(3.45,4.1) 111(3.75,-4.1) 112(4.05,4.1) 113(4.35,-4.1) 114(4.65,4.1) 115(4.95,-4.1) 116(5.25,4.1) 117(5.55,-4.1) 118(5.85,4.1) 119(6.15,-4.1) 120(6.45,4.1) 121(6.75,-4.1) 122(7.05,4.1) 123(7.35,-4.1) 124(7.65,4.1) 125(7.95,-4.1) 126(8.25,4.1) 127(8.55,-4.1) 128(8.85,4.1) 129(9.15,-4.1) 130(9.45,4.1) 131(9.75,-4.1) 132(10.05,4.1) 133(10.35,-4.1) 134(10.65,4.1) 135(10.95,-4.1) 136(11.25,4.1) 137(11.55,-4.1) 138(11.85,4.1) 139(12.15,-4.1) 140(12.45,4.1) 141(12.75,-4.1) 142(13.05,4.1) 143(13.35,-4.1) 144(13.65,4.1) 145(13.95,-4.1) 146(14.25,4.1) 147(14.55,-4.1) 148(14.85,4.1) 149(15.15,-4.1) 150(15.45,4.1) 151(15.75,-4.1) 152(16.05,4.1) 153(16.35,-4.1) 154(16.65,4.1) 155(16.95,-4.1) 156(17.25,4.1) 157(17.55,-4.1) 158(17.85,4.1) 159(18.15,-4.1) 160(18.45,4.1) 161(18.75,-4.1) 162(19.05,4.1) 163(19.35,-4.1) 164(19.65,4.1) 165(19.95,-4.1) 166(20.25,4.1) 167(20.55,-4.1) 168(20.85,4.1) 169(21.15,-4.1) 170(21.45,4.1) 171(21.75,-4.1) 172(22.05,4.1) 173(22.35,-4.1) 174(22.65,4.1) 175(22.95,-4.1) 176(23.25,4.1) 177(23.55,-4.1) 178(23.85,4.1) 179(24.15,-4.1) 180(24.45,4.1) 181(24.75,-4.1) 182(25.05,4.1) 183(25.35,-4.1) 184(25.65,4.1) 185(25.95,-4.1) 186(26.25,4.1) 187(26.55,-4.1) 188(26.85,4.1) 189(27.15,-4.1) 190(27.45,4.1) 191(27.75,-4.1) 192(28.05,4.1) 193(28.35,-4.1) 194(28.65,4.1) 195(28.95,-4.1) 196(29.25,4.1) 197(29.55,-4.1) 198(29.85,4.1) 199(30.15,-4.1) 200(30.45,4.1) 201(30.75,-4.1) 202(31.05,4.1) 203(31.35,-4.1) 204(31.65,4.1)
  rect 4.496x4.597 smd: 205(-32.55,12) 206(32.55,12)
DFN10-3X3-5-11P-RT9296
  rect 0.305x0.991 smd: 1(-1,-1.6) 2(-0.5,-1.6) 3(0,-1.6) 4(0.5,-1.6) 5(1,-1.6) 6(1,1.6) 7(0.5,1.6) 8(0,1.6) 9(-0.5,1.6) 10(-1,1.6)
  rect 2.464x1.626 smd: 11(0,0)
DSM
  rect 1.016x0.508 smd: 1(-1.3,0) 2(1.321,0)
DSMV
  rect 1.016x0.762 smd: 1(-1.27,0) 2(1.27,0)
DSUB-070546FR015S265ZR-15P-V
  round 0.965 hole 0.711: 1(4.58,-0.1) 2(2.29,-0.1) 3(0,-0.1) 4(-2.29,-0.1) 5(-4.58,-0.1) 6(5.725,-0.1) 7(3.435,-0.1) 8(1.145,-0.1) 9(-1.145,-0.1) 10(-3.435,-0.1)
  round 1.118 hole 0.711: 11(4.58,-1.5) 12(2.29,-1.5) 13(0,-1.5) 14(-2.29,-1.5) 15(-4.58,-1.5)
  oval 1.626x3.505 hole 0.61x2.489: 16(-10.05,0) 17(10.05,0)
ECAP6_3X6_1-7_2
  rect 3.505x1.6 smd: 1(2.8,0) 2(-2.8,0)
ESD10-4_1X2-8-11P
  rect 0.203x0.508 smd: 1(-1.8,-0.95) 2(-1,-0.95) 3(-0.2,-0.95) 4(0.6,-0.95) 5(1.4,-0.95) 6(1.8,0.95) 7(1,0.95) 8(0.2,0.95) 9(-0.6,0.95) 10(-1.4,0.95)
  rect 1.397x0.787 smd: 11(-0.4,0)
GS12401-1011-40P-R-NH-SMT
  round 0.94 hole 0.94 unplated: (-10.5,0) (10.5,0)
  rect 0.254x1.143 smd: 1(9.75,2.125) 2(9.25,2.125) 3(8.75,2.125) 4(8.25,2.125) 5(7.75,2.125) 6(7.25,2.125) 7(6.75,2.125) 8(6.25,2.125) 9(5.75,2.125) 10(5.25,2.125) 11(4.75,2.125) 12(4.25,2.125) 13(3.75,2.125) 14(3.25,2.125) 15(2.75,2.125) 16(2.25,2.125) 17(1.75,2.125) 18(1.25,2.125) 19(0.75,2.125) 20(0.25,2.125) 21(-0.25,2.125) 22(-0.75,2.125) 23(-1.25,2.125) 24(-1.75,2.125) 25(-2.25,2.125) 26(-2.75,2.125) 27(-3.25,2.125) 28(-3.75,2.125) 29(-4.25,2.125) 30(-4.75,2.125) 31(-5.25,2.125) 32(-5.75,2.125) 33(-6.25,2.125) 34(-6.75,2.125) 35(-7.25,2.125) 36(-7.75,2.125) 37(-8.25,2.125) 38(-8.75,2.125) 39(-9.25,2.125) 40(-9.75,2.125)
  rect 1.499x2.997 smd: 41(12.65,0) 42(-12.65,0)
  rect 2.794x1.499 smd: 43(5.7,-2.45) 44(-5.7,-2.45)
H-C118D118
  round 2.997 hole 2.997: 1(0,0)
H-C236D140P2
  round 5.994 hole 3.556: 1(0,0)
H-C236D142P2
  round 5.994 hole 3.607: 1(0,0)
H-C236IC180D140P2
  round 5.994 hole 3.556: 1(0,0)
H-C256D134P2
  round 6.502 hole 3.404: 1(0,0)
H-O112X120D112X120N
  oval 2.845x3.048 hole 2.845x3.048 unplated: (0,0)
H-O138X114D138X114N
  oval 3.505x2.896 hole 3.505x2.896 unplated: (0,0)
H-O152X93D152X93N
  oval 3.861x2.362 hole 3.861x2.362 unplated: (0,0)
H-TC256IC201BC236D161P2
  round 6.502 hole 4.089: 1(0,0)
H-TC315BC354D134P2
  round 8.001 hole 3.404: 1(0,0)
H-TC315BC354D217P2
  round 8.001 hole 5.512: 1(0,0)
H-ZRW-1
  custom 2.062x2.062 hole 6.401: 1(0,0)
HDMI-10444-19001-19P
  round 0.813 hole 0.559: 1(-4.5,6.65) 2(-4,8.2) 3(-3.5,6.65) 4(-3,8.2) 5(-2.5,6.65) 6(-2,8.2) 7(-1.5,6.65) 8(-1,8.2) 9(-0.5,6.65) 10(0,8.2) 11(0.5,6.65) 12(1,8.2) 13(1.5,6.65) 14(2,8.2) 15(2.5,6.65) 16(3,8.2) 17(3.5,6.65) 18(4,8.2) 19(4.5,6.65)
  oval 1.803x2.794 hole 0.787x1.803: 20(-9.25,0) 22(9.25,0)
  oval 1.803x3.607 hole 0.787x2.591: 21(-7.25,7.6) 23(7.25,7.6)
HS8803F-3P-L
  rect 0.787x1.905 smd: 1(-1.25,4.875) 2(0,4.875) 3(1.25,4.875)
  rect 1.295x3.353 smd: 4(-4.1,0) 5(4.1,0)
JOPEN25X30_S
  custom 0.159x0.159 smd: 1(-0.368,0) 2(0.368,0)
L3_2X2_5-1_55
  rect 1.245x2.007 smd: 1(-1.275,0) 2(1.275,0)
LEDLTST-S326KGJRKT-3P-SMT
  rect 0.991x0.991 smd: 1(-1.5,0) 3(1.5,0)
  rect 0.889x0.889 smd: 2(0,-0.65)
LQFP128-16X16-4-1_6H
  rect 0.203x1.499 smd: 1(-6.2,-7.85) 2(-5.8,-7.85) 3(-5.4,-7.85) 4(-5,-7.85) 5(-4.6,-7.85) 6(-4.2,-7.85) 7(-3.8,-7.85) 8(-3.4,-7.85) 9(-3,-7.85) 10(-2.6,-7.85) 11(-2.2,-7.85) 12(-1.8,-7.85) 13(-1.4,-7.85) 14(-1,-7.85) 15(-0.6,-7.85) 16(-0.2,-7.85) 17(0.2,-7.85) 18(0.6,-7.85) 19(1,-7.85) 20(1.4,-7.85) 21(1.8,-7.85) 22(2.2,-7.85) 23(2.6,-7.85) 24(3,-7.85) 25(3.4,-7.85) 26(3.8,-7.85) 27(4.2,-7.85) 28(4.6,-7.85) 29(5,-7.85) 30(5.4,-7.85) 31(5.8,-7.85) 32(6.2,-7.85) 65(6.2,7.85) 66(5.8,7.85) 67(5.4,7.85) 68(5,7.85) 69(4.6,7.85) 70(4.2,7.85) 71(3.8,7.85) 72(3.4,7.85) 73(3,7.85) 74(2.6,7.85) 75(2.2,7.85) 76(1.8,7.85) 77(1.4,7.85) 78(1,7.85) 79(0.6,7.85) 80(0.2,7.85) 81(-0.2,7.85) 82(-0.6,7.85) 83(-1,7.85) 84(-1.4,7.85) 85(-1.8,7.85) 86(-2.2,7.85) 87(-2.6,7.85) 88(-3,7.85) 89(-3.4,7.85) 90(-3.8,7.85) 91(-4.2,7.85) 92(-4.6,7.85) 93(-5,7.85) 94(-5.4,7.85) 95(-5.8,7.85) 96(-6.2,7.85)
  rect 1.499x0.203 smd: 33(7.85,-6.2) 34(7.85,-5.8) 35(7.85,-5.4) 36(7.85,-5) 37(7.85,-4.6) 38(7.85,-4.2) 39(7.85,-3.8) 40(7.85,-3.4) 41(7.85,-3) 42(7.85,-2.6) 43(7.85,-2.2) 44(7.85,-1.8) 45(7.85,-1.4) 46(7.85,-1) 47(7.85,-0.6) 48(7.85,-0.2) 49(7.85,0.2) 50(7.85,0.6) 51(7.85,1) 52(7.85,1.4) 53(7.85,1.8) 54(7.85,2.2) 55(7.85,2.6) 56(7.85,3) 57(7.85,3.4) 58(7.85,3.8) 59(7.85,4.2) 60(7.85,4.6) 61(7.85,5) 62(7.85,5.4) 63(7.85,5.8) 64(7.85,6.2) 97(-7.85,6.2) 98(-7.85,5.8) 99(-7.85,5.4) 100(-7.85,5) 101(-7.85,4.6) 102(-7.85,4.2) 103(-7.85,3.8) 104(-7.85,3.4) 105(-7.85,3) 106(-7.85,2.6) 107(-7.85,2.2) 108(-7.85,1.8) 109(-7.85,1.4) 110(-7.85,1) 111(-7.85,0.6) 112(-7.85,0.2) 113(-7.85,-0.2) 114(-7.85,-0.6) 115(-7.85,-1) 116(-7.85,-1.4) 117(-7.85,-1.8) 118(-7.85,-2.2) 119(-7.85,-2.6) 120(-7.85,-3) 121(-7.85,-3.4) 122(-7.85,-3.8) 123(-7.85,-4.2) 124(-7.85,-4.6) 125(-7.85,-5) 126(-7.85,-5.4) 127(-7.85,-5.8) 128(-7.85,-6.2)
MIC-FM-M201-U03-6P
  round 0.991 smd: 1(-1.17,1.65) 2(-1.17,0) 3(-1.17,-1.65) 4(1.17,-1.65) 5(1.17,0)
  oval 0.991x1.295 smd rot 135: 6(1.065,1.55)
NGFF-APCI0085-P005A-75P-KE
  round 1.092 hole 1.092 unplated: (-10,0)
  round 1.6 hole 1.6 unplated: (10,0)
  rect 0.305x1.549 smd: 1(-9.25,5.275) 2(-9,-2.275) 3(-8.75,5.275) 4(-8.5,-2.275) 5(-8.25,5.275) 6(-8,-2.275) 7(-7.75,5.275) 8(-7.5,-2.275) 9(-7.25,5.275) 10(-7,-2.275) 11(-6.75,5.275) 12(-6.5,-2.275) 13(-6.25,5.275) 14(-6,-2.275) 15(-5.75,5.275) 16(-5.5,-2.275) 17(-5.25,5.275) 18(-5,-2.275) 19(-4.75,5.275) 20(-4.5,-2.275) 21(-4.25,5.275) 22(-4,-2.275) 23(-3.75,5.275) 32(-1.5,-2.275) 33(-1.25,5.275) 34(-1,-2.275) 35(-0.75,5.275) 36(-0.5,-2.275) 37(-0.25,5.275) 38(0,-2.275) 39(0.25,5.275) 40(0.5,-2.275) 41(0.75,5.275) 42(1,-2.275) 43(1.25,5.275) 44(1.5,-2.275) 45(1.75,5.275) 46(2,-2.275) 47(2.25,5.275) 48(2.5,-2.275) 49(2.75,5.275) 50(3,-2.275) 51(3.25,5.275) 52(3.5,-2.275) 53(3.75,5.275) 54(4,-2.275) 55(4.25,5.275) 56(4.5,-2.275) 57(4.75,5.275) 58(5,-2.275) 59(5.25,5.275) 60(5.5,-2.275) 61(5.75,5.275) 62(6,-2.275) 63(6.25,5.275) 64(6.5,-2.275) 65(6.75,5.275) 66(7,-2.275) 67(7.25,5.275) 68(7.5,-2.275) 69(7.75,5.275) 70(8,-2.275) 71(8.25,5.275) 72(8.5,-2.275) 73(8.75,5.275) 74(9,-2.275) 75(9.25,5.275)
  rect 1.194x2.743 smd: 76(-10.35,4.5) 77(10.35,4.5)
O-ZRTA-2
  custom 2x2 hole 3.404: 1(0,0)
O-ZRTA-3
  custom 2.25x2.25 hole 3.404: 1(0,0)
O-ZRTA-4
  custom 1.9x1.9 hole 3.404: 1(0,0)
O-ZRTA-5
  custom 1.475x1.475 hole 3.404: 1(0,0)
O-ZRZ-7
  round 5.004 hole 5.004 unplated: (0,0)
O-ZRZ-8
  round 5.004 hole 5.004 unplated: (0,0)
PHJK-2SJ3080-077111F-6P
  oval 1.092x2.007 hole 0.508x1.499: 1(-4.85,7.025) 2(4.7,1.525) 3(-4.85,-0.775) 4(4.7,-1.375) 5(4.7,7.025) 6(4.7,4.275) 7(-4.85,2.925)
POWER-3_5X5-5-14P
  rect 0.254x0.559 smd: 1(-1,-2.325) 2(-0.5,-2.325) 3(0,-2.325) 4(0.5,-2.325) 5(1,-2.325)
  rect 2.972x1.473 smd: 6(0.37,-1.115)
  custom 0.588x0.588 smd: 9(0,0)
  rect 1.956x0.686 smd: 13(0.25,2.262)
  rect 0.559x0.254 smd: 19(-1.575,0.5) 20(-1.575,0) 21(-1.575,-0.5) 22(-1.575,-1) 23(-1.575,-1.5)
  rect 0.533x0.254 smd: 24(-1.575,-2)
POWER-5X6-1_27-7P
  rect 0.635x0.66 smd: 1(2.835,-1.905) 5(-2.835,1.905) 6(-2.835,0.635) 7(-2.835,-0.635) 8(-2.835,-1.905)
  custom 0.485x0.485 smd: 2(2.18,0.115)
  rect 2.159x3.988 smd: 9(-0.525,0)
QFN13-2X3-5
  rect 0.254x1.499 smd: 1(-0.5,-0.55) 2(0.5,-0.55) 8(0,0.55)
  rect 0.711x0.254 smd: 3(1.45,-0.75) 4(1.45,-0.25) 5(1.45,0.25) 6(1.45,0.75) 10(-1.45,0.75) 11(-1.45,0.25) 12(-1.45,-0.25) 13(-1.45,-0.75)
  rect 0.254x0.711 smd: 7(0.5,0.95) 9(-0.5,0.95)
QFN14-3X3-4-16P
  rect 0.203x1.092 smd: 1(-0.525,-1.25) 2(0.175,-1.25) 8(0.525,1.25) 9(-0.175,1.25)
  rect 0.711x0.203 smd: 3(1.45,-0.8) 4(1.45,-0.4) 5(1.45,0) 6(1.45,0.4) 7(1.45,0.8) 10(-1.45,0.8) 11(-1.45,0.4) 12(-1.45,0) 13(-1.45,-0.4) 14(-1.45,-0.8)
  rect 0.203x0.66 smd: 15(-0.165,0) 16(0.435,0)
QFN16-3X3-5-17P-TPS2543RTER
  rect 0.305x0.991 smd: 1(-0.75,-1.6) 2(-0.25,-1.6) 3(0.25,-1.6) 4(0.75,-1.6) 9(0.75,1.6) 10(0.25,1.6) 11(-0.25,1.6) 12(-0.75,1.6)
  rect 0.991x0.305 smd: 5(1.6,-0.75) 6(1.6,-0.25) 7(1.6,0.25) 8(1.6,0.75) 13(-1.6,0.75) 14(-1.6,0.25) 15(-1.6,-0.25) 16(-1.6,-0.75)
  custom 0.415x0.415 smd: 17(0,0)
QFN20-3X3-4-21P-0_8H
  rect 0.203x0.991 smd: 1(-0.8,-1.6) 2(-0.4,-1.6) 3(0,-1.6) 4(0.4,-1.6) 5(0.8,-1.6) 11(0.8,1.6) 12(0.4,1.6) 13(0,1.6) 14(-0.4,1.6) 15(-0.8,1.6)
  rect 0.991x0.203 smd: 6(1.6,-0.8) 7(1.6,-0.4) 8(1.6,0) 9(1.6,0.4) 10(1.6,0.8) 16(-1.6,0.8) 17(-1.6,0.4) 18(-1.6,0) 19(-1.6,-0.4) 20(-1.6,-0.8)
  rect 1.6x1.6 smd: 21(0,0)
QFN20-3X3-4-26P
  rect 0.203x0.787 smd: 1(-0.8,-1.5) 2(-0.4,-1.5) 3(0,-1.5) 4(0.4,-1.5) 5(0.8,-1.5) 11(0.8,1.5) 12(0.4,1.5) 13(0,1.5) 14(-0.4,1.5) 15(-0.8,1.5)
  rect 0.787x0.203 smd: 6(1.5,-0.8) 7(1.5,-0.4) 8(1.5,0) 9(1.5,0.4) 10(1.5,0.8) 16(-1.5,0.8) 17(-1.5,0.4) 18(-1.5,0) 19(-1.5,-0.4) 20(-1.5,-0.8)
  rect 1.803x1.803 smd: 21(0,0)
  round 0.508 hole 0.305: 22(-0.5,-0.5) 23(0.5,-0.5) 24(0.5,0.5) 25(-0.5,0.5) 26(0,0)
QFN24-4X4-5-25P-ALC5629
  rect 0.305x0.991 smd: 1(-1.25,-2.1) 2(-0.75,-2.1) 3(-0.25,-2.1) 4(0.25,-2.1) 5(0.75,-2.1) 6(1.25,-2.1) 13(1.25,2.1) 14(0.75,2.1) 15(0.25,2.1) 16(-0.25,2.1) 17(-0.75,2.1) 18(-1.25,2.1)
  rect 0.991x0.305 smd: 7(2.1,-1.25) 8(2.1,-0.75) 9(2.1,-0.25) 10(2.1,0.25) 11(2.1,0.75) 12(2.1,1.25) 19(-2.1,1.25) 20(-2.1,0.75) 21(-2.1,0.25) 22(-2.1,-0.25) 23(-2.1,-0.75) 24(-2.1,-1.25)
  rect 2.261x2.261 smd: 25(0,0)
QFN28-4X4-4-38P
  custom 0.05x0.05 smd: 1(-1.2,-2) 2(-0.8,-2) 3(-0.4,-2) 4(0,-2) 5(0.4,-2) 6(0.8,-2) 7(1.2,-2) 8(2,-1.2) 9(2,-0.8) 10(2,-0.4) 11(2,0) 12(2,0.4) 13(2,0.8) 14(2,1.2) 15(1.2,2) 16(0.8,2) 17(0.4,2) 18(0,2) 19(-0.4,2) 20(-0.8,2) 21(-1.2,2) 22(-2,1.2) 23(-2,0.8) 24(-2,0.4) 25(-2,0) 26(-2,-0.4) 27(-2,-0.8) 28(-2,-1.2)
  rect 2.591x2.591 smd: 29(0,0)
  round 0.61 hole 0.305: 30(-1,-1) 31(0,-1) 32(1,-1) 33(1,0) 34(1,1) 35(0,1) 36(-1,1) 37(-1,0) 38(0,0)
QFN32-4X4-4-33P-0_9H
  custom 0.051x0.051 smd: 1(-1.4,-2.1) 8(1.4,-2.1) 9(2.1,-1.4) 16(2.1,1.4) 17(1.4,2.1) 24(-1.4,2.1) 25(-2.1,1.4) 32(-2.1,-1.4)
  rect 0.203x0.991 smd: 2(-1,-2.1) 3(-0.6,-2.1) 4(-0.2,-2.1) 5(0.2,-2.1) 6(0.6,-2.1) 7(1,-2.1) 18(1,2.1) 19(0.6,2.1) 20(0.2,2.1) 21(-0.2,2.1) 22(-0.6,2.1) 23(-1,2.1)
  rect 0.991x0.203 smd: 10(2.1,-1) 11(2.1,-0.6) 12(2.1,-0.2) 13(2.1,0.2) 14(2.1,0.6) 15(2.1,1) 26(-2.1,1) 27(-2.1,0.6) 28(-2.1,0.2) 29(-2.1,-0.2) 30(-2.1,-0.6) 31(-2.1,-1)
  rect 2.692x2.692 smd: 33(0,0)
QFN40-5X5-4-41P-ISL62771HRTZ-T
  rect 0.203x0.61 smd: 1(-1.8,-2.4) 2(-1.4,-2.4) 3(-1,-2.4) 4(-0.6,-2.4) 5(-0.2,-2.4) 6(0.2,-2.4) 7(0.6,-2.4) 8(1,-2.4) 9(1.4,-2.4) 10(1.8,-2.4) 21(1.8,2.4) 22(1.4,2.4) 23(1,2.4) 24(0.6,2.4) 25(0.2,2.4) 26(-0.2,2.4) 27(-0.6,2.4) 28(-1,2.4) 29(-1.4,2.4) 30(-1.8,2.4)
  rect 0.61x0.203 smd: 11(2.4,-1.8) 12(2.4,-1.4) 13(2.4,-1) 14(2.4,-0.6) 15(2.4,-0.2) 16(2.4,0.2) 17(2.4,0.6) 18(2.4,1) 19(2.4,1.4) 20(2.4,1.8) 31(-2.4,1.8) 32(-2.4,1.4) 33(-2.4,1) 34(-2.4,0.6) 35(-2.4,0.2) 36(-2.4,-0.2) 37(-2.4,-0.6) 38(-2.4,-1) 39(-2.4,-1.4) 40(-2.4,-1.8)
  rect 3.505x3.505 smd: 41(0,0)
QFN40-5X5-4-41P-IT6515FN
  rect 0.203x0.991 smd: 1(-1.8,-2.6) 2(-1.4,-2.6) 3(-1,-2.6) 4(-0.6,-2.6) 5(-0.2,-2.6) 6(0.2,-2.6) 7(0.6,-2.6) 8(1,-2.6) 9(1.4,-2.6) 10(1.8,-2.6) 21(1.8,2.6) 22(1.4,2.6) 23(1,2.6) 24(0.6,2.6) 25(0.2,2.6) 26(-0.2,2.6) 27(-0.6,2.6) 28(-1,2.6) 29(-1.4,2.6) 30(-1.8,2.6)
  rect 0.991x0.203 smd: 11(2.6,-1.8) 12(2.6,-1.4) 13(2.6,-1) 14(2.6,-0.6) 15(2.6,-0.2) 16(2.6,0.2) 17(2.6,0.6) 18(2.6,1) 19(2.6,1.4) 20(2.6,1.8) 31(-2.6,1.8) 32(-2.6,1.4) 33(-2.6,1) 34(-2.6,0.6) 35(-2.6,0.2) 36(-2.6,-0.2) 37(-2.6,-0.6) 38(-2.6,-1) 39(-2.6,-1.4) 40(-2.6,-1.8)
  rect 3.505x3.505 smd: 41(0,0)
QFN40-5X5-4-50P-0_75H
  custom 0.05x0.05 smd: 1(-1.8,-2.475) 2(-1.4,-2.475) 3(-1,-2.475) 4(-0.6,-2.475) 5(-0.2,-2.475) 6(0.2,-2.475) 7(0.6,-2.475) 8(1,-2.475) 9(1.4,-2.475) 10(1.8,-2.475) 11(2.475,-1.8) 12(2.475,-1.4) 13(2.475,-1) 14(2.475,-0.6) 15(2.475,-0.2) 16(2.475,0.2) 17(2.475,0.6) 18(2.475,1) 19(2.475,1.4) 20(2.475,1.8) 21(1.8,2.475) 22(1.4,2.475) 23(1,2.475) 24(0.6,2.475) 25(0.2,2.475) 26(-0.2,2.475) 27(-0.6,2.475) 28(-1,2.475) 29(-1.4,2.475) 30(-1.8,2.475) 31(-2.475,1.8) 32(-2.475,1.4) 33(-2.475,1) 34(-2.475,0.6) 35(-2.475,0.2) 36(-2.475,-0.2) 37(-2.475,-0.6) 38(-2.475,-1) 39(-2.475,-1.4) 40(-2.475,-1.8)
  rect 3.607x3.607 smd: 41(0,0)
  round 0.61 hole 0.305: 42(-1,-1) 43(0,-1) 44(1,-1) 45(1,0) 46(1,1) 47(0,1) 48(-1,1) 49(-1,0) 50(0,0)
QFN48-6X6-4-49P-ALC280
  rect 0.203x0.991 smd: 1(-2.2,-3.1) 2(-1.8,-3.1) 3(-1.4,-3.1) 4(-1,-3.1) 5(-0.6,-3.1) 6(-0.2,-3.1) 7(0.2,-3.1) 8(0.6,-3.1) 9(1,-3.1) 10(1.4,-3.1) 11(1.8,-3.1) 12(2.2,-3.1) 25(2.2,3.1) 26(1.8,3.1) 27(1.4,3.1) 28(1,3.1) 29(0.6,3.1) 30(0.2,3.1) 31(-0.2,3.1) 32(-0.6,3.1) 33(-1,3.1) 34(-1.4,3.1) 35(-1.8,3.1) 36(-2.2,3.1)
  rect 0.991x0.203 smd: 13(3.1,-2.2) 14(3.1,-1.8) 15(3.1,-1.4) 16(3.1,-1) 17(3.1,-0.6) 18(3.1,-0.2) 19(3.1,0.2) 20(3.1,0.6) 21(3.1,1) 22(3.1,1.4) 23(3.1,1.8) 24(3.1,2.2) 37(-3.1,2.2) 38(-3.1,1.8) 39(-3.1,1.4) 40(-3.1,1) 41(-3.1,0.6) 42(-3.1,0.2) 43(-3.1,-0.2) 44(-3.1,-0.6) 45(-3.1,-1) 46(-3.1,-1.4) 47(-3.1,-1.8) 48(-3.1,-2.2)
  rect 4.394x4.394 smd: 49(0,0)
RC0402
  custom 0.12x0.12 smd: 1(0.39,0) 2(-0.39,0)
RC0603
  rect 0.813x0.711 smd: 1(0.737,0) 2(-0.737,0)
RC0805
  rect 0.94x1.346 smd: 1(0.895,0) 2(-0.895,0)
RC1206
  rect 1.6x1.6 smd: 1(1.702,0) 2(-1.702,0)
RC3216
  rect 3.2x0.94 smd: 1(0,0.825) 2(0,-0.825)
RC3720-SMT
  rect 3.759x1.016 smd: 1(0,1.008) 2(0,-1.008)
RJ45-130452-01-8P-RUV
  round 1.295 hole 0.889: 1(3.57,7.5) 2(2.55,6.4) 3(1.53,7.5) 4(0.51,6.4) 5(-0.51,7.5) 6(-1.53,6.4) 7(-2.55,7.5) 8(-3.57,6.4)
  oval 2.007x3.404 hole 0.991x2.388: 9(7.99,0) 10(-7.99,0)
SATA-C166FQ-12208-L-22P-R
  round 1.067 hole 0.711: 1(15.875,-0.8) 2(14.605,-0.8) 3(13.335,-0.8) 4(12.065,-0.8) 5(10.795,-0.8) 6(9.525,-0.8) 7(8.255,-0.8) 8(1.905,-0.8) 9(0.635,-0.8) 10(-0.635,-0.8) 11(-1.905,-0.8) 12(-3.175,-0.8) 13(-4.445,-0.8) 14(-5.715,-0.8) 15(-6.985,-0.8) 16(-8.255,-0.8) 17(-9.525,-0.8) 18(-10.795,-0.8) 19(-12.065,-0.8) 20(-13.335,-0.8) 21(-14.605,-0.8) 22(-15.875,-0.8)
  oval 1.803x2.87 hole 0.991x2.083: 23(18.71,0) 24(-18.71,0)
SATA-SLS-13PVAB-13P-R
  round 1.092 hole 1.092 unplated: (-11.4,0) (11.4,0)
  round 1.041 hole 0.787: 1(9.38,1.52) 2(8.11,1.52) 3(6.84,1.52) 4(5.57,1.52) 5(4.3,1.52) 6(3.03,1.52) 7(1.76,1.52)
  round 0.813 hole 0.61: 8(-4.45,1.52) 9(-5.45,1.52) 10(-6.45,1.52) 11(-7.45,1.52) 12(-8.45,1.52) 13(-9.45,1.52)
  oval 1.803x2.87 hole 0.991x2.083: 14(13.125,1.52) 15(-13.125,1.52)
SC70-2_1-65-6P
  rect 1.27x0.279 smd: 1(1.02,-0.65) 2(1.02,0) 3(1.02,0.65) 4(-1.02,0.65) 5(-1.02,0) 6(-1.02,-0.65)
SDCARD-PSDAT4-09GLBS1NN4H0-11P
  round 1.092 hole 1.092 unplated: (-11.5,0)
  round 1.6 hole 1.6 unplated: (9.5,0)
  rect 0.991x1.499 smd: 1(6.875,2.8) 2(4.375,2.8) 3(1.875,2.8) 4(-0.625,2.8) 5(-3.125,2.8) 6(-5.625,2.8) 7(-8.125,2.8) 8(-9.755,2.8) 9(9.375,2.8)
  rect 0.711x1.499 smd: 10(-11.055,2.8) 11(-12.255,2.8)
  rect 1.499x2.794 smd: 12(11.3,1) 13(-13.65,1) 14(13.65,-13.6) 15(-13.65,-13.6)
SENSOR-3X3-5-16P-SMT
  rect 0.254x0.762 smd: 1(-1,-1.377) 2(-0.5,-1.377) 3(0,-1.377) 4(0.5,-1.377) 5(1,-1.377) 9(1,1.377) 10(0.5,1.377) 11(0,1.377) 12(-0.5,1.377) 13(-1,1.377)
  rect 0.762x0.254 smd: 6(1.377,-0.5) 7(1.377,0) 8(1.377,0.5) 14(-1.377,0.5) 15(-1.377,0) 16(-1.377,-0.5)
SHORT0402
  rect 0.648x0.5 smd: 1(-0.39,0) 2(0.39,0)
SHORT0603
  rect 1.168x0.711 smd: 1(0.737,0) 2(-0.737,0)
SHORT0805
  rect 1.397x1.346 smd: 1(0.895,0) 2(-0.895,0)
SLP10-2_5X1-5-10P
  rect 0.203x0.686 smd: 1(-1,-0.437) 2(-0.5,-0.437) 4(0.5,-0.437) 5(1,-0.437) 6(1,0.437) 7(0.5,0.437) 9(-0.5,0.437) 10(-1,0.437)
  rect 0.406x1.549 smd: 3(0,0)
SO-8FL-5P-OA
  rect 0.991x0.762 smd: 1(3.73,-1.905) 2(3.73,-0.635) 3(3.73,0.635) 4(3.73,1.905)
  custom 1.132x1.132 smd: 5(0,0)
SOIC8-6-1_27
  rect 0.533x1.753 smd: 1(-1.905,-2.73) 2(-0.635,-2.73) 3(0.635,-2.73) 4(1.905,-2.73) 5(1.905,2.73) 6(0.635,2.73) 7(-0.635,2.73) 8(-1.905,2.73)
SOIC8-7_9-1_27
  rect 0.533x1.549 smd: 1(-1.905,-3.775) 2(-0.635,-3.775) 3(0.635,-3.775) 4(1.905,-3.775) 5(1.905,3.775) 6(0.635,3.775) 7(-0.635,3.775) 8(-1.905,3.775)
SOIC8-8-1_27
  rect 0.533x1.6 smd: 1(-1.905,-3.8) 2(-0.635,-3.8) 3(0.635,-3.8) 4(1.905,-3.8) 5(1.905,3.8) 6(0.635,3.8) 7(-0.635,3.8) 8(-1.905,3.8)
SON10-3X3-5-16P
  rect 0.279x0.838 smd: 1(-1,-1.475) 2(-0.5,-1.475) 3(0,-1.475) 4(0.5,-1.475) 5(1,-1.475) 6(1,1.475) 7(0.5,1.475) 8(0,1.475) 9(-0.5,1.475) 10(-1,1.475)
  custom 0.413x0.413 smd: 11(0,0)
  round 0.61 hole 0.305: 12(-0.75,-0.5) 13(0.75,-0.5) 14(0.75,0.5) 15(-0.75,0.5) 16(0,0)

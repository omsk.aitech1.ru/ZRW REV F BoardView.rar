# Allegro board Quanta ZRW REV F - BoardView (.BRD).brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
VMA_DQ57: length 22.2
  TOP w0.114: U3.C3 v1(188.61,177.5)
  IN1 w0.165: v1(182.59,170.11) 183.31,170.11 183.48,170.27 183.48,170.77 183.64,170.93 184.67,170.93 184.84,170.77 184.84,170.57 185.03,170.38 185.4,170.38 185.6,170.57 185.6,170.79 185.76,170.95 188.05,170.95 188.45,171.34 188.45,172.89 188.28,173.05 187.86,173.05 187.69,173.22 187.69,173.59 187.86,173.76 188.28,173.76 188.45,173.92 188.45,174.33 188.28,174.49 187.62,174.49 187.46,174.66 187.46,177.3 187.65,177.5 v1(188.61,177.5)
  BOTTOM w0.102: U29.D7 v1(188.61,177.5)
  BOTTOM w0.127: U34.T25 180.69,166.38 181.14,166.82 181.14,168.07 181.63,168.56 181.69,168.56 181.99,168.86 181.99,169.51 v1(182.59,170.11)
VMA_DQ58: length 21.1
  TOP w0.114: U3.A3 188.21,175.5 188.63,175.08 v1(188.63,175.08)
  IN1 w0.165: v1(188.63,175.08) 188.63,174.66 188.82,174.48 188.82,174.47 188.97,174.32 188.97,173.96 189.14,173.79 189.71,173.79 189.88,173.63 189.88,173.3 189.71,173.13 189.1,173.13 188.93,172.96 188.93,172.63 189.1,172.47 189.82,172.47 189.98,172.3 189.98,171.97 189.82,171.81 189.1,171.81 188.93,171.64 188.93,169.76 188.77,169.59 188.37,169.59 188.2,169.76 188.2,170.31 188.04,170.47 187.62,170.47 187.45,170.31 187.45,169.76 187.29,169.59 186.91,169.59 186.74,169.76 186.74,170.38 186.58,170.55 186.15,170.55 185.98,170.38 185.98,169.13 185.82,168.97 185.33,168.97 185.16,169.13 185.16,169.75 185,169.91 184.53,169.91 v1(184.21,169.59)
  BOTTOM w0.102: U3.A3 188.63,175.08 v1(188.63,175.08)
  BOTTOM w0.127: U34.N27 183.4,168.15 183.4,168.78 v1(184.21,169.59)
VMA_DQ59: length 21.5
  TOP w0.114: U3.C2 v1(188.6,176.68)
  IN1 w0.102: v1(188.6,176.68) 189,176.28 189,175.27 189.04,175.23 189.04,174.81
  IN1 w0.165: 189.04,174.81 189.04,174.8 189.2,174.64 190.15,174.64 190.43,174.36 190.43,171.45 190.26,171.29 189.76,171.29 189.59,171.12 189.59,170.78 189.76,170.62 190.34,170.62 190.51,170.45 190.51,169.96 190.34,169.79 189.99,169.79 189.29,169.09 186.49,169.09 185.87,168.47 184,168.47 182.99,169.47 v1(182.57,169.47)
  BOTTOM w0.102: U3.C2 v1(188.6,176.68)
  BOTTOM w0.127: v1(182.57,169.47) 182.22,169.12 182.22,168.65 U34.R27
VMA_DQ60: length 20.4
  TOP w0.102: U3.B8 v1(183.83,175.92)
  IN1 w0.102: v1(183.83,175.92) 183.46,176.29 182.59,176.29
  IN1 w0.165: v1(179.77,169.72) 179.98,169.72 180.19,169.94 180.19,170.87 180.64,171.31 180.64,173.41 180.8,173.57 181.04,173.57 181.21,173.41 181.21,172.85 181.37,172.68 181.67,172.68 181.84,172.85 181.84,173.47 182,173.63 182.39,173.63 182.56,173.47 182.56,172.99 182.71,172.84 183.05,172.84 183.2,172.99 183.2,174.49 183.03,174.66 182.58,174.66 182.41,174.49 182.41,174.42 182.25,174.26 181.92,174.26 181.75,174.42 181.75,175.31 181.92,175.47 182.17,175.47 182.34,175.64 182.34,176.08 182.55,176.29 182.59,176.29
  BOTTOM w0.102: U29.A2 184.21,175.54 v1(183.83,175.92)
  BOTTOM w0.127: v1(179.77,169.72) 178.63,168.58 178.63,167.71 179.01,167.32 U34.V26
VMA_DQ61: length 19.7
  TOP w0.102: v1(184.62,175.1) 185.01,175.49 U3.A7
  IN1 w0.165: v1(179.84,169.01) 180.56,169.72 180.56,170.66 181.01,171.11 181.01,171.47 182,172.47 185.29,172.47 185.96,173.14 185.96,174.1 185.58,174.48 184.71,174.48 184.26,174.03 184.26,173.84 184.43,173.68 185.01,173.68 185.18,173.51 185.18,173.16 185.01,173 184.03,173 183.58,173.45 183.58,174.16 184.53,175.1 v1(184.62,175.1)
  BOTTOM w0.102: v1(184.62,175.1) 185.01,175.49 U3.A7
  BOTTOM w0.127: U34.V27 179.01,168.18 v1(179.84,169.01)
VMA_DQ62: length 20.4
  TOP w0.102: U3.D7 v1(184.61,177.5)
  IN1 w0.165: v1(184.61,177.5) 185.41,177.5 185.58,177.66 185.58,178.24 185.41,178.41 185.14,178.41 184.97,178.57 184.97,179.24 184.87,179.35 184.49,179.35 184.33,179.18 184.33,178.73 184.16,178.57 183.54,178.57 183.38,178.4 183.38,178.09 183.21,177.93 182.44,177.93 181.38,176.87 181.38,176.64 180.2,175.46 180.2,175.43 180.2,174.15 179.83,173.78 179.83,172.43 179.69,172.29 179.25,172.29 179.09,172.13 179.09,170.93 179.62,170.39 v1(179.73,170.39)
  BOTTOM w0.102: U29.C3 v1(184.61,177.5)
  BOTTOM w0.127: v1(179.73,170.39) 178.21,168.87 U34.W27
VMA_DQ63: length 18.9
  TOP w0.102: U3.C8 v1(184.61,176.7)
  IN1 w0.102: v1(184.61,176.7) 184.23,177.08 183.22,177.08 183.19,177.11 182.59,177.11
  IN1 w0.165: 182.59,177.11 182.48,177.11 180.65,175.28 180.65,175.04 180.84,174.85 181.22,174.85 181.38,174.68 181.38,174.27 181.39,174.27 181.25,174.13 180.71,174.13 180.2,173.63 180.2,171.52 v1(179.74,171.06)
  BOTTOM w0.102: U3.C8 v1(184.61,176.7)
  BOTTOM w0.127: v1(179.74,171.06) 179.27,170.6 179.09,170.6 178.98,170.71 178.8,170.71 178.62,170.53 178.62,170.35 178.74,170.24 178.74,170.06 178.56,169.88 178.38,169.88 178.32,169.93 178.14,169.93 177.96,169.75 177.96,169.57 178.02,169.52 178.02,169.34 177.83,169.15 177.83,167.73 178.04,167.52 178.38,167.52 178.61,167.28 178.61,166.72 U34.W25
VMA_RDQS0: length 21.6
  TOP w0.102: U4.G3 205.27,165.36 204.94,165.03 203.78,165.03 v1(203.63,165.18)
  IN2 w0.127: v1(203.63,165.18) 203.4,164.94 202.99,164.94 202.48,164.43 202.48,163.59 201.42,162.53 199.64,162.53 199.31,162.2 198.48,162.2 197.59,163.09 196.47,163.09 196.3,163.27 193.97,163.27 193.14,162.43 191.94,162.43 191.48,161.97 190.44,161.97 189.96,161.49 189.74,161.49 v1(189.44,161.79)
  BOTTOM w0.102: v1(203.63,165.18) 203.43,164.98 202.89,164.98 202.74,165.13 202.25,165.13 202.07,165.31 U31.G3 ; U34.F19 v1(189.44,161.79)
VMA_RDQS1: length 40.9
  TOP w0.102: v1(215.6,165.17) 215.84,164.93 216.44,164.93 216.64,165.13 217.05,165.13 217.14,165.22 U5.G3
  IN2 w0.102: v1(191.82,156.83) 192,157.02 192.21,157.02 192.4,157.2 192.77,157.2 193.29,156.68 193.29,156.5 193.28,156.49 193.28,156.46
  IN2 w0.127: 193.28,156.46 193.28,155.91 194.13,155.06 195.5,155.06 196.21,154.35 197.04,154.35 197.22,154.17 210.6,154.17 211.33,154.91 211.33,155.28 210.91,155.71 210.91,155.94 211.12,156.16 211.36,156.16 211.78,155.73 212.15,155.73 216.29,159.87 216.29,160.58 216.62,160.9 216.62,161.72 216.29,162.05 216.29,163.51 216.39,163.61 216.39,164.7 216.07,165.02 215.75,165.02 v1(215.6,165.17)
  BOTTOM w0.102: v1(191.82,156.83) 191.43,157.21 U34.C14 ; v1(215.6,165.17) 215.34,164.9 214.83,164.9 214.61,165.12 214.24,165.12 U32.G3
VMA_RDQS2: length 37.9
  TOP w0.102: U5.B7 213.94,161.58 214.06,161.7 214.26,161.7 214.39,161.83 214.67,161.83 214.79,161.7 215.17,161.7 v1(215.43,161.45)
  IN1 w0.127: v1(215.43,161.45) 215.65,161.67 215.87,161.67 216.01,161.52 216.01,159.72 212.78,156.49 212.06,156.49 211.53,155.96 211.35,155.96 211.06,156.24 210.69,156.24 210.29,155.84 210.29,155.47 210.57,155.18 210.57,155 210.48,154.91 209.87,154.91 208.26,153.3 198.89,153.3 197.42,154.78 197.42,155.31 196.27,156.46 195.13,156.46 194.92,156.67 194.92,157.22 195.04,157.35 195.31,157.35 195.52,157.15 v1(195.52,156.94)
  BOTTOM w0.102: v1(195.52,156.94) 195.51,156.94 195.06,156.94 194.75,157.25 194.75,157.43 193.46,158.72 193.17,158.72 U34.A16 ; U32.B7 216.83,161.73 215.71,161.73 v1(215.43,161.45)
VMA_RDQS3: length 23.5
  TOP w0.102: v1(203.77,161.55) 203.59,161.73 202.38,161.73 U4.B7
  IN1 w0.102: 201,162.4 201.03,162.4 201.04,162.42 201.82,162.42 202.47,161.77 203.16,161.77 203.55,161.77 v1(203.77,161.55)
  IN1 w0.127: 201,162.4 199.84,162.4 199.33,162.91 198.85,162.91 198.18,163.58 198.18,166.65 198.06,166.77 196.66,166.77 196.53,166.65 196.53,166.29 196.66,166.16 196.98,166.16 197.24,165.9 197.24,165.36 196.98,165.1 195.57,165.1 195.44,164.97 195.44,164.66 195.58,164.52 v1(195.96,164.52)
  BOTTOM w0.102: U31.B7 205.27,161.62 205.19,161.7 204.97,161.7 204.91,161.64 204.3,161.64 204.19,161.75 203.97,161.75 v1(203.77,161.55)
  BOTTOM w0.114: v1(195.96,164.52) 195.85,164.64 195.57,164.64 195.41,164.48 195.41,164.05 195.02,163.66 194.05,163.66 193.75,163.96 193.17,163.96 U34.A22
VMA_RDQS4: length 21.5
  TOP w0.102: v1(186.64,179.4) 186.83,179.21 187.15,179.21 187.34,179.4 187.34,179.65 187.69,180.01 187.92,180.01 U3.G3
  IN2 w0.102: v1(186.64,179.4) 186.43,179.19 186.15,179.19 185.45,178.49 185.45,178.04 185.43,178.02 185.43,178
  IN2 w0.127: 185.43,178 185.43,177.85 185.03,177.44 185.03,177.09 185.54,176.58 185.54,176.2 185.18,175.85 185.18,175.32 185.43,175.07 185.43,174.54 185.22,174.32 184.76,174.32 183.06,172.62 183.06,167.57 182.77,167.28 182.77,167.03 182.16,166.42 182.03,166.42 181.88,166.56 v1(181.88,166.74)
  BOTTOM w0.102: U29.G3 185.01,180.22 185.28,179.95 185.42,179.95 186.2,179.17 186.4,179.17 v1(186.64,179.4)
  BOTTOM w0.114: v1(181.88,166.74) 181.92,166.74 U34.P25
VMA_RDQS5: length 26.3
  TOP w0.102: v1(174.82,180.07) 174.82,179.93 174.98,179.76 175.51,179.76 175.72,179.98 176.08,179.98 176.34,180.24 U2.G3
  IN2 w0.127: v1(174.82,180.07) 174.63,179.88 174.19,179.88 173.62,179.31 173.62,178.9 173.62,177.44 174.1,176.96 174.1,174.8 173.66,174.36 172.74,174.36 172.34,173.95 172.34,172.78 173.88,171.24 174.97,171.24 175.28,170.93 175.28,170.36 175.15,170.23 175.15,167.95 177.4,165.7 177.84,165.7 178.27,165.26 178.27,164.95 178.01,164.69 178.01,164.52 v1(177.79,164.3)
  BOTTOM w0.102: U28.G3 173.46,179.98 174.19,179.98 174.39,179.78 174.53,179.78 v1(174.82,180.07) ; U34.W22 v1(177.79,164.3)
VMA_RDQS6: length 19.9
  TOP w0.102: U2.B7 173.44,176.6 174.51,176.6 v1(174.81,176.3)
  IN1 w0.127: v1(174.21,170.46) 174.38,170.28 174.38,170.13 174.24,169.99 174.19,169.99 173.98,169.77 173.76,169.77 173.61,169.93 173.61,171.31 173.12,171.79 171.64,171.79 171.51,171.92 171.51,173.35 171.64,173.48 172.94,173.48 174.21,174.75 174.21,176.58 174.31,176.68 174.64,176.68 174.81,176.51 v1(174.81,176.3)
  BOTTOM w0.102: U28.B7 176.34,176.49 176.24,176.6 175.06,176.6 174.81,176.34 v1(174.81,176.3)
  BOTTOM w0.114: v1(174.21,170.46) 174.13,170.38 174.13,170.18 174.35,169.96 174.83,169.96 175.56,169.22 175.56,168.09 U34.AB27
VMA_RDQS7: length 21.9
  TOP w0.102: v1(186.66,176.09) 186.43,176.32 185.96,176.32 185.7,176.58 185.29,176.58 U3.B7
  IN1 w0.127: v1(181.55,169.01) 181.55,169.05 182.14,169.65 182.14,171.02 182.49,171.36 187.61,171.36 187.93,171.69 187.93,172.3 187.61,172.63 187.27,172.63 187.14,172.76 187.14,174.34 186.02,175.46 186.02,175.97 186.15,176.09 v1(186.66,176.09)
  BOTTOM w0.102: U29.B7 188.21,176.42 188.03,176.6 187.47,176.6 187.18,176.31 186.88,176.31 v1(186.66,176.09)
  BOTTOM w0.114: U34.T27 180.52,168.1 180.52,168.3 180.64,168.42 181.03,168.42 181.15,168.55 181.15,168.75 181.03,168.88 180.64,168.88 180.52,169.01 180.52,169.17 180.85,169.5 181.15,169.5 181.55,169.11 v1(181.55,169.01)
VMA_WDQS0: length 21.6
  TOP w0.102: v1(203.6,164.54) 203.89,164.83 205.06,164.83 U4.F3
  IN2 w0.127: v1(189.4,160.93) 189.73,161.26 190.06,161.26 190.54,161.74 191.58,161.74 192.04,162.2 193.23,162.2 194.07,163.04 196.2,163.04 196.38,162.86 197.5,162.86 198.39,161.97 199.4,161.97 199.73,162.3 201.51,162.3 202.7,163.5 202.7,164.33 203.09,164.71 203.43,164.71 v1(203.6,164.54)
  BOTTOM w0.102: U34.E19 189.42,160.93 v1(189.4,160.93) ; v1(203.6,164.54) 203.37,164.77 202.8,164.77 202.65,164.93 202.25,164.93 202.07,164.75 U31.F3
VMA_WDQS1: length 41
  TOP w0.102: U5.F3 217.14,164.79 217,164.93 216.72,164.93 216.52,164.72 215.91,164.72 v1(215.61,164.42)
  IN2 w0.102: v1(191.84,157.65) 191.73,157.54 191.73,157.32 191.82,157.24 191.98,157.24 192,157.22 192.13,157.22 192.31,157.41 192.86,157.41 193.5,156.77 193.5,156.5 193.51,156.49 193.51,156.46
  IN2 w0.127: v1(215.61,164.42) 215.61,164.59 215.81,164.79 215.98,164.79 216.16,164.6 216.16,163.7 216.07,163.6 216.07,161.95 216.4,161.62 216.4,161 216.07,160.67 216.07,159.97 212.06,155.96 211.88,155.96 211.45,156.38 211.03,156.38 210.68,156.03 210.68,155.61 211.11,155.19 211.11,155.01 210.5,154.4 197.31,154.4 197.14,154.58 196.31,154.58 195.59,155.29 194.22,155.29 193.51,156 193.51,156.46
  BOTTOM w0.102: v1(215.61,164.42) 215.33,164.7 214.74,164.7 214.52,164.92 214.24,164.92 U32.F3 ; U34.C15 191.43,157.7 191.59,157.55 191.74,157.55 v1(191.84,157.65)
VMA_WDQS2: length 37.9
  TOP w0.102: U5.C7 213.94,162.02 214.06,161.9 214.18,161.9 214.3,162.03 214.75,162.03 214.88,161.9 215.23,161.9 v1(215.43,162.11)
  IN1 w0.127: v1(215.43,162.11) 215.64,161.9 215.96,161.9 216.24,161.62 216.24,159.63 212.87,156.26 212.15,156.26 211.62,155.73 211.25,155.73 210.97,156.01 210.79,156.01 210.52,155.74 210.52,155.56 210.8,155.28 210.8,154.91 210.58,154.68 209.96,154.68 208.36,153.08 198.8,153.08 197.19,154.68 197.19,155.22 196.18,156.23 195.03,156.23 194.69,156.58 194.69,156.75 194.5,156.94 v1(194.47,156.94)
  BOTTOM w0.102: U34.B16 192.55,158.86 192.89,158.52 193.38,158.52 194.55,157.35 194.55,157.02 v1(194.47,156.94) ; U32.C7 216.85,161.93 215.61,161.93 v1(215.43,162.11)
VMA_WDQS3: length 23.5
  TOP w0.102: v1(203.77,162.18) 203.52,161.93 202.36,161.93 U4.C7
  IN1 w0.102: v1(203.77,162.18) 203.56,161.97 202.55,161.97 201.9,162.62 201.04,162.62 201.03,162.63 201,162.63
  IN1 w0.127: 201,162.63 199.94,162.63 199.43,163.14 198.95,163.14 198.41,163.67 198.41,166.74 198.15,167 196.56,167 196.3,166.74 196.3,166.19 196.56,165.93 196.89,165.93 197.02,165.81 197.02,165.45 196.89,165.32 195.47,165.32 195.21,165.06 195.21,164.77 v1(195,164.55)
  BOTTOM w0.102: U31.C7 205.27,162.06 205.12,161.9 204.88,161.9 204.82,161.84 204.39,161.84 204.28,161.96 204,161.96 v1(203.77,162.18)
  BOTTOM w0.114: v1(195,164.55) 195.19,164.35 195.19,164.14 194.93,163.88 194.14,163.88 193.84,164.17 192.89,164.17 192.54,163.82 U34.B22
VMA_WDQS4: length 21.5
  TOP w0.102: v1(186.67,178.75) 186.92,179.01 187.23,179.01 187.54,179.32 187.54,179.57 187.78,179.8 187.91,179.8 U3.F3
  IN2 w0.102: 185.66,178 185.66,178.02 185.65,178.04 185.65,178.41 186.23,178.99 186.44,178.99 v1(186.67,178.75)
  IN2 w0.127: v1(181.91,165.92) 181.91,165.99 182.11,166.19 182.25,166.19 182.99,166.93 182.99,167.19 183.29,167.48 183.29,172.52 184.85,174.09 185.31,174.09 185.66,174.44 185.66,175.16 185.41,175.41 185.41,175.76 185.77,176.11 185.77,176.67 185.26,177.18 185.26,177.35 185.66,177.75 185.66,178
  BOTTOM w0.102: U29.F3 185.01,179.61 185.15,179.75 185.33,179.75 186.12,178.96 186.46,178.96 v1(186.67,178.75)
  BOTTOM w0.114: U34.R25 181.59,166.32 181.91,166 v1(181.91,165.92)
VMA_WDQS5: length 26.3
  TOP w0.102: U2.F3 176.34,179.63 176.2,179.77 175.81,179.77 175.6,179.56 174.98,179.56 174.82,179.4 v1(174.82,179.27)
  IN2 w0.127: v1(174.82,179.27) 174.82,179.27 174.82,179.45 174.61,179.65 174.28,179.65 173.85,179.22 173.85,177.54 174.33,177.05 174.33,174.71 173.75,174.13 172.84,174.13 172.57,173.86 172.57,172.87 173.97,171.46 175.07,171.46 175.51,171.02 175.51,170.26 175.37,170.13 175.37,168.04 177.49,165.92 177.93,165.92 178.5,165.35 178.5,164.86 178.24,164.6 178.24,164.44 178.4,164.28 v1(178.6,164.28)
  BOTTOM w0.102: v1(178.6,164.28) 178.6,164.34 U34.W23 ; v1(174.82,179.27) 174.51,179.57 174.31,179.57 174.1,179.78 173.42,179.78 U28.F3
VMA_WDQS6: length 19.9
  TOP w0.102: U2.C7 173.44,176.8 174.51,176.8 v1(174.81,177.1)
  IN1 w0.127: v1(174.81,177.1) 174.62,176.91 174.21,176.91 173.98,176.67 173.98,174.84 172.84,173.71 171.55,173.71 171.28,173.45 171.28,171.83 171.55,171.57 173.03,171.57 173.38,171.22 173.38,170.08 173.38,169.83 173.68,169.53 v1(174.37,169.53)
  BOTTOM w0.102: v1(174.81,177.1) 174.81,177.04 175.05,176.8 176.24,176.8 176.34,176.9 U28.C7
  BOTTOM w0.114: v1(174.37,169.53) 174.59,169.74 174.74,169.74 175.35,169.13 175.35,167.66 175.73,167.28 U34.AB26
VMA_WDQS7: length 21.9
  TOP w0.102: U3.C7 185.33,176.78 185.79,176.78 186.04,176.53 186.46,176.53 v1(186.66,176.73)
  IN1 w0.127: v1(181.53,169.72) 181.58,169.67 181.84,169.67 181.92,169.74 181.92,171.11 182.39,171.59 187.51,171.59 187.71,171.79 187.71,172.21 187.51,172.4 187.17,172.4 186.91,172.66 186.91,174.25 185.79,175.37 185.79,176.06 186.05,176.32 186.26,176.32 v1(186.66,176.73)
  BOTTOM w0.102: v1(186.66,176.73) 186.88,176.51 187.1,176.51 187.38,176.8 188.04,176.8 188.21,176.97 U29.C7
  BOTTOM w0.114: v1(181.53,169.72) 180.76,169.72 180.3,169.26 180.3,167.82 180.69,167.43 U34.T26
VR_SVID_ALERT#_VCORE: length 120.4
  TOP w0.203: PU1.36 152.77,181.88 152.84,181.96 153.5,181.96 154.01,181.45 155.31,181.45 v1(155.37,181.39)
  BOTTOM w0.114: R134.2 R552.2 113.75,139.86 116.1,142.21 116.1,144.91 115.44,145.57 115.44,178.94 114.03,180.34 114.03,184.99 120.69,191.65 121.41,191.65 124.58,194.81 127.55,194.81 134.77,202.04 143.36,202.04 143.81,202.5 146.23,202.5 146.94,201.79 148.2,201.79 149.4,200.59 149.4,197.69 151.66,195.43 151.66,193.53 157.28,187.91 157.28,185.05 157.99,184.34 157.99,182.33 157.05,181.39 v1(155.37,181.39)
VREFC_VMA1: length 55.9
  TOP w0.356: v1(212.74,169.78) 213.09,169.42 U5.M8 ; U4.M8 200.92,169.07 200.9,169.07 v1(200.87,169.04)
  IN1 w0.508: v1(218.78,174.11) 218.78,173.49 217.31,172.01 217.31,170.64
  IN2 w0.102: 200.87,169.27 v1(200.87,169.04)
  IN2 w0.508: v1(218.78,174.11) 217.31,175.59 217.31,176.96 212.44,181.83 206.18,181.83 204.81,180.46 v1(204.81,179.58) 204.74,179.51 202.85,179.51 202.28,178.94 202.01,178.94 201.64,178.57 201.64,176.48 200.47,175.31 200.47,174.26 201.26,173.48 201.26,171.75 200.87,171.37 200.87,169.27
  BOTTOM w0.229: 207.1,176.38 207.35,176.13 207.35,174.15 208.61,172.89 208.61,172.07 207.16,170.61 206.71,170.61 206.48,170.38 206.48,169.83 U31.M8
  BOTTOM w0.356: v1(218.34,169.82) 217.94,169.42 U32.M8
  BOTTOM w0.508: 207.1,176.38 v3(205.73,177.75) 204.61,177.75 R469.2 203.96,178.46 C590.2 ; v1(204.81,179.58) 204.74,179.65 C590.2 ; C590.2 203.96,180.17 R466.1
VREFC_VMA3: length 61
  TOP w0.203: U3.M8 184.42,184.3 184.83,184.72 185.58,184.72 185.76,184.9 186.97,184.9 v1(187.04,184.83) ; v1(174.1,185.09) 173.67,185.09 173.3,184.72 173.28,184.72 173.24,184.68 172.96,184.68 172.58,184.3 U2.M8 171.93,183.89 171.12,183.89 170.89,183.66
  TOP w0.508: R33.1 C37.2 R34.2 170.25,183.88 170.47,183.66 170.89,183.66
  IN2 w0.508: v1(187.04,184.83) 187.04,184.35 187.06,184.32 187.06,184.27 187.42,183.92 187.92,183.92 188.07,184.06 191.07,184.06 191.5,184.49 191.5,189.99 187.62,193.87 186.83,193.87 185.88,194.83 181.83,194.83 181.64,195.02 177.94,195.02 177.28,195.68 176.01,195.68 171.84,191.51 171.84,188.51 172.33,188.03 172.33,185.8 172.96,185.16 174.03,185.16 v1(174.1,185.09)
  BOTTOM w0.203: v1(187.04,184.83) 187.04,184.46 187.48,184.02 187.95,184.02 188.05,183.92 188.37,183.92 188.75,184.3 U29.M8 ; v1(174.1,185.09) 174.16,185.03 174.54,185.03 174.55,185.02 174.73,185.02 174.97,185.26 175.67,185.26 175.93,185 175.93,184.93 176.19,184.68 176.76,184.68 U28.M8
VREFD_VMA1: length 59.5
  TOP w0.356: 207.05,157.16 207.05,159.2 207.88,160.04 207.88,165.84 ; 207.05,157.16 206.46,157.16 206.34,157.28 206.34,158.87 206.18,159.03 200.29,159.03 199.12,160.2 199.12,166.14 199.61,166.63 199.88,166.63 v1(199.96,166.71) ; 207.05,157.16 R77.2 ; U5.H1 v1(219.42,166.22) 220.13,166.22 220.85,165.5 220.85,156.88 v3(220.51,156.54) 219.93,155.95 C115.2 R76.1 ; 207.88,165.84 v1(207.94,165.9) ; 207.88,165.84 207.43,165.84 207.06,166.22 U4.H1
  IN1 w0.356: v1(219.42,166.22) 219.42,166.22 219.42,167.57 218.53,168.46 215.96,168.46 215.53,168.89 215.5,168.89 215.48,168.91 215.3,168.91 214.94,169.28 214.16,169.28 213.86,168.98 211.92,168.98 210.75,167.81 v1(210.75,167.06) 210.19,167.06 209.38,166.25 208.29,166.25 v1(207.94,165.9)
  BOTTOM w0.356: v1(199.96,166.71) 199.98,166.71 200.47,166.22 U31.H1 ; v1(210.75,167.06) 211.18,167.06 211.69,166.55 211.96,166.55 212.3,166.22 U32.H1
VREFD_VMA3: length 59.4
  TOP w0.33: v1(178.4,180.67) 177.97,181.1 U2.H1
  TOP w0.356: v1(190.26,180.73) 190.03,180.96 189.99,180.96 189.86,181.1 U3.H1
  IN1 w0.508: v1(178.4,180.67) 178.4,179.95 179.95,178.41 180.4,178.41 v1(180.51,178.3)
  IN2 w0.508: v1(180.51,178.3) 180.84,178.3 181.83,179.29 181.83,179.65 182.87,180.69 v1(183.02,180.69) ; v1(168.14,171.24) 168.19,171.29 168.19,179.53 168.86,180.21 v1(168.87,180.21)
  BOTTOM w0.33: U29.H1 183.41,181.08 v1(183.02,180.69)
  BOTTOM w0.356: 186.91,173.73 187.67,174.49 189.61,174.49 190.85,175.74 190.85,180.14 v1(190.26,180.73) ; U28.H1 171.26,181.38 170.93,181.38
  BOTTOM w0.508: v1(180.51,178.3) 180.63,178.18 180.63,172.27 C599.2 ; v1(168.87,180.21) 168.48,180.6 R467.2 168.49,180.98 169.26,180.98 169.66,181.38 170.93,181.38 ; 186.91,173.73 186.65,173.48 184.62,173.48 183.36,172.22 v3(182.31,172.22) C599.2 ; C599.2 180.48,172.22 180.27,172.42 180.26,172.42 180.1,172.59 179.54,172.59 178.65,171.7 171.14,171.7 170.98,171.54 R472.1 169.01,171.24 v1(168.14,171.24)
VRON: length 467.6
  TOP w0.114: PR136.1 58.32,86.55 58.32,80.2 60.21,78.31 83.58,78.31 84.5,79.23 84.5,80.39 85.01,80.89 86.03,80.89 86.49,80.44 86.49,77.19 86.7,76.98 86.7,69.01 85.28,67.59 85.28,51.08 98.64,37.71 110.45,37.71 v1(110.96,38.22) ; R792.1 51.53,12.81 51.74,12.6 U50.4 53.09,12.6 53.25,12.44 v1(53.25,11.27)
  TOP w0.203: PR196.2 157.32,185.16 v1(156.17,185.16) PR28.2
  IN1 w0.127: v1(202.68,37.63) 202.12,38.19 202.12,48.74 202.88,49.5 202.88,51.22 201.89,52.21 198.92,52.21 197.62,53.51 197.17,53.51 196.94,53.74 196.94,54.49 197.56,55.11 197.56,57.65 198.2,58.29 198.2,60.83 200.24,62.87 200.24,68.51 200.05,68.7 200.05,77.68 195.95,81.78 194.45,81.78 188.93,87.3 188.93,91.31 187.68,92.55 187.68,103.74 188.94,105 189.95,105 190.16,105.2 190.16,105.79 189.42,106.52 189.42,109.85 187.31,111.96 186.48,111.96 183.63,114.81 183.63,114.86 182.44,116.05 182.44,122.9 181.19,124.15 181.19,124.48 180.53,125.14 180.53,127.08 181.51,128.06 181.51,131.89 179.52,133.88 178.93,133.88 178.6,134.21 178.37,134.21 178.21,134.37 170.31,134.37 169.91,133.98 169.64,133.98 169.32,134.3 169.32,136.01 168.67,136.66 167.49,136.66 167.02,137.13 166.18,137.13 165.81,137.5 164.24,137.5 163.84,137.89 163.84,142.93 162.26,144.52 162.26,148.42 162.84,149 162.84,150.69 165.42,153.27 165.42,157.41 164.55,158.28 164.55,169.37 163.54,170.39 163.54,176.16 164.39,177.02 164.39,180.42 161.81,183 161.38,183 159.22,185.16 v1(156.17,185.16) ; v1(194.91,33.78) 194.91,31.64 194.5,31.24 181.14,31.24 176.57,35.81 170.22,35.81 167.81,38.22 v1(110.96,38.22)
  BOTTOM w0.114: v1(194.91,33.78) 196.07,34.94 197.33,34.94 197.59,34.68 198.51,34.68 201.26,37.43 202.48,37.43 v1(202.68,37.63) ; v1(53.25,11.27) 54.44,12.47 80.53,12.47 85.56,17.5 85.56,19.81 86.45,20.7 86.45,21.64 89.39,24.58 90.31,25.5 99.76,25.5 107.66,33.4 107.66,34.92 v1(110.96,38.22)
VRON_EC: length 169.8
  TOP w0.114: U50.1 v1(49.62,13.9) 49.62,14.73 50,15.11 R792.2 ; R463.1 195.4,35.68 194.33,34.61 194.33,34.6 193.43,33.7 v1(193.43,33.52)
  IN1 w0.127: v1(110.32,38.22) 110.86,38.76 156.48,38.76 156.65,38.58 167.86,38.58 170.35,36.09 176.65,36.09 181.25,31.49 191.41,31.49 v1(193.43,33.52)
  BOTTOM w0.114: v1(193.43,33.52) 193.03,33.11 U45.69 ; v1(49.62,13.9) 50.83,12.7 80.44,12.7 85.33,17.59 85.33,19.9 86.22,20.79 86.22,21.73 90.22,25.73 99.61,25.73 107.39,33.51 107.39,35.03 110.32,37.97 v1(110.32,38.22)
VSA_SENSE: length 75.2
  TOP w0.114: PR50.1 153.45,173.55 155.18,173.55 v3(156.53,172.21) 157.77,170.96 163.46,170.96 164.27,170.15 164.27,167.28 163.41,166.42 163.41,162.43 161.29,160.31 161.29,152.93 160.17,151.81 158.52,151.81 156.88,150.17 156.88,148.13 157.1,147.91 157.1,142.06 155.41,140.38 153.54,140.38 R122.2 152.65,139.49 150.28,139.49 149.21,138.42 149.21,137.52 144.72,133.03 144.11,133.03 142.83,131.75 142.83,131.23 143.25,130.81 143.25,129.25 144.11,128.39 144.11,126.86 143.63,126.39 v2(143.63,125.74)
  BOTTOM w0.114: v2(143.63,125.74) 143.69,125.68 144.24,125.68 144.49,125.93 145.58,125.93 U35.H20
VSASS_SENSE: length 72
  TOP w0.114: PR52.1 154.44,169.92 v3(155.26,170.73) 163.37,170.73 164.05,170.06 164.05,167.38 163.18,166.51 163.18,162.52 161.06,160.4 161.06,153.02 160.07,152.03 158.42,152.03 156.65,150.26 156.65,148.04 156.87,147.82 156.87,142.16 155.32,140.6 152.26,140.6 R109.1 151.38,139.72 150.19,139.72 148.96,138.49 148.96,137.59 144.63,133.26 144.01,133.26 142.6,131.85 142.6,131.13 143.02,130.71 143.02,129.15 143.78,128.4 143.78,128.01 143.19,127.43 143.19,125.57 143.44,125.33 143.8,125.33 144.04,125.57 144.04,126.07 v2(144.59,126.61)
  BOTTOM w0.114: U35.H21 144.66,126.61 v2(144.59,126.61)
VSYNC: length 4
  TOP w0.114: U13.1 18.66,110.38 v1(18.25,110.79)
  BOTTOM w0.114: U37.2 16.22,110.84 16.42,111.04 18,111.04 v1(18.25,110.79)
WIFI_SUSCLK: length 21.9
  TOP w0.114: v1(190.72,94.53) v1(190.72,98.04)
  BOTTOM w0.114: U43.4 195.2,85.1 195.36,85.26 195.36,85.59 195.19,85.77 194.75,85.77 194.66,85.86 R714.1 195.9,87.46 195.9,91.46 v3(195.37,91.99) 192.75,94.61 190.79,94.61 v1(190.72,94.53) ; CN10.50 189.15,96.48 v1(190.72,98.04)
WLAN_CLKREQ#: length 15.1
  TOP w0.114: R253.2 185.64,92.71 186.14,92.2 187.03,92.2 187.16,92.32 v3(187.16,92.96) 187.02,93.1 R245.1 186.85,94.28 186.27,94.28 185.62,94.93 Q23.4 185.25,95.62 185,95.37 v1(185,95.12)
  BOTTOM w0.114: v1(185,95.12) 185.38,95.5 185.38,96.77 185,97.15 183.1,97.15 181.67,95.72 CN10.53
WLAN_RST#: length 5.3
  BOTTOM w0.114: R671.2 R680.2 190.59,97.15 v1(190.49,97.05) 189.41,95.97 CN10.52
WLAN_WAKE_R#: length 10.1
  TOP w0.114: R242.1 R243.2 184.5,96.02 184.87,96.39 v1(184.87,96.52) 185.15,96.52 185.41,96.77 186.78,96.77 186.92,96.91 Q23.1
  BOTTOM w0.114: CN10.55 180.89,95.23 181.14,95.47 181.93,95.47 182.97,96.52 v1(184.87,96.52)
WRST#: length 70.4
  TOP w0.114: v1(206.57,38.32) 206.77,38.53 206.77,39.32 C491.1 205.68,39.76 R368.1 205.13,39.92 204.51,39.92 203.62,40.81 202.51,40.81 201.06,39.37 D12.2
  IN1 w0.127: v1(213.83,76.2) 213.83,75.18 216.95,72.06 216.95,67.89 220.94,63.9 220.94,51.43 219.54,50.03 219.54,48 219.88,47.67 219.88,44.01 217.26,41.4 v1(217.26,34.92)
  IN2 w0.127: v1(217.26,34.92) 217.26,35.23 213.98,38.5 206.74,38.5 v1(206.57,38.32)
  BOTTOM w0.114: Q56.6 213.94,75.58 213.83,75.69 v1(213.83,76.2) ; v1(206.57,38.32) 206.96,38.71 U45.14
XCLK_BIASREF: length 20.8
  TOP w0.114: R768.1 125.84,140.14 v1(126.1,139.87) 126.1,139.39 v1(126.45,139.04)
  IN1 w0.127: v1(126.45,139.04) 125.96,138.54 125.96,136.89 127.17,135.68 129.96,135.68 130.39,135.25 130.39,133.35 131.08,132.66 132.68,132.66 v1(132.75,132.74)
  BOTTOM w0.114: v1(126.45,139.04) 125.82,139.67 R512.1 ; v1(132.75,132.74) 133.79,131.69 133.79,129.51 133.59,129.31 133.33,129.31 133.14,129.12 133.14,128.42 133.12,128.39 U35.E42
XD_CD#: length 40.1
  TOP w0.114: U26.7 55.1,24.23 54.37,24.96 54.01,24.96 52.03,22.98 52.03,22.61 51.92,22.5 49.58,22.5 49.47,22.39 49.47,22.16 49.58,22.04 51.92,22.04 52.03,21.93 52.03,21.7 51.92,21.59 49.58,21.59 49.47,21.47 49.47,21.24 49.58,21.13 51.92,21.13 52.03,21.01 52.03,20.79 51.92,20.67 49.58,20.67 49.47,20.56 49.47,20.33 49.58,20.21 51.92,20.21 52.03,20.1 52.03,19.87 51.92,19.76 49.58,19.76 49.47,19.64 49.47,19.41 49.58,19.3 51.92,19.3 52.03,19.19 52.03,18.96 51.92,18.84 49.58,18.84 49.47,18.73 49.47,18.5 49.58,18.39 51.92,18.39 52.03,18.27 52.03,18.04 51.92,17.93 49.58,17.93 49.47,17.81 49.47,17.59 49.58,17.47 51.92,17.47 52.03,17.36 TP43.1
XD_D7: length 2
  TOP w0.114: U26.23 61.8,23.73 TP35.1
XDP_BPM#0: length 7.9
  BOTTOM w0.076: 125.06,133.35 125.06,132.74 125.21,132.59 125.21,131.29 125.36,131.15 125.36,130.08 U35.C55
  BOTTOM w0.114: TP89.1 126.58,136.52 125.06,135 125.06,133.35
XDP_BPM#1: length 10.1
  BOTTOM w0.076: 125.34,133.22 125.34,132.7 125.37,132.66 125.37,131.36 125.52,131.21 125.52,130.34 125.76,130.11 125.76,129.83 125.46,129.54 U35.D55
  BOTTOM w0.114: 125.34,133.22 125.34,134.68 127.09,136.44 127.09,138.25 TP90.1
XDP_BPM#2: length 5.1
  BOTTOM w0.076: 125.82,133.36 125.82,133.09 125.54,132.81 125.54,131.43 125.69,131.28 125.69,130.68 126.03,130.34 U35.B54
  BOTTOM w0.114: 125.82,133.36 125.82,134.41 TP64.1
XDP_BPM#3: length 7
  BOTTOM w0.076: U35.C56 124.9,129.82 124.49,130.23 124.49,130.73 124.47,130.8 124.47,131.46 124.55,131.55 124.55,132.32 124.09,132.77 124.09,133.98
  BOTTOM w0.114: TP62.1 124.09,135.99 124.09,133.98
XDP_PRDY#: length 7.9
  BOTTOM w0.076: U35.D56 125.06,129.15 125.06,129.38 125.22,129.54 125.22,129.74 125.16,129.79 125.16,130.17 125.19,130.2 125.19,131.08 125.04,131.22 125.04,132.52 124.78,132.79 124.78,133.65
  BOTTOM w0.114: TP91.1 125.54,136.07 124.82,135.35 124.82,134.33 124.78,134.29 124.78,133.65
XDP_PREQ#: length 10
  BOTTOM w0.076: U35.D61 122.13,129.29 122.13,129.62 122.06,129.69 122.06,130.42 122.01,130.47 122.01,130.75 122,130.79 121.98,130.8 121.98,131.52 122.22,131.75 122.22,132.35 121.97,132.6 121.95,132.6 121.81,132.74 121.25,132.74 120.31,133.68 120.31,133.98
  BOTTOM w0.114: TP92.1 119.11,135.76 119.91,134.97 119.91,134.86 120.31,134.46 120.31,133.98
XDP_TCK0: length 16.7
  BOTTOM w0.076: 121.11,133.98 121.4,133.98 121.92,133.46 121.92,132.94 122.38,132.48 122.38,131.43 122.15,131.2 122.15,130.85 122.18,130.78 122.18,130.54 U35.B61
  BOTTOM w0.114: R517.2 121.07,139.31 119.31,141.07 118.32,141.07 v3(118.3,141.09) 118.2,140.99 118.2,140.28 118.82,139.66 118.82,139.66 119.01,139.47 119.01,138.55 119.67,137.89 119.67,136.77 119.42,136.52 119.42,136.17 119.86,135.74 119.86,135.58 120.31,135.13 120.31,134.78 R558.2 121.11,133.98
XDP_TCK1: length 11.5
  BOTTOM w0.076: U35.B56 124.66,130.54 124.66,130.78 124.63,130.85 124.63,131.4 124.71,131.48 124.71,132.38 124.32,132.78 124.32,133.98
  BOTTOM w0.114: v1(124.9,139.85) 124.32,139.26 124.22,139.26 124.04,139.09 124.04,137.78 R537.2 123.98,136.83 124.43,136.83 124.78,136.48 124.78,135.96 124.32,135.51 124.32,133.98
XDP_TDI: length 15.2
  BOTTOM w0.076: 123.86,133.35 123.86,132.69 123.76,132.58 123.76,131.47 124,131.23 124,130.87 123.94,130.7 123.94,130.56 124,130.33 124,130.2 123.92,130.02 123.92,129.59 123.55,129.21 U35.D59
  BOTTOM w0.114: R796.1 123.71,141.74 123.94,141.51 v1(123.94,141.45) 123.94,141.22 123.53,140.81 123.53,140.2 R515.2 123.72,139.37 123.38,139.37 123.02,139.01 123.02,136.57 123.86,135.73 123.86,133.35
XDP_TDI_CPU: length 15.6
  IN1 w0.127: v1(122.44,142.95) 121.65,142.16 121.65,134.87 v1(122.64,133.88)
  BOTTOM w0.076: U35.D60 122.99,129.5 123.28,129.79 123.28,130.17 123.05,130.4 123.05,133.47 v1(122.64,133.88)
  BOTTOM w0.114: R796.2 122.72,142.52 122.44,142.79 v1(122.44,142.95)
XDP_TDO: length 4
  BOTTOM w0.114: R795.1 124.8,141.42 125.34,140.88 125.34,138.91 125.56,138.68 R539.2
XDP_TDO_CPU: length 19.1
  IN1 w0.127: v1(118.68,140.4) 118.68,140.69 121.39,143.39 122.89,143.39 123.34,142.93 v1(124.09,142.93)
  BOTTOM w0.076: U35.A61 122.55,131.07 122.55,132.55 122.09,133.01 122.09,133.53 121.81,133.81 121.81,133.98
  BOTTOM w0.114: v1(124.09,142.93) 124.09,142.77 124.35,142.52 R795.2 ; v1(118.68,140.4) 118.77,140.4 119.83,139.34 119.83,138.34 v1(119.85,138.32) 120.23,137.94 120.23,137.16 120.82,136.57 120.82,135.91 121.2,135.53 121.2,134.91 R559.2 121.75,134.03 121.81,133.98
XDP_TMS: length 14.3
  BOTTOM w0.076: 123.63,133.09 123.63,132.75 123.58,132.7 123.58,131.39 123.83,131.14 123.83,130.9 123.77,130.73 123.77,130.54 123.84,130.31 123.84,130.23 123.76,130.06 123.76,129.85 U35.C59
  BOTTOM w0.114: 123.63,133.09 123.63,135.63 122.77,136.5 122.77,139.08 123.02,139.33 R514.2 122.27,139.69 121.94,140.02 121.94,140.66 122.09,140.81 v3(122.09,141.27) 121.41,141.27 R797.1
XDP_TMS_CPU: length 13.9
  IN1 w0.127: v1(122.64,133.24) 121.37,134.51 121.37,140.96 v1(120.48,141.85)
  BOTTOM w0.076: U35.C60 122.88,130.08 122.88,132.28 122.88,133.09 122.72,133.24 v1(122.64,133.24)
  BOTTOM w0.114: R797.2 121.17,142.31 120.71,141.85 v1(120.48,141.85)
XDP_TRST#: length 13.1
  BOTTOM w0.076: U35.B59 123.55,130.5 123.23,130.82 123.23,133.68 123.18,133.73 123.18,133.98
  BOTTOM w0.114: 123.18,133.98 123.18,135.44 122.35,136.27 R549.2 122.02,137.14 R535.2 122.18,137.83 122.18,138.43 121.73,138.88 120.81,138.88 120.7,138.99 120.7,139.36 119.94,140.12 119.65,140.12 v1(119.39,140.38)
XTAL1: length 7.1
  TOP w0.114: U15.28 36.1,91.94 36.23,92.07 C359.1 35.65,92.82 35.65,94.1 36.63,95.08 Y1.3
XTAL2: length 4.8
  TOP w0.114: U15.29 35.7,90.87 v1(35.65,90.92) 35.7,90.98 35.7,91.76 35.39,92.07 C358.1 35.15,92.91 Y1.1
XTAL24_IN: length 15.6
  IN2 w0.127: v5(135.74,137.38) 136.02,137.66 136.11,137.66 136.61,137.16 136.61,135.58 135.27,134.23 135.27,129.99 135.75,129.51 135.75,128.89 v2(135.43,128.57)
  BOTTOM w0.114: v5(135.74,137.38) 135.46,137.66 134.72,137.66 R536.1 133.95,137.4 133.8,137.55 C665.2 132.93,137.55 132.71,137.32 Y4.3 ; U35.E37 135.51,128.57 v2(135.43,128.57)
XTAL24_OUT: length 19.6
  IN2 w0.127: v1(135.74,138.19) 136.01,137.92 136.21,137.92 136.87,137.26 136.87,135.47 135.52,134.12 135.52,130.1 136,129.62 136,128.82 v2(136.26,128.57)
  BOTTOM w0.114: v2(136.26,128.57) 136.43,128.57 U35.E35 ; Y4.1 130.37,139.85 132.55,139.85 132.63,139.77 132.63,138.98 132.81,138.8 C658.2 134.06,138.18 R536.2 134.73,137.91 135.46,137.91 v1(135.74,138.19)
XTAL_SSIN: length 16.4
  BOTTOM w0.114: U34.A10 193.03,153.72 193.46,153.3 193.46,152.97 194.88,151.55 194.88,150.48 196.53,148.83 196.53,142.95 v1(196.87,142.61) 197.22,142.26 197.22,140.01 R524.1
N59981: length 15.5
  IN1 w0.076: 155.92,125.62 155.73,125.42 155.73,125.11 155.2,124.58 v2(154.4,124.58)
  IN1 w0.127: 155.92,125.62 156.8,126.5 160.65,126.5 163.56,129.41 164.68,129.41 v1(165.19,129.92)
  BOTTOM w0.076: v2(154.4,124.58) 154.08,124.91 U35.L6
  BOTTOM w0.114: v1(165.19,129.92) v1(165.82,129.92) 166.38,129.92 166.51,129.79 R567.2
N59985: length 18.9
  IN1 w0.076: 155.92,125.07 155.27,124.42 154.91,124.42 154.69,124.19 152.87,124.19 152.75,124.07 152.46,124.07 v2(151.85,123.47)
  IN1 w0.127: 155.92,125.07 155.99,125.14 155.99,125.33 156.91,126.25 160.75,126.25 162.9,128.39 165.87,128.39 166.33,128.85 v1(166.33,129.38)
  BOTTOM w0.114: v2(151.85,123.47) 151.85,123.75 U35.N9 ; R571.2 166.35,129.38 v1(166.33,129.38)
N62917: length 8.8
  TOP w0.114: R158.2 111.72,127 v1(111.72,127.25)
  IN1 w0.127: v2(118.74,126.64) 118.56,126.82 115.99,126.82 115.73,127.07 114.95,127.07 114.94,127.07 112.81,127.07 112.54,126.81 112.17,126.81 v1(111.72,127.25)
  BOTTOM w0.254: U35.H66 119.05,126.33 v2(118.74,126.64)
N62945: length 9
  TOP w0.114: v1(112.36,127.25) 112.36,127.64 R162.2
  IN1 w0.127: v1(112.36,127.25) 112.43,127.33 115.84,127.33 116.09,127.07 119.23,127.07 119.26,127.05 v2(119.66,126.65)
  BOTTOM w0.254: v2(119.66,126.65) 119.85,126.65 U35.H65
N62977: length 24
  IN1 w0.132: v1(166.81,104.39) 165.68,104.39 164.75,105.33 161.29,105.33 160.99,105.03 158.18,105.03 157.89,105.33 156.91,105.33 154.94,107.3 152.63,107.3 149.25,110.67 148.91,110.67 148.66,110.92 148.66,111.39 148.3,111.76 v2(148.21,111.76)
  BOTTOM w0.114: R635.2 167.34,104.91 v1(166.81,104.39) ; U35.AT16 147.88,112.08 v2(148.21,111.76)
N62981: length 23.8
  IN1 w0.132: v5(167.25,103.75) 165.95,103.75 164.64,105.07 161.4,105.07 161.1,104.77 158.08,104.77 157.88,104.96 156.89,104.96 154.82,107.04 152.51,107.04 149.13,110.42 148.69,110.42 148.21,110.9 v2(148.21,111.11)
  BOTTOM w0.114: R646.2 167.51,103.49 v5(167.25,103.75)
  BOTTOM w0.127: U35.AU16 v2(148.21,111.11)
N74227: length 6.5
  TOP w0.114: R174.2 157.34,122.04 156.1,120.8 153.58,120.8 v1(153.45,120.93) 153.12,120.6 v2(153.12,120.37)
  BOTTOM w0.127: U35.AB7 153.12,120.07 v2(153.12,120.37)
N108264: length 12.3
  BOTTOM w0.076: 159.73,107.82 159.42,107.51 155.6,107.51 155.14,107.97 154.75,107.97 154.65,108.07 154.65,108.4 154.39,108.66 154.14,108.66 153.81,108.33 153.53,108.33 153.23,108.63 152.95,108.63 152.79,108.78 152.79,109.42 152.62,109.6 152.36,109.6 151.91,110.05 U35.AW9
  BOTTOM w0.114: 159.73,107.82 159.88,107.97 160.41,107.97 v1(160.62,108.17) 161.09,108.17 R623.2
N108478: length 135.7
  TOP w0.114: v1(159.35,106.27) 159.35,106.17 159.77,105.75 164.2,105.75 166.2,103.75 166.2,103.51 166.62,103.09 166.62,100.26 166.41,100.05 166.41,96.3 C806.1 166.51,95.72 166.51,94.41 166.44,94.34 166.44,93.58 166.89,93.13 167.68,93.13 169.63,91.17 169.63,89.47 168.69,88.53 167.56,88.53 166.97,87.94 166.97,78.35 169.22,76.1 171.22,76.1 172.23,75.09 174.46,75.09 174.99,74.56 177.79,74.56 179.35,73 182.16,73 183.89,71.27 183.89,66.14 184.84,65.19 185.12,65.19 191.49,58.82 191.49,46.76 192.27,45.98 192.27,45.75 192.68,45.34 192.68,44.33 193.28,43.73 194.48,43.73 195.94,45.19 198.74,45.19 199.45,45.89 203.81,45.89 205.21,44.49 205.62,44.49 205.87,44.25 207.86,44.25 208.32,44.71 208.32,44.84 209.08,45.6 212.24,45.6 214.41,43.42 v1(214.41,36.67)
  BOTTOM w0.076: v1(159.35,106.27) 159.35,106.29 158.98,106.66 155.21,106.66 154.73,107.14 153.93,107.14 153.74,107.33 152.67,107.33 152.34,107.67 151.63,107.67 151.47,107.82 150.71,107.82 150.42,108.11 150.42,108.7 U35.BA11
  BOTTOM w0.114: v1(214.41,36.67) 214.39,36.67 214.09,36.97 v3(211.95,36.97) 210.41,35.44 R748.1
N109188: length 16.5
  BOTTOM w0.076: U35.AY9 151.91,109.41 152.84,108.49 152.84,108.1 152.94,108 154.07,108 154.27,107.8 155.07,107.8 155.53,107.34 159.65,107.34 160,107.69 160.36,107.69
  BOTTOM w0.114: 160.36,107.69 160.95,107.69 161.51,108.25 162.73,108.25 162.78,108.3 163.31,108.3 163.66,107.95 R626.2 164.23,108.27 165.38,108.27 165.69,107.95 R627.2
N109300: length 15.5
  BOTTOM w0.076: U35.AY13 149.29,109.42 149.29,109.26 149.21,109.04 149.21,108.91 149.28,108.68 149.28,108.54 149.22,108.42 149.22,108.1 149.37,107.95 149.37,107.55 150.16,106.76 151.08,106.76 151.19,106.65 151.86,106.65 152.17,106.34 153.27,106.34 153.46,106.15 154.29,106.15 154.79,105.65 155.8,105.65 156.1,105.36 156.89,105.36
  BOTTOM w0.114: 156.89,105.36 157.16,105.08 157.16,102.89 157.31,102.74 157.31,101.86 157.82,101.35 R659.1
N109332: length 10.8
  BOTTOM w0.076: U35.BA13 149.76,108.7 149.76,107.69 150.35,107.1 151.21,107.1 151.33,106.98 152.03,106.98 152.34,106.67 153.41,106.67 153.6,106.48 154.43,106.48 154.93,105.99 157.02,105.99 157.31,105.69
  BOTTOM w0.114: 157.31,105.69 157.82,105.19 R640.1
N109356: length 12.1
  BOTTOM w0.076: 156.93,105.79 156.9,105.82 154.86,105.82 154.36,106.32 153.53,106.32 153.34,106.51 152.23,106.51 151.93,106.82 151.26,106.82 151.15,106.93 150.29,106.93 149.54,107.68 149.54,108.05 149.49,108.1 U35.BB13
  BOTTOM w0.114: 156.93,105.79 157.39,105.33 157.39,103.31 R653.1
N109380: length 25.1
  BOTTOM w0.076: 157.7,105.79 157.48,105.79 157.12,106.15 154.99,106.15 154.5,106.65 153.67,106.65 153.47,106.84 152.4,106.84 152.1,107.15 151.4,107.15 151.26,107.29 150.42,107.29 149.92,107.79 149.92,108.86 149.76,109.02 149.76,109.45 150.06,109.75 U35.AY12
  BOTTOM w0.114: R668.1 167.22,100.5 v1(166.89,100.83) 166.36,101.36 166.36,103.23 164.31,105.29 163.92,105.29 163.71,105.49 160.7,105.49 160.43,105.22 160.3,105.22 159.92,104.84 158.55,104.84 158.23,105.15 158.23,105.25 157.7,105.79
N112417: length 11
  BOTTOM w0.076: 160.36,112.02 160.34,112.05 157.49,112.05 157.35,112.18 U35.AT1
  BOTTOM w0.114: R616.2 165.46,110.38 161.28,110.38 161.2,110.31 160.79,110.31 160.67,110.44 160.67,111.72 160.36,112.02
N112429: length 7.6
  BOTTOM w0.114: U35.B7 153.29,130.5 153.57,130.78 153.57,131.04 155.33,132.81 156.77,132.81 158.73,134.77 TP63.1
N112433: length 4.5
  TOP w0.114: v2(150.03,127.91) 150.98,127.91 R145.2
  BOTTOM w0.127: v2(150.03,127.91) U35.E13
N119188: length 4
  TOP w0.114: R153.1 154.85,128.49 v1(154.37,128.01) 153.5,128.01 152.98,128.53 v2(152.74,128.53)
  BOTTOM w0.152: U35.E8 152.43,128.22 v2(152.74,128.53)
N136283: length 2.1
  TOP w0.114: R282.1 175.82,79.71 CN2.2
N136287: length 2.2
  TOP w0.114: R279.1 175.57,80.71 CN2.4
N136291: length 2.6
  TOP w0.114: CN2.6 176.6,81.71 R273.1
N136295: length 2.5
  TOP w0.114: CN2.9 176.97,83.21 176.09,84.1 R268.1
N136299: length 2.5
  TOP w0.114: CN2.11 176.78,84.21 175.88,85.11 R265.1
N136321: length 10.7
  TOP w0.114: R267.1 v3(186.4,84.2) 185.89,84.7 182.21,84.7 182.08,84.83 178.78,84.83 178.4,85.21 CN2.13
N136329: length 2.4
  TOP w0.114: R274.1 176.08,81.21 CN2.5
N151936: length 1.4
  TOP w0.508: C478.1 R357.2
N151940: length 2.5
  TOP w0.508: C478.2 139.29,43.8 138.87,43.38 R362.1 R363.1
N152180: length 3.9
  TOP w0.508: v3(93.23,58.37) 93.23,58.35 ; 93.23,58.35 92.94,58.06 R327.1 R328.1 ; 93.23,58.35 C427.2
N152184: length 2
  TOP w0.114: R325.2 94.96,60.32 94.96,61.24 v3(95.01,61.29)
  TOP w0.508: C427.1 R325.2
N163999: length 3.5
  TOP w0.508: C397.2 92.72,70.66 v1(92.82,70.76) 93.18,71.12 R307.1 93.87,71.7 93.56,72 R302.1
N164003: length 2.2
  TOP w0.508: R313.2 93.48,68.02 v1(92.95,68.02) 92.72,68.25 C397.1
N250004: length 4.4
  TOP w0.114: U13.34 22.53,112.69 23.05,113.2 23.05,115.16 TP15.1
N250028: length 3
  TOP w0.203: R202.2 24.6,112.62 v1(24.83,112.39) 24.4,111.96 24.07,111.96 23.73,111.63 U13.31
N250076: length 2.5
  TOP w0.114: U13.36 21.73,111.78 22.03,112.09 22.03,112.92 R200.2
N250080: length 2.4
  TOP w0.114: R201.2 22.29,113.12 22.29,111.96 22.13,111.8 U13.35
N259399: length 8.2
  TOP w0.114: MR1.1 v3(61.95,5.22) 62.6,5.86 D28.2 62.6,7.08 62.54,7.15 C556.1 63.18,8.03 63.18,8.02 R434.1
N265494: length 3.5
  TOP w0.114: U18.18 23.09,72.22 v1(22.97,72.34) 22.97,72.61 22.07,73.52 R294.2
N265518: length 3.3
  TOP w0.114: R306.1 28.94,70.13 28.94,70.12 v1(28.31,69.49) 28.01,69.19 U18.8
N321886: length 3.5
  TOP w0.508: U25.5 44.09,28.13 43.62,28.6 v3(43.62,29.03) 43.55,28.95 R395.2 R390.2
N366230: length 3.4
  BOTTOM w0.114: R673.2 224.5,96.97 224.5,96.08 v1(224.37,95.96) 223.86,95.45 223.86,94.61 Q36.3
N16779422:
  vias: v1(206.18,27.07) v1(206.79,26.82) v3(207.38,27.35)
N16779565: length 4.3
  TOP w0.114: Q19.3 210.76,131.54 211.04,131.82 R148.2 212.3,132.48 211.92,132.85 Q18.2
N16779579: length 5.3
  BOTTOM w0.114: Q42.2 205.83,24.84 206.16,24.51 v1(207.1,24.51) 207.15,24.51 208.49,23.17 R754.2 C786.1
N16781100: length 12.4
  TOP w0.508: R415.1 R416.1 205.19,17.13 205.19,17.14 v3(205.6,17.55) 206.07,18.02 206.07,18.67 205.38,19.36 205.38,20.52 205.19,20.71 205.19,21.46 203.92,22.73 203.92,23.63 203.42,24.14 201.98,24.14 201.76,24.36 201.76,24.76 R402.2
N16787949: length 1.1
  TOP w0.114: R373.1 C490.2
N16788300: length 4.3
  BOTTOM w0.114: C778.1 210.06,41.47 209.64,41.04 209.64,40.1 209.31,39.77 208.98,39.77 208.72,39.52 U45.12
N16788484: length 94.5
  BOTTOM w0.114: R774.1 C798.2 v3(194.32,95.12) 195.72,95.12 198.44,92.4 198.44,82.39 197.22,81.17 197.22,73.07 196.92,72.77 196.92,71.69 198.57,70.04 198.57,66.15 199.35,65.37 199.35,63.98 196.67,61.29 196.67,56.5 194.69,54.52 192.17,54.52 187.81,50.16 187.81,47.06 185.76,45.01 185.76,43.56 184.11,41.91 180.81,41.91 180.05,41.14 180.05,32.08 180.89,31.24 182.46,31.24 183.14,31.91 U45.66
N16788550: length 293.6
  TOP w0.114: v1(163.36,197.43) 164.38,197.43 v3(166.37,195.44) 167.5,194.31 174.97,194.31 175.58,193.7 178.46,193.7 178.75,193.99 179.81,193.99 180.66,194.84 181.95,194.84 182.89,193.9 184.72,193.9 185.05,194.23 189.62,194.23 189.75,194.1 198.18,194.1 199.15,193.14 200.22,193.14 202.31,191.05 203.68,191.05 205.37,189.35 206.77,189.35 207.86,188.26 207.86,187.5 208.8,186.56 211.67,186.56 212.43,185.8 220.31,185.8 225.28,180.82 225.28,150.87 222.54,148.13 220.46,148.13 218.27,145.94 218.27,134.62 218.68,134.21 218.68,126.79 220.61,124.86 v1(221.45,124.86) ; v1(112.56,183.84) 113.37,183.03 R460.1 C801.1
  IN1 w0.127: v1(112.56,183.84) 112.94,183.84 117.13,188.03 117.77,188.03 121.07,191.33 121.83,191.33 124.27,193.77 125.03,193.77 131.43,200.17 132.5,200.17 133.34,201.01 v1(138.47,201.01) ; v1(221.45,124.86) 221.45,123.87 220.33,122.75 220.33,117.93 221.25,117.01 221.25,116.45 225.5,112.2 226.06,112.2 227.19,111.07 227.19,105.91 226.66,105.38 226.66,93.57 223.91,90.83 219.93,90.83 218.53,89.43 218.53,68.83 v1(218.38,68.68)
  IN2 w0.127: v1(163.36,197.43) 163.36,198.05 159.97,201.44 151.32,201.44 150.76,202 139.46,202 v1(138.47,201.01) ; v1(204.91,52.9) 205.14,53.13 207.4,53.13 208.98,54.71 208.98,59.28 v1(218.38,68.68)
  BOTTOM w0.102: U45.118 202.31,47.45 202.24,47.52 202.24,49.88 202.68,50.31 202.76,50.31
  BOTTOM w0.114: 202.76,50.31 203.82,51.38 203.82,52.57 204.16,52.9 v1(204.91,52.9)
N16788590: length 2.4
  BOTTOM w0.114: TP78.1 204.69,47.11 203.91,46.34 U45.122
N16788607: length 2.2
  TOP w0.114: TP33.1 193.03,38.2 v1(193.51,37.71)
  BOTTOM w0.114: U45.80 193.31,37.52 v1(193.51,37.71)
N16788623: length 49.5
  TOP w0.114: v1(198.44,18.46) 198.44,16.91 199.61,15.74 206.84,15.74 207.99,16.89 C796.1 R190.1
  IN1 w0.127: v1(196.76,44.27) 196.76,43 197.1,42.66 197.1,42.17 196.74,41.8 196.74,39.6 197.46,38.88 197.46,36.82 196.83,36.19 196.57,36.19 196.05,35.66 196.05,34.85 197.12,33.78 198.15,33.78 198.6,33.33 198.6,32.53 198.79,32.34 198.79,30.83 195.29,27.33 195.29,25.71 194.85,25.27 194.85,23.77 v1(195.26,23.36)
  BOTTOM w0.114: v1(196.76,44.27) 196.71,44.32 194.78,44.32 194.31,44.79 U45.98 ; v1(195.26,23.36) v1(195.77,22.85) 196.08,22.55 197.16,22.55 198.44,21.26 v1(198.44,18.46)
N16789334: length 6
  BOTTOM w0.114: U45.126 205.51,48.26 205.96,48.7 205.96,51.05 TP77.1
N16824426: length 3
  TOP w0.114: U9.2 175.54,134.27 175.97,133.85 R139.2 R140.2
N16946782: length 2.4
  TOP w0.114: Q5.2 164.3,160.24 v1(164.66,160.6) 164.3,160.96 164.3,160.98 164,161.28 R74.2
N16946786: length 4.1
  TOP w0.114: R74.1 163.67,162.06 163.21,161.59 163.21,161.03 v3(162.88,160.7) 163.28,160.3 v1(163.28,159.76)
  BOTTOM w0.114: Q31.1 163.51,159.51 163.28,159.74 v1(163.28,159.76)
N16998366: length 4
  TOP w0.114: v3(30.16,47.19) 30.16,48.09 R343.1
  TOP w0.508: Q27.2 30.16,48.16 R343.1 R344.2
N16998426: length 6.3
  TOP w0.508: Q27.3 32.83,51.79 v3(32.88,51.84) 33.24,51.48 Q28.2 33.77,49.12 R345.2
N16999417: length 6
  TOP w0.114: U17.1 202.15,84.6 v3(202.15,81.2) R284.2 R285.1
N17002655: length 4.9
  TOP w0.114: U23.39 36.26,32.5 36.51,32.25 37.43,32.25 38.44,31.24 v1(38.44,31.09) 38.63,30.9 38.79,30.9 39.33,30.35 C529.2
N17002661: length 3.3
  TOP w0.114: U23.37 36.2,31.71 36.84,31.06 v1(37.12,31.06) 37.36,30.82 37.36,30.54 37.68,30.22 38.07,30.22 C528.1
N17002676: length 1.9
  TOP w0.114: U23.34 34,30.22 34.75,29.47 C530.2
N17002678: length 3.1
  TOP w0.114: U23.19 28.92,33.71 28.81,33.6 27.9,33.6 v1(27.8,33.5) 26.95,32.64 C519.1
N17002722: length 2
  TOP w0.114: TP34.1 37,37.28 36.28,36.57 36.28,36.24 36.15,36.1 U23.48
N17002952: length 7.4
  TOP w0.114: U23.7 32.4,38.12 31.89,38.63 31.89,39.62 33.13,40.86 v1(34.71,40.86) 34.85,40.86 C481.1
N17003087: length 5.7
  TOP w0.114: v3(36.59,49.04) 36.61,49.02 D9.1 D10.1 37.3,46.99 37.17,46.86 R352.2
N17003129: length 5
  TOP w0.114: C528.2 38.02,29.32 v1(37.63,29.71) ; v1(35.19,29.89) 34.84,29.89 34.4,30.33 U23.35
  BOTTOM w0.114: v1(37.63,29.71) 37.55,29.71 36.97,30.3 v3(36.87,30.3) 35.62,30.3 35.22,29.89 v1(35.19,29.89)
N17003186: length 5
  TOP w0.203: U23.20 28.29,33.3 27.6,32.61 27.6,30.88 v1(27.57,30.86) 27.37,30.65 26.66,30.65 R388.2
N17004316: length 5.1
  TOP w0.114: Q29.3 v3(42.76,41.45) 42.76,41.14 44.16,39.75 D15.1
N17023094: length 9.2
  TOP w0.114: U15.27 36.5,90.39 38.51,92.4 38.51,97.34 TP26.1
N17023105: length 10.6
  TOP w0.114: TP27.1 40.57,96.48 39.3,96.48 39.02,96.21 39.02,92.19 37.3,90.47 U15.25
N17023109: length 9.3
  TOP w0.114: TP28.1 39.41,97.02 38.77,96.39 38.77,92.3 36.9,90.43 U15.26
N17023253: length 5.2
  BOTTOM w0.114: R709.2 48.6,87.37 48.85,87.13 R713.1 R715.1 v3(47.51,85.72) 47.21,85.72 46.82,86.1 Q39.3
N17023337: length 6.6
  TOP w0.508: C364.2 v1(28.66,89.9)
  BOTTOM w0.508: v1(28.66,89.9) 28.61,89.96 U42.4 ; v1(28.41,92.96) 28.41,92.96 U42.1 ; U42.7 v1(28.41,86.96) ; U42.10 v1(28.41,83.96)
N17023386: length 3.3
  TOP w0.508: R259.2 C368.2 45.94,88.9 v3(45.94,89.86) Q24.2
N17028021: length 3.5
  TOP w0.114: R230.2 179.66,101.45 179.58,101.53 C344.2 179.58,103.03 v3(179.59,103.04) 180.05,103.04 180.68,103.68 180.68,103.75
N17045098: length 115.1
  TOP w0.114: v1(209.26,52.19) 209.77,51.68 209.77,51.18 209,50.41 208.62,50.41 208.37,50.67 208.37,51.18 207.99,51.56 206.21,51.56 205.45,50.8 203.42,50.8 202.53,49.91 198.59,49.91 197.57,50.92 197.57,51.68 196.43,52.83 195.29,52.83 192.75,55.37 192.75,65.02 v1(194.78,67.05) ; R349.1 C797.1 179.79,119.99 180.99,118.79 180.99,115.74 180.81,115.57 180.81,113.28 181.67,112.42 181.67,109.25 182.23,108.7 182.23,107.58 181.57,106.93 181.16,106.93 177.63,103.41 177.63,100.07 178.65,99.06 178.65,94.86 181.11,92.4 182.41,92.4 v1(182.71,92.71)
  IN2 w0.127: v1(194.78,67.05) 195.29,67.56 195.29,69.85 194.91,70.23 194.91,76.07 191.6,79.37 191.6,87.88 190.89,88.59 189.65,88.59 189.06,88.01 183.98,88.01 182.71,89.28 v1(182.71,92.71)
  BOTTOM w0.114: v1(209.26,52.19) 208.62,52.19 208.37,51.94 208.37,50.8 208.62,50.54 v1(208.62,50.16) 208.62,49.27 208.24,48.89 208.24,48.13 206.31,46.2 U45.128
N17046941: length 2
  TOP w0.114: PR6.1 157.57,195.07 v1(157.7,194.94)
  BOTTOM w0.114: PJ1.3 158.24,194.39 v1(157.7,194.94)
N17047009: length 3.7
  BOTTOM w0.114: PR183.2 204.66,191.08 v3(203.67,191.08)
  BOTTOM w0.178: PR183.2 204.69,191.77 204.65,191.8 PU5.20
N17047028: length 3.1
  BOTTOM w0.178: PU5.19 205.05,193.29 204.94,193.18 204.94,192.2 v1(205.14,191.99) 205.54,191.6 205.54,191.52 PR184.2
N17047083: length 1.9
  TOP w0.114: v1(162.52,194.94) 162.52,195.31 PR8.1
  BOTTOM w0.114: PJ1.5 162.24,194.66 v1(162.52,194.94)
N17047087: length 34.1
  IN2 w0.508: v4(184.37,196.97) 184.49,196.85 188.83,196.85 190.15,195.53 193.97,195.53 194.68,194.81 199.33,194.81 199.48,194.66 199.5,194.66 202.22,191.94 204.61,191.94 205.42,191.13 207,191.13 v1(208.32,189.81)
  BOTTOM w0.178: PR176.2 181.74,195.97 179.81,197.9 179.16,197.9 179,198.06 179,199.61 179.29,199.89 PR169.1
  BOTTOM w0.508: v1(208.32,189.81) 209.21,189.81 PR186.1
  vias: v3(179.41,198.47) v4(180.61,200.86) v4(180.61,200.12) v4(180.61,199.39) v4(180.61,197.99) v4(181.34,200.87) v4(181.34,200.14) v4(181.34,199.39) v4(181.34,197.99)
N17047112: length 26.4
  IN2 w0.254: v1(206.84,201.06) 207.45,200.45 208.3,200.45 208.73,200.02 209.26,200.02 209.61,199.67 209.61,192.93 212.69,189.86 212.69,187.19 v1(212.56,187.07)
  BOTTOM w0.254: v1(206.84,201.06) 206.43,201.06 PR165.1 ; PC133.2 212.43,187.19 v1(212.56,187.07) 212.56,183.71 v3(212.66,183.61) 213.58,182.7 213.58,182.27 PC136.2 214.21,182.09 PQ22.4
N17047335: length 1.2
  TOP w0.508: PC4.1 PR2.2
N17047399: length 1.5
  BOTTOM w0.508: PR173.1 199.5,198.07 PC119.2
N17047425: length 2
  TOP w0.114: v1(159.73,194.94) 159.6,195.07 PR7.1
  BOTTOM w0.114: v1(159.73,194.94) 160.24,194.42 PJ1.4
N17047601: length 38.1
  TOP w0.508: v1(188.3,195.68) 188.3,196.08 187.49,196.9 v3(186.35,196.9) 181.7,201.54 179.79,201.54 179.18,200.93 PC1.2 179.15,200.5 PQ1.4
  IN2 w0.508: v1(188.3,195.68) 188.89,195.68 189.67,194.89 193.69,194.89 194.41,194.18 199.05,194.18 199.2,194.03 199.22,194.03 201.94,191.31 204.33,191.31 205.14,190.5 206.72,190.5 208.04,189.18 v1(208.32,189.18)
  BOTTOM w0.508: PR185.1 207.94,189.18 v1(208.32,189.18)

# Allegro board Quanta ZRW REV F - BoardView (.BRD).brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
UART2_RXD: length 95.9
  TOP w0.114: R275.1 152.75,87.19 153.02,87.19 154.57,85.64 154.57,81.58 154.77,81.38 CN3.2 157.16,81.38 157.49,81.05 158.2,81.05 v3(158.74,81.58) 159.27,81.05 159.7,81.05 161.84,78.91 162.72,78.91 167.85,73.78 v1(169.38,73.78)
  IN2 w0.127: v1(171.01,118.99) 170.9,118.87 172.4,117.37 172.45,117.37 173.39,116.43 173.39,115.62 173.49,115.52 173.49,114.09 173.8,113.79 174.46,113.79 174.8,113.45 174.8,111.02 177.76,108.07 177.76,104.49 178.09,104.16 178.09,98.88 176.8,97.58 176.8,92.16 172.42,87.79 170.92,87.79 168.36,85.24 168.36,84.96 168.67,84.65 168.67,83.34 168.4,83.07 168.4,78.6 168.88,78.12 168.88,76.69 169.74,75.84 169.74,74.14 v1(169.38,73.78)
  BOTTOM w0.076: U35.AD1 156.81,118.16 157.57,118.16 158.2,117.52 159.22,117.52 159.73,118.03 160.19,118.03 160.36,118.2
  BOTTOM w0.114: 160.36,118.2 160.93,118.77 161.94,118.77 162.33,119.16 164.98,119.16 165.38,119.56 166.21,119.56 166.77,118.99 167.75,118.99 167.98,118.77 170.78,118.77 v1(171.01,118.99)
UART2_TXD: length 97.7
  TOP w0.114: v1(170.01,73.27) 170,73.29 168.02,73.29 162.63,78.69 161.73,78.69 159.6,80.82 159.25,80.82 v3(158.74,80.31) 158.23,80.82 157.57,80.82 157.13,80.38 CN3.3 155.42,80.38 154.34,81.45 154.34,85.54 152.92,86.97 152.62,86.97 R280.1
  IN2 w0.127: v1(170.01,73.27) 169.99,73.3 169.99,75.95 169.14,76.8 169.14,78.23 168.68,78.69 168.68,79.62 168.66,79.65 168.66,82.97 168.92,83.23 168.92,83.99 169.58,84.65 169.58,85.39 171.73,87.54 172.53,87.54 177.05,92.06 177.05,96.31 178.35,97.61 178.35,104.31 178.09,104.57 178.09,108.09 175.06,111.13 175.06,113.57 174.54,114.09 174.54,115 173.67,115.86 173.67,116.51 171.56,118.62 v1(171.67,119.02)
  BOTTOM w0.076: U35.AD2 156.46,117.85 157.5,117.85 158.08,117.28 159.21,117.28 159.73,117.8 160.28,117.8 160.36,117.88
  BOTTOM w0.114: 160.36,117.88 160.99,118.51 162.01,118.51 162.44,118.93 165.08,118.93 165.47,119.33 166.12,119.33 166.68,118.77 167.65,118.77 167.88,118.54 171.41,118.54 171.67,118.79 v1(171.67,119.02)
URDBG: length 1.6
  TOP w0.114: TP24.1 26.09,107.98 U13.24
USB2_ID: length 9.4
  BOTTOM w0.076: 160.36,116.38 160.19,116.38 160.16,116.4 159.78,116.4 159.42,116.05 156.91,116.05 156.68,115.82 155.66,115.82 155.51,115.98 U35.AG3
  BOTTOM w0.114: R587.1 163.43,117.12 162.88,117.12 162.83,117.17 162.47,117.17 162.01,116.71 161.12,116.71 160.79,116.38 160.36,116.38
USB3_RXN0: length 267.5
  TOP w0.114: v1(30.95,46.48) 30.77,46.29 30.77,45.91 30.56,45.7 30.56,42.27 28.65,40.37 28.65,39.77 27.48,38.6 25.87,38.6 24.51,37.25 24.51,36.13 25.01,35.63 25.01,35.15 24.77,34.91 v1(24.77,34.09) 23.92,34.09 23.44,33.61 22.64,33.61 22.25,33.22 22.25,32.44 C518.2 22.2,31.5 22.2,31.12 20.99,29.92 20.24,29.92 19.91,29.59 R392.2
  IN2 w0.127: v1(93.63,77.27) 93.41,77.05 93.09,77.05 90.45,74.41 90.45,73.5 85.49,68.54 82.11,68.54 79.49,65.91 65.77,65.91 65.01,65.15 46.34,65.15 32.85,51.66 32.85,50.65 30.29,48.08 30.29,47.14 v1(30.95,46.48) ; v2(152.8,125.96) 153.23,126.39 153.23,126.76 153.55,127.07 154.29,127.07 154.47,127.25 157.23,127.25 157.59,126.89 159.66,126.89 160.67,127.91 163.59,127.91 163.87,127.63 166.1,127.63 166.31,127.83 166.46,127.83 166.97,128.34 168.92,128.34 169.88,127.38 171.61,127.38 172.25,126.74 173.72,126.74 174.02,126.45 174.02,123.54 176.4,121.16 176.4,119.89 177.58,118.71 177.58,118.43 177.74,118.28 177.74,116.4 178.22,115.92 178.22,114.88 178.42,114.68 178.42,114.14 181.06,111.5 181.06,110.13 182.05,109.14 182.05,106.27 183.98,104.34 183.98,98.22 182.71,96.95 181.03,96.95 179.93,95.85 179.93,90.43 174.36,84.86 172.23,84.86 171.82,84.45 171.82,83.57 171.13,82.88 171.13,79.7 170.22,78.79 170.22,77.77 169.99,77.54 169.66,77.54 v1(169.58,77.62)
  BOTTOM w0.114: U35.H8 152.63,125.96 v2(152.8,125.96) ; v1(93.63,77.27) 93.71,77.19 94.62,77.19 96.64,79.21 151.08,79.21 151.23,79.06 167.89,79.06 168.16,78.79 168.16,77.75 168.43,77.48 169.44,77.48 v1(169.58,77.62)
USB3_RXN0_R: length 9.6
  TOP w0.114: R392.1 18.67,29.67 17.7,29.67 17.21,29.18 U24.6 15.71,29.18 15.62,29.09 15.62,28.61 15.34,28.33 14.79,28.33 13.92,27.46 12.57,27.46 11.61,26.51 CN16.5
USB3_RXN1: length 246
  TOP w0.114: v1(29.93,51.94) 29.55,51.94 29.3,51.68 29.3,50.03 28.78,49.51 28.78,46.76 28.32,46.3 26.85,46.3 26.82,46.27 26.8,46.27 C475.2 25.91,46.3 25.68,46.3 24.98,45.6 23.57,45.6 23.48,45.51 23.48,45.39 23.38,45.29 23.04,45.29 R355.2
  IN2 w0.127: v1(93.69,78.61) 93.44,78.37 92.88,78.37 85,70.48 80.23,70.48 79.72,69.97 75.27,69.97 74.31,69.01 64.04,69.01 63.48,68.45 47.3,68.45 37.73,58.87 33.84,58.87 29.43,54.46 29.43,52.45 v1(29.93,51.94) ; v1(153.68,125.98) 153.81,126.11 155.13,126.11 155.22,126.2 159.97,126.2 160.72,126.95 166.41,126.95 166.61,127.15 166.84,127.15 167.35,127.66 168.61,127.66 169.66,126.61 171.21,126.61 172.55,125.27 172.55,123.96 175.72,120.8 175.72,119.03 176.31,118.43 176.31,116.55 177.51,115.36 177.51,114.5 177.56,114.45 177.56,113.89 179.36,112.08 179.36,110.84 180.87,109.33 180.87,106.05 182.78,104.15 182.78,101.05 183.16,100.67 183.16,98.36 182.9,98.1 182.14,98.1 182.02,98.23 181.16,98.23 179.25,96.32 179.25,91.36 173.43,85.54 171.89,85.54 171.11,84.76 171.11,83.85 170.45,83.18 170.45,80.04 169.78,79.37 169.55,79.37 169.5,79.42 v1(169.33,79.42)
  BOTTOM w0.114: v1(153.68,125.98) 153.32,125.62 U35.J6 ; v1(169.33,79.42) 169.15,79.24 168.64,79.24 168.17,79.72 152.59,79.72 152.44,79.87 96.34,79.87 94.85,78.39 93.91,78.39 v1(93.69,78.61)
USB3_RXN1_R: length 13.4
  TOP w0.114: CN13.5 11.61,44.52 12.38,45.29 13.63,45.29 14.34,44.59 15.11,44.59 v3(15.61,44.09) 16.1,44.59 17.12,44.59 17.46,44.93 17.46,45.36 17.79,45.69 U21.6 20.13,45.69 20.23,45.6 21.56,45.6 21.66,45.51 21.66,45.39 21.76,45.29 22.09,45.29 R355.1
USB3_RXP0: length 267.5
  TOP w0.114: R387.2 19.91,30.6 20.35,30.16 20.89,30.16 21.96,31.22 21.96,31.58 C517.2 22.01,32.45 22.01,33.32 22.54,33.85 23.34,33.85 23.87,34.38 v1(23.87,34.99) 24.5,34.99 24.77,35.25 24.77,35.53 24.27,36.03 24.27,37.35 25.77,38.85 27.38,38.85 28.41,39.87 28.41,40.47 30.31,42.37 30.31,45.8 30.52,46.01 30.52,46.69 v1(30.95,47.11)
  IN2 w0.127: v2(152.78,126.59) 152.78,126.66 153.44,127.33 154.19,127.33 154.36,127.5 157.34,127.5 157.7,127.15 159.55,127.15 160.57,128.16 163.69,128.16 163.97,127.88 166,127.88 166.2,128.09 166.35,128.09 166.86,128.6 169.02,128.6 169.99,127.63 171.72,127.63 172.35,127 173.82,127 174.27,126.55 174.27,123.65 176.65,121.26 176.65,120 177.84,118.82 177.84,118.54 177.99,118.39 177.99,116.51 178.47,116.03 178.47,114.99 178.68,114.78 178.68,114.25 181.32,111.6 181.32,110.24 182.31,109.25 182.31,106.37 184.24,104.44 184.24,98.11 182.82,96.69 181.14,96.69 180.19,95.74 180.19,90.33 174.47,84.6 172.33,84.6 172.07,84.34 172.07,83.46 171.39,82.77 171.39,79.6 170.47,78.69 170.47,77.67 170.09,77.29 169.89,77.29 v1(169.58,76.98) ; v1(93.63,76.63) 93.47,76.8 93.2,76.8 90.71,74.31 90.71,73.39 85.6,68.28 82.22,68.28 79.59,65.65 65.87,65.65 65.11,64.89 46.44,64.89 33.11,51.56 33.11,50.54 30.54,47.98 30.54,47.24 30.67,47.11 v1(30.95,47.11)
  BOTTOM w0.114: v2(152.78,126.59) 152.66,126.59 U35.G8 ; v1(93.63,76.63) 93.95,76.95 94.72,76.95 96.74,78.97 150.98,78.97 151.13,78.82 167.79,78.82 167.92,78.69 167.92,77.65 168.33,77.24 169.38,77.24 169.58,77.03 v1(169.58,76.98)
USB3_RXP0_R: length 9.5
  TOP w0.114: CN16.6 13.82,27.7 14.69,28.57 15.24,28.57 15.38,28.71 15.38,29 15.01,29.37 U24.5 15.56,29.58 15.64,29.5 17.19,29.5 17.74,30.06 17.74,30.22 18.04,30.52 18.67,30.52 R387.1
USB3_RXP1: length 246.1
  TOP w0.114: R353.2 23.04,46.14 23.38,46.14 23.48,46.04 23.48,45.93 23.56,45.84 24.88,45.84 25.58,46.54 25.8,46.54 C469.2 26.94,46.54 28.22,46.54 28.54,46.86 28.54,49.61 29.06,50.13 29.06,51.79 29.45,52.18 29.54,52.18 v1(29.93,52.57)
  IN2 w0.127: v1(29.93,52.57) 29.68,52.83 29.68,54.35 33.95,58.62 37.83,58.62 47.41,68.19 63.59,68.19 64.15,68.75 74.41,68.75 75.38,69.72 79.82,69.72 80.33,70.23 85.1,70.23 92.99,78.11 93.55,78.11 v1(93.69,77.97) ; v1(153.73,126.61) 153.99,126.36 155.03,126.36 155.12,126.45 159.86,126.45 160.61,127.2 166.3,127.2 166.51,127.4 166.73,127.4 167.24,127.91 168.72,127.91 169.76,126.87 171.31,126.87 172.81,125.37 172.81,124.06 175.97,120.9 175.97,119.14 176.57,118.54 176.57,116.66 177.76,115.46 177.76,114.6 177.81,114.55 177.81,113.99 179.62,112.19 179.62,110.95 181.13,109.44 181.13,106.16 183.03,104.25 183.03,101.15 183.41,100.77 183.41,98.26 183,97.85 182.04,97.85 181.91,97.98 181.26,97.98 179.5,96.22 179.5,91.26 173.53,85.29 172,85.29 171.36,84.65 171.36,83.74 170.7,83.08 170.7,79.93 169.89,79.12 169.66,79.12 v1(169.33,78.79)
  BOTTOM w0.114: U35.H6 153.58,126.61 v1(153.73,126.61) ; v1(169.33,78.79) 169.11,79 168.54,79 168.07,79.48 152.49,79.48 152.34,79.63 96.44,79.63 94.95,78.15 93.86,78.15 v1(93.69,77.97)
USB3_RXP1_R: length 13.5
  TOP w0.114: CN13.6 11.78,45.53 13.73,45.53 14.44,44.83 15.07,44.83 v3(15.61,45.36) 16.14,44.83 17.02,44.83 17.22,45.03 17.22,45.47 16.79,45.9 U21.5 19.01,46.09 19.17,45.94 20.23,45.94 20.33,45.84 21.58,45.84 21.66,45.93 21.66,46.04 21.76,46.14 22.09,46.14 R353.1
USB3_TXN0: length 203
  TOP w0.114: C499.1 22.59,37.42 22.33,37.68 22.33,38.31 v1(22.72,38.71)
  IN2 w0.127: v1(22.72,38.71) 22.34,39.09 22.34,39.34 21.93,39.75 21.93,42.23 20.43,43.73 20.43,50.19 43.22,72.97 72.93,72.97 76.35,76.39 84.53,76.39 89.63,81.48 92.87,81.48 94.32,82.93 94.32,93.09 95.77,94.53 95.77,108.8 101.38,114.42 101.38,117.29 100.8,117.88 100.8,121.61 104.99,125.8 105.85,125.8 108.94,128.9 109.54,128.9 109.92,129.28 112.73,129.28 114.89,127.12 116.42,127.12 117.69,125.85 120.51,125.85 120.91,125.45 122.03,125.45 122.87,124.61 138.06,124.61 138.9,125.45 138.9,125.6 139.22,125.92 141.12,125.92 141.44,126.23 143.78,126.23 144.04,125.98 145.95,125.98 146.37,126.39 146.37,127.97 146.86,128.46 146.86,128.67 147.53,129.33 147.82,129.33 148.04,129.11 148.04,128.95 v2(147.87,128.77)
  BOTTOM w0.076: v2(147.87,128.77) 147.87,128.52 147.99,128.39 148.17,128.39 148.46,128.69 148.84,128.69 148.86,128.66 149.17,128.66 149.39,128.88 149.39,129.11 149.56,129.29 149.75,129.29 149.8,129.33 149.8,129.53 U35.C13
USB3_TXN0_C: length 4.7
  TOP w0.114: R384.2 20.25,34.11 20.54,34.11 20.84,34.41 21.43,34.41 21.78,34.77 22.53,34.77 v1(22.53,34.78) 22.54,34.78 22.57,34.8 22.57,35.56 22.82,35.81 22.82,36.51 C499.2
USB3_TXN0_R: length 12.3
  TOP w0.114: R384.1 19.3,34.11 18.85,34.11 18.55,34.41 17.74,34.41 17.55,34.6 17.16,34.6 C511.1 16.2,34.43 16.09,34.43 15.94,34.27 15.94,33.68 16.28,33.33 16.28,32.94 16.43,32.79 16.78,32.79 16.91,32.65 U24.10 16.16,32.38 16.07,32.48 14.03,32.48 13.53,31.97 11.89,31.97 CN16.8
USB3_TXN1: length 266.5
  TOP w0.114: v1(37.68,54.99) 38.07,55.38 38.07,55.6 37.58,56.09 32.52,56.09 28.52,52.09 28.52,50.91 27.85,50.24 27.53,50.24 27.28,49.98 C461.1
  IN2 w0.127: v1(37.68,54.99) 37.92,55.23 37.92,55.59 46.72,64.38 81.64,64.38 83.42,66.16 88.86,66.16 91.08,68.39 95.15,68.39 v1(95.34,68.58) ; v1(170.76,73.87) 170.9,74.01 170.9,78.49 171.82,79.4 171.82,82.52 172.86,83.56 174.59,83.56 180.62,89.59 180.62,95.21 181.15,95.74 182.5,95.74 185.46,98.7 185.46,101.45 185.15,101.76 185.15,104.44 184.67,104.92 184.67,105.58 182.79,107.46 182.79,109.39 181.75,110.44 181.75,111.8 179.11,114.44 179.11,116.32 178.6,116.83 178.6,118.42 178.4,118.62 178.4,118.99 177.09,120.3 177.09,121.44 175.48,123.05 175.48,128.03 174.79,128.72 174.79,129.46 174.51,129.74 174.51,130.78 173.51,131.78 173.51,133.26 172.6,134.17 171.12,134.17 170.69,134.6 170.69,135.49 170.66,135.52 169.35,136.82 169.35,137.44 166.84,139.95 166.45,139.95 166.02,140.38 163.79,140.38 162.01,138.6 162.01,137.05 158.72,133.75 154.42,133.75 153.63,132.96 152.62,132.96 150.81,131.16 150.61,131.16 v5(150.23,130.78)
  BOTTOM w0.114: U35.B13 149.68,130.49 149.97,130.78 v5(150.23,130.78) ; v1(95.34,68.58) 95.47,68.45 96.1,68.45 100.09,72.44 103.38,72.44 107.88,76.93 154.95,76.93 159.35,72.54 166.94,72.54 167.35,72.13 170.14,72.13 170.76,72.75 v1(170.76,73.87)
USB3_TXN1_C: length 2.4
  TOP w0.114: R341.2 24.86,49.91 25.99,49.91 C461.2
USB3_TXN1_R: length 16.7
  TOP w0.114: v1(17.39,50.11) 17.46,50.03 17.46,49.65 17.39,49.58 17.01,49.58 16.79,49.36 U21.1 17.03,49.29 17.34,48.98 17.99,48.98 18.38,48.59 19.32,48.59 19.75,49.02 19.75,49.65 20,49.89 20.27,49.89 20.43,49.73 20.43,49.5 20.54,49.4 C460.1 21.38,49.87 22.98,49.87 23.33,49.53 R341.1
  IN2 w0.127: v1(17.39,50.11) 17.39,50.41 17.15,50.64 16.25,50.64 15.69,50.08 12,50.08 CN13.8
USB3_TXP0: length 203
  TOP w0.114: C498.1 22.09,37.57 v1(22.09,38.68)
  IN2 w0.127: v1(22.09,38.68) 22.09,39.24 21.68,39.65 21.68,42.13 20.18,43.63 20.18,50.29 43.11,73.22 72.83,73.22 76.25,76.64 84.43,76.64 89.52,81.73 92.77,81.73 94.07,83.03 94.07,93.19 95.52,94.64 95.52,108.91 101.13,114.52 101.13,117.19 100.55,117.77 100.55,121.72 104.89,126.06 105.74,126.06 108.84,129.15 109.44,129.15 109.82,129.54 112.84,129.54 115,127.38 116.53,127.38 117.8,126.11 120.61,126.11 121.02,125.7 122.14,125.7 122.98,124.86 137.95,124.86 138.65,125.55 138.65,125.7 139.11,126.17 141.02,126.17 141.33,126.49 143.85,126.49 144.13,126.21 145.86,126.21 146.14,126.49 146.14,128.06 146.63,128.56 146.63,128.76 147.43,129.56 147.92,129.56 148.3,129.18 148.3,128.02 v5(148.17,127.89)
  BOTTOM w0.076: v5(148.17,127.89) 148.17,128.16 148.53,128.52 148.77,128.52 148.79,128.5 149.24,128.5 149.68,128.93 U35.D13
USB3_TXP0_C: length 4.7
  TOP w0.114: C498.2 22.21,36.64 22.58,36.27 22.58,35.91 22.33,35.66 21.65,35.66 v1(21.64,35.67) 21.63,35.67 21.63,34.96 21.33,34.65 20.8,34.65 20.49,34.96 20.25,34.96 R381.2
USB3_TXP0_R: length 12.3
  TOP w0.114: R381.1 19.3,34.96 18.83,34.96 18.52,34.65 17.84,34.65 17.65,34.84 17.17,34.84 C505.1 16.59,34.76 16.5,34.67 15.99,34.67 15.7,34.37 15.7,33.58 16.04,33.23 16.04,32.89 15.87,32.72 15.08,32.72 U24.1 14.95,32.72 13.93,32.72 13.43,32.22 12.6,32.22 11.61,33.2 CN16.9
USB3_TXP1: length 266.5
  TOP w0.114: C459.1 27.47,50.48 27.75,50.48 28.28,51.01 28.28,52.19 32.42,56.33 37.68,56.33 38.32,55.7 v1(38.32,54.99)
  IN2 w0.127: v1(150.23,131.42) 150.71,131.42 152.51,133.22 153.53,133.22 154.31,134.01 158.61,134.01 161.76,137.16 161.76,138.71 163.69,140.64 166.13,140.64 166.56,140.2 166.95,140.2 169.61,137.54 169.61,136.93 170.85,135.68 170.94,135.6 170.94,134.7 171.22,134.43 172.71,134.43 173.76,133.37 173.76,131.89 174.76,130.89 174.76,129.84 175.04,129.56 175.04,128.82 175.73,128.14 175.73,123.16 177.34,121.55 177.34,120.41 178.65,119.1 178.65,118.73 178.85,118.52 178.85,116.94 179.36,116.43 179.36,114.55 182,111.91 182,110.54 183.05,109.5 183.05,107.56 184.92,105.69 184.92,105.02 185.41,104.54 185.41,101.86 185.71,101.56 185.71,98.59 182.6,95.49 181.25,95.49 180.87,95.11 180.87,89.49 174.69,83.31 172.97,83.31 172.07,82.41 172.07,79.29 171.16,78.38 171.16,74.11 v1(171.4,73.87) ; v1(38.32,54.99) 38.18,55.12 38.18,55.48 46.82,64.13 81.75,64.13 83.53,65.91 88.97,65.91 91.19,68.13 95.15,68.13 v1(95.34,67.94)
  BOTTOM w0.114: U35.A13 149.81,130.94 150.23,131.36 v1(150.23,131.42) ; v1(95.34,67.94) 95.61,68.21 96.2,68.21 100.19,72.2 103.48,72.2 107.98,76.69 154.85,76.69 159.25,72.3 166.84,72.3 167.25,71.89 170.24,71.89 171.01,72.65 171.01,73.48 v1(171.4,73.87)
USB3_TXP1_C: length 2.4
  TOP w0.114: C459.2 25.98,50.15 24.88,50.15 R340.2
USB3_TXP1_R: length 16.7
  TOP w0.114: v1(18.05,50.11) 17.7,49.77 17.7,49.43 17.91,49.22 18.09,49.22 18.42,48.89 U21.10 19.01,48.89 19.07,48.83 19.22,48.83 19.51,49.12 19.51,49.75 19.92,50.15 20.35,50.15 20.43,50.24 20.43,50.57 20.54,50.67 C458.1 21.47,50.11 22.89,50.11 23.33,50.54 R340.1
  IN2 w0.127: CN13.9 11.61,51.16 12.43,50.34 15.58,50.34 16.14,50.9 17.26,50.9 v1(18.05,50.11)
USB_BC_ON: length 251.7
  TOP w0.114: U22.4 22.91,42.15 22.98,42.22 22.98,42.7 v1(22.82,42.86) 22.76,42.92 v1(22.19,42.92)
  IN1 w0.133: v1(22.19,42.92) 22.81,43.55 22.81,44.54 25.87,47.6 26.73,47.6 27.62,46.71 27.98,46.71 28.87,47.6 35.95,47.6 37.86,45.69 42.51,45.69 42.68,45.51 42.86,45.51 51.52,36.85 51.52,33.45 55.54,29.43 58.15,29.43 62.27,25.32 72.99,25.32 73.55,24.76 77.36,24.76 79.16,26.56 86.42,26.56 86.91,27.05 86.92,27.05 87.55,27.68 96.72,27.68 99.24,30.2 122.52,30.2 130.95,21.76 190.06,21.76 194.75,17.06 197.85,17.06 198.46,17.67 206.31,17.67 209.31,20.67 209.31,23.19 207.24,25.25 207.24,27.03 206.59,27.68 206.59,28.69 205.87,29.42 205.87,31.81 205.57,32.1 205.32,32.1 204.42,33 204.42,35.93 204.63,36.13 204.63,37.39 204.13,37.89 204.13,39.49 204.53,39.89 204.83,39.89 205.08,40.14 205.08,43.06 v1(204.64,43.51)
  BOTTOM w0.114: U45.97 193.91,44.84 195.02,43.73 199.08,43.73 199.9,42.9 202.18,42.9 202.78,43.51 v1(204.64,43.51)
USB_CHARGE_ON: length 207.7
  TOP w0.114: v1(29.43,47.11) 29.43,46.1 29.81,45.72 29.81,43.44 29.44,43.08 26.17,43.08 25.69,43.56 24.97,43.56 R364.1 24.18,42.85 24.18,43.23 24.05,43.35 22.16,43.35 21.93,43.58 21.54,43.58 21.41,43.46 U22.5
  IN1 w0.127: v1(191.2,44.69) 187.68,44.69 185.89,42.9 179.64,42.9 177,40.25 168.68,40.25 168.05,40.89 159.83,40.89 158.99,41.73 100.65,41.73 74.69,67.69 73.32,67.69 71.62,69.39 71.59,69.39 69.08,71.9 67.48,71.9 v1(67.02,71.45)
  BOTTOM w0.114: v1(191.2,44.69) 191.2,44.32 191.6,43.91 U45.96 ; v1(29.43,47.11) 31.33,49.02 v3(31.33,56.54) 31.33,57.91 41.97,68.54 56.41,68.54 58.98,71.12 66.69,71.12 v1(67.02,71.45)
USB_CLT1: length 228
  TOP w0.114: v1(22.36,43.79) 22.34,43.81 21.15,43.81 20.91,43.58 U22.6
  IN1 w0.133: v1(204.76,31.59) 204.79,31.57 204.79,29.84 205.7,28.93 205.7,26.36 207.89,24.18 207.89,23.59 209.03,22.45 209.03,20.77 206.21,17.95 198.36,17.95 197.74,17.33 194.92,17.33 190.21,22.04 131.05,22.04 122.62,30.48 99.15,30.48 96.61,27.94 87.24,27.94 86.14,26.84 79.06,26.84 77.25,25.04 73.65,25.04 73.09,25.6 62.37,25.6 58.25,29.71 55.64,29.71 51.8,33.55 51.8,36.95 43.35,45.41 43.35,46.17 43.09,46.43 41.97,46.43 40.86,47.54 36.61,47.54 36.29,47.87 25.69,47.87 22.36,44.55 v1(22.36,43.79)
  BOTTOM w0.114: U45.31 206.96,31.91 206.77,32.1 205.27,32.1 v1(204.76,31.59)
USB_OC0#: length 415.8
  TOP w0.114: v1(19.91,38.9) U22.13
  IN1 w0.127: v1(209.28,102.61) 208.81,102.14 208.81,71.81 212.94,67.69 212.94,66.52 215.35,64.11 215.35,60.05 215.04,59.73 215.04,54.57 212.09,51.62 212.09,49.64 211.55,49.1 211.55,49.1 210.57,48.11 210.57,45.96 209.79,45.19 209.79,43.11 211.9,41 211.9,39.41 210.84,38.35 207.4,38.35 206.34,37.28 205.93,37.28 205.32,36.67 205.32,36.11 205.73,35.71 205.73,33.17 206.39,32.51 206.39,29.66 207.11,28.94 207.11,27.93 208.44,26.6 208.44,25.7 208.81,25.33 208.81,24.4 209.89,23.33 209.89,23.11 210.87,22.13 210.87,20.54 206.84,16.51 198.37,16.51 198.09,16.78 194.63,16.78 189.93,21.48 130.85,21.48 122.42,29.92 99.32,29.92 96.82,27.42 87.66,27.42 86.53,26.28 79.26,26.28 77.46,24.48 73.44,24.48 72.89,25.04 62.17,25.04 58.05,29.16 55.44,29.16 51.24,33.35 51.24,36.75 42.76,45.23 42.58,45.23 42.39,45.42 35.61,45.42 35.01,44.83 31.25,44.83 29.3,42.87 27.6,42.87 27.39,42.67 27.39,42.03 23.58,38.22 21.08,38.22 20.41,38.9 v1(19.91,38.9)
  IN2 w0.127: v1(209.28,102.61) 208.27,101.6 206.51,101.6 204.76,99.84 199.91,99.84 197.9,101.85 197.9,103.88 189.19,112.59 189.19,115.79 188.56,116.43 184.9,116.43 184.19,117.14 184.19,121.92 183.25,122.86 183.25,124.05 182.7,124.6 182.7,124.82 182.36,125.17 182.36,134.44 179.31,137.49 179.31,138.17 178.45,139.04 177.86,139.04 175.81,141.09 175.81,142.11 174.71,143.2 173.42,143.2 169.63,146.99 165.21,146.99 163.79,145.56 161.52,145.56 158.51,142.55 157.6,142.55 156.73,141.67 156.73,141.04 156.68,140.99 v1(156.68,140.71)
  BOTTOM w0.114: U35.A9 152.16,131.57 152.96,132.37 153.9,132.37 155.11,133.58 156.57,133.58 157.83,134.84 157.83,136.26 157.21,136.88 157.21,137.44 157.83,138.05 157.83,138.57 R541.1 157.29,140.35 157.04,140.35 156.68,140.71 v1(156.68,140.71)
USB_OC1#: length 362.7
  TOP w0.114: v1(178.4,125.6) 178.33,125.6 174.59,129.33 173.47,129.33 172.35,130.45 172.35,130.73 170.98,132.1 170.19,132.1 169.29,133 168.35,133 166.1,135.25 v1(165.06,135.25) ; v1(43.26,54.99) 41.1,57.15 29.41,57.15 26.94,54.68 24.79,54.68 U20.3
  IN1 w0.127: v1(178.4,125.6) 178.84,125.16 178.84,125.03 179.9,123.97 179.9,123.07 180.31,122.66 180.31,121.98 180.72,121.57 180.72,121.06 181.38,120.4 181.38,113.24 182.75,111.87 183.11,111.87 184.02,110.96 184.02,109.41 184.92,108.5 184.92,108.17 185.66,107.44 186.07,107.44 186.91,106.6 186.91,93.79 186.03,92.91 186.03,92.52 187.89,90.66 187.89,85.91 191.25,82.55 192.6,82.55 194.19,80.96 195.37,80.96 198.02,78.31 198.02,75.27 199.54,73.75 199.54,67.81 199.73,67.62 199.73,63.08 197.69,61.04 197.69,59.41 197.05,58.77 197.05,56.35 196.24,55.54 196.24,53.42 196.67,52.99 197.42,52.99 198.73,51.68 201.61,51.68 202.27,51.02 202.27,49.75 201.61,49.09 201.61,36.79 202.21,36.19 202.21,34.93 202.85,34.29 203.57,34.29 203.9,33.96 203.9,32.94 203.61,32.65 203.61,30.77 202.06,29.22 202.06,26.4 204.14,24.32 204.14,24.09 205.13,23.1 205.13,22.41 204.69,21.97 203.75,21.97 202.51,20.72 194.75,20.72 194.53,20.95 194.53,22.02 189.31,27.24 173.79,27.24 170.45,30.58 170.45,31.24 167.3,34.39 100.8,34.39 87.41,47.77 83.43,47.77 82.75,48.45 82.75,48.9 74.59,57.07 71.51,57.07 v1(71.08,56.64)
  IN2 w0.127: v1(43.26,54.99) 46.48,58.21 68.34,58.21 69.91,56.64 v1(71.08,56.64)
  BOTTOM w0.114: v1(165.06,135.25) 163.31,135.25 v1(162.34,136.22) 162.34,136.23 160.52,138.05 160.11,138.05 160.02,137.96 160.01,137.95 159.98,137.92 159.92,137.85 159.92,137.21 R540.1 159.47,136.16 158.29,134.98 158.29,134.65 156.65,133.01 155.24,133.01 154.2,131.97 153.13,131.97 152.69,131.52 152.69,130.37 152.41,130.1 152.16,129.85 U35.C9
USB_OC2#: length 203.2
  IN1 w0.127: v1(210.4,23.49) 210.4,23.74 209.38,24.76 209.38,25.27 208.75,25.9 208.75,26.67 207.36,28.06 207.36,29.2 206.69,29.87 206.69,32.61 205.98,33.32 205.98,35.86 205.78,36.06 205.78,36.72 205.96,36.9 206.46,36.9 207.66,38.1 210.95,38.1 212.15,39.3 212.15,41.15 210.05,43.25 210.05,45.08 210.82,45.86 210.82,48 211.81,48.99 211.81,49 212.37,49.56 212.37,51.54 215.29,54.46 215.29,59.62 215.61,59.94 215.61,64.26 213.19,66.67 213.19,67.86 209.18,71.88 209.18,78.02 209.84,78.69 209.84,88.34 209.08,89.1 209.08,101.67 209.77,102.36 209.77,102.87 209.36,103.27 v1(209.18,103.27)
  IN2 w0.127: v1(156.12,140.41) 156.11,140.42 156.11,140.77 156.47,141.14 156.47,141.78 157.5,142.8 158.4,142.8 161.42,145.82 163.66,145.82 165.09,147.24 170.09,147.24 171.74,145.59 172.76,145.59 176.06,142.29 176.06,141.35 178.12,139.29 178.57,139.29 179.57,138.3 179.57,137.61 182.61,134.57 182.61,127.86 183.45,127.02 183.45,125.32 183.2,125.07 183.2,124.51 183.53,124.18 183.53,122.98 184.44,122.07 184.44,117.27 185.03,116.68 188.71,116.68 188.89,116.51 188.89,116.48 189.57,115.79 189.57,112.62 198.08,104.11 198.08,104.09 198.16,104.01 198.16,101.98 200.01,100.12 204.56,100.12 207.71,103.27 v1(209.18,103.27)
  BOTTOM w0.114: U35.D9 151.85,129.3 151.85,131.55 152.88,132.58 153.78,132.58 155.02,133.81 156.48,133.81 157.6,134.93 157.6,136.11 156.98,136.73 156.98,137.66 157.24,137.92 157.24,139.79 156.87,140.15 156.38,140.15 v1(156.12,140.41) 156.12,140.41 155.92,140.61 R543.1 ; U46.3 209.68,24.21 v1(210.4,23.49)
USB_OC3#: length 10.5
  BOTTOM w0.114: U35.B9 152.48,130.62 152.48,131.61 153.05,132.17 154.08,132.17 155.26,133.35 155.93,133.35 155.93,133.35 156.66,133.35 158.06,134.75 158.06,135.07 158.46,135.47 R542.1
USBCOMP: length 5.2
  TOP w0.114: R178.1 v1(156.96,121.03) 156.62,121.03 156.13,120.54 153.93,120.54 v2(153.76,120.37)
  BOTTOM w0.076: v2(153.76,120.37) 153.76,120.08 U35.AB6
USBON#: length 250.6
  TOP w0.114: U20.4 24.79,56.32 24.98,56.13 27.77,56.13 29.04,57.4 31.58,57.4 v1(31.84,57.65) ; v1(217.39,33.9) 217.81,34.33 217.81,44.39 217.38,44.82 216.73,44.82 215.42,46.14 208.97,46.14 208.33,45.49 204.86,45.49 204,46.35 199.2,46.35 198.51,45.66 193.83,45.66 193.33,45.16 v1(193.33,45.02)
  IN1 w0.127: v1(67.65,71.45) 69.15,71.45 71.49,69.11 71.51,69.11 73.19,67.43 74.38,67.43 100.27,41.55 100.44,41.55 100.52,41.47 158.86,41.47 159.7,40.64 167.88,40.64 170.93,37.59 177.45,37.59 178.84,38.98 178.84,41.59 179.9,42.64 186.04,42.64 187.64,44.24 192.56,44.24 v1(193.33,45.02)
  BOTTOM w0.114: v1(193.33,45.02) 193.33,45.16 193.64,45.47 193.64,46.74 193.76,46.86 194.4,46.86 194.71,46.54 U45.99 ; U46.4 209.33,27.1 208.11,28.32 208.11,30.63 208.34,30.86 214.34,30.86 v1(217.39,33.9) ; v1(31.84,57.65) 31.84,57.72 v1(33.62,59.5) 42.44,68.32 56.5,68.32 59.08,70.89 67.09,70.89 v1(67.65,71.45)
USBP0+: length 269.4
  TOP w0.114: v1(23.38,41.75) 23.28,41.65 U22.3
  IN2 w0.127: v5(151.14,120.39) 151.59,120.84 151.92,120.84 152.16,121.08 154.08,121.08 154.26,120.9 161.53,120.9 163.1,122.47 164.88,122.47 166.59,120.77 166.59,120.29 168.11,118.77 168.34,118.77 169.43,117.67 169.43,117.27 170.4,116.3 170.4,116.07 170.75,115.72 170.75,115.03 171.26,114.53 171.84,114.53 172.33,114.04 172.33,112.17 176.64,107.85 176.64,104.04 177.13,103.56 177.13,100.88 176.67,100.43 176.67,98.92 175.86,98.11 175.86,93.62 175.47,93.23 174.98,93.23 174.33,92.58 174.33,91.69 173.44,90.8 172.28,90.8 171.26,89.78 170.25,89.78 169.89,89.43 169.89,88.16 167.26,85.53 167.26,77.78 167.83,77.21 167.83,73.18 169.66,71.35 169.66,62.98 169,62.32 169,53.26 169.66,52.6 169.66,47.5 166.42,44.26 149.28,44.26 148.68,43.65 148.68,43.63 148.55,43.51 98.34,43.51 98.31,43.48 97.72,43.48 86.88,54.33 76.95,54.33 71.26,60.02 48.48,60.02 48.15,59.69 45.17,59.69 38.82,53.34 38.82,51.18 31.08,43.43 23.56,43.43 22.95,42.82 22.95,41.88 23.08,41.75 v1(23.38,41.75)
  BOTTOM w0.114: U35.AB10 151.14,120.1 v5(151.14,120.39)
USBP0+_C: length 17.4
  TOP w0.114: U22.10 17.9,41.65 v1(17.72,41.83) ; v1(20.86,31.77) 20.81,31.83 19.61,31.83 R386.2
  IN2 w0.127: v1(20.86,31.77) 20.26,31.77 19.01,33.02 19.01,33.77 18.51,34.28 17.47,34.28 15.84,35.91 15.84,41.14 16.52,41.83 v1(17.72,41.83)
USBP0+_R: length 8.4
  TOP w0.114: R386.1 18.37,31.75 18,32.11 17.67,32.11 17.6,32.04 17.6,30.52 17.22,30.14 17.18,30.14 17.02,29.98 U24.7 16.6,29.98 16.44,30.14 15.39,30.14 15.34,30.09 14.7,30.09 14.2,29.6 13.65,29.6 13.11,29.06 CN16.3
USBP0-: length 269.4
  TOP w0.114: v1(23.35,40.84) 23.35,41 23.2,41.15 U22.2
  IN2 w0.127: v2(151.85,120.39) 152.29,120.82 153.97,120.82 154.15,120.65 161.63,120.65 163.21,122.22 164.78,122.22 166.33,120.67 166.33,120.19 168.01,118.51 168.23,118.51 169.18,117.57 169.18,117.16 170.14,116.2 170.14,115.97 170.5,115.61 170.5,114.93 171.16,114.27 171.74,114.27 172.07,113.94 172.07,112.07 176.39,107.75 176.39,103.93 176.87,103.45 176.87,100.99 176.42,100.53 176.42,99.03 175.6,98.21 175.6,93.72 175.36,93.48 174.88,93.48 174.08,92.68 174.08,91.8 173.34,91.05 172.17,91.05 171.16,90.04 170.14,90.04 169.63,89.53 169.63,88.26 167,85.63 167,77.68 167.58,77.11 167.58,73.08 169.41,71.25 169.41,63.09 168.74,62.43 168.74,53.16 169.41,52.5 169.41,47.6 166.31,44.51 149.17,44.51 148.42,43.76 98.21,43.76 98.18,43.73 97.83,43.73 86.98,54.58 77.05,54.58 71.36,60.27 48.37,60.27 48.04,59.94 45.05,59.94 38.57,53.46 38.57,51.28 30.97,43.68 23.46,43.68 22.69,42.92 22.69,41.78 23.35,41.12 v1(23.35,40.84)
  BOTTOM w0.114: v2(151.85,120.39) 151.65,120.19 151.65,120.06 151.95,119.76 U35.AB9
USBP0-_C: length 17.4
  TOP w0.114: R385.2 19.73,32.56 v1(20.87,32.56) ; U22.11 18.47,41.15 18.22,41.41 18,41.41 17.72,41.12 v1(17.72,41.07)
  IN2 w0.127: v1(20.87,32.56) 20.87,32.4 20.49,32.02 20.36,32.02 19.27,33.12 19.27,33.88 18.62,34.53 17.58,34.53 16.09,36.01 16.09,41.04 16.63,41.58 17.34,41.58 17.72,41.2 v1(17.72,41.07)
USBP0-_R: length 8.4
  TOP w0.114: CN16.2 13.11,30.15 13.42,29.84 14.1,29.84 14.65,30.38 U24.4 17.12,30.38 17.35,30.62 17.35,32.14 17.57,32.36 17.97,32.36 18.37,32.76 R385.1
USBP1+: length 258.1
  TOP w0.114: R348.2 23.33,47.24 23.6,47.5 24.17,47.5 v1(24.35,47.32)
  IN2 w0.127: v1(24.35,47.32) 24.35,47.87 23.96,48.26 23.76,48.26 23.52,48.02 23.52,47.3 24.22,46.6 29.02,46.6 29.91,45.72 31.99,45.72 36.41,50.14 36.41,52.3 44.74,60.63 47.51,60.63 47.84,60.96 71.82,60.96 77.43,55.34 87.21,55.34 98.11,44.45 100.16,44.45 102.06,46.34 163.02,46.34 164.55,47.87 165.72,47.87 167.28,49.44 167.28,49.7 168.03,50.45 168.03,51.89 167.37,52.55 167.37,63.04 168.03,63.7 168.03,70.68 166.14,72.57 166.14,76.6 165.63,77.11 165.63,87.67 169.45,91.49 170.42,91.49 173.57,94.64 173.57,98.15 174.21,98.78 174.21,106.95 173.95,107.21 173.95,108.04 172.41,109.58 172.16,109.58 170.17,111.58 170.17,112.57 169.58,113.15 168.89,113.15 166.74,115.31 166.74,116.86 166.66,116.93 166.66,116.94 165.87,117.72 165.11,117.72 164,118.84 162.45,118.84 161.84,118.23 160.54,118.23 159.68,117.37 158.08,117.37 157.21,118.23 156.55,118.23 156.35,118.44 154.87,118.44 154.53,118.78 153.95,118.78 153.51,119.22 v2(153.51,119.22)
  BOTTOM w0.114: U35.AD7 153.59,118.7 153.71,118.82 153.71,119.02 v2(153.51,119.22)
USBP1+_R: length 10.8
  TOP w0.114: CN13.3 13.83,47.42 14.51,47.42 15.31,46.61 17.76,46.61 17.88,46.49 U21.7 19.08,46.49 19.18,46.6 19.18,46.61 20.5,47.93 21.5,47.93 21.66,47.77 21.66,47.42 21.76,47.32 22.09,47.32 R348.1
USBP1-: length 258.1
  TOP w0.114: v1(24.35,48.51) 24.01,48.17 23.42,48.17 23.33,48.26 R342.2
  IN2 w0.127: v1(24.35,48.51) 23.66,48.51 23.27,48.12 23.27,47.19 24.11,46.35 28.92,46.35 29.81,45.46 32.09,45.46 36.66,50.03 36.66,52.19 44.84,60.37 47.61,60.37 47.94,60.7 71.71,60.7 77.33,55.09 87.11,55.09 98.01,44.19 100.27,44.19 102.16,46.09 163.12,46.09 164.66,47.62 165.82,47.62 167.54,49.34 167.54,49.6 168.29,50.35 168.29,51.99 167.63,52.65 167.63,62.93 168.29,63.59 168.29,70.78 166.4,72.68 166.4,76.71 165.89,77.22 165.89,87.56 169.56,91.23 170.52,91.23 173.82,94.53 173.82,98.04 174.46,98.67 174.46,107.06 174.21,107.31 174.21,108.15 172.52,109.84 172.27,109.84 170.42,111.68 170.42,112.67 169.69,113.41 169,113.41 166.99,115.41 166.99,116.96 166.92,117.04 166.92,117.04 165.98,117.98 165.22,117.98 164.1,119.1 162.34,119.1 161.73,118.49 160.44,118.49 159.58,117.62 158.18,117.62 157.32,118.49 156.66,118.49 156.46,118.69 154.98,118.69 154.64,119.03 154.32,119.03 v5(154.13,119.22)
  BOTTOM w0.114: v5(154.13,119.22) 154.08,119.17 U35.AD6
USBP1-_R: length 10.8
  TOP w0.114: CN13.2 13.11,48.06 13.51,47.66 14.61,47.66 15.37,46.89 U21.4 17.87,46.89 17.98,46.78 19.01,46.78 20.4,48.17 22.09,48.17 R342.1
USBP3+: length 172
  IN2 w0.127: v1(151.6,119.25) 152.29,119.93 154.75,119.93 155.18,119.5 155.66,119.5 156.2,120.04 164.18,120.04 164.53,119.68 166.18,119.68 168.03,117.83 168.03,116.94 167.83,116.73 167.83,115.85 168.11,115.57 168.11,115.57 169,114.68 169.51,114.68 171.11,113.08 171.11,111.97 172.37,110.7 172.62,110.7 174.49,108.83 174.69,108.83 175.79,107.73 175.79,101.47 175.67,101.34 175.67,98.89 175.03,98.25 175.03,94.74 170.83,90.55 169.86,90.55 166.57,87.26 166.57,77.5 167.08,76.99 167.08,72.96 168.97,71.07 168.97,63.29 168.31,62.63 168.31,52.96 168.97,52.3 168.97,50.06 168.22,49.31 168.22,47.76 v1(168.19,47.72)
  BOTTOM w0.114: v1(151.6,119.25) 151.6,118.82 U35.AD10 ; v1(168.19,47.72) 168.08,47.62 167.47,47.62 167.22,47.37 167.22,46.52 168.94,44.8 168.94,35.68 173.8,30.82 178.43,30.82 179.95,29.29 185.78,29.29 186.07,29 189.13,29 193.08,25.05 193.81,25.05 194.49,24.37 194.49,22.98 195.58,21.88 196.89,21.88 197.76,21.02 197.76,17.97 198.05,17.68 198.05,16.71 198.82,15.94 214.37,15.94 215.13,16.7 215.13,17.2 215.38,17.45 216.22,17.45 CN22.8
USBP3-: length 172
  IN2 w0.127: v1(168.21,47.04) 167.86,47.04 167.63,47.27 167.63,47.81 167.97,48.15 167.97,49.42 168.72,50.17 168.72,52.19 168.06,52.85 168.06,62.73 168.72,63.39 168.72,70.96 166.83,72.85 166.83,76.89 166.32,77.4 166.32,87.36 169.76,90.8 170.73,90.8 174.78,94.85 174.78,98.36 175.41,98.99 175.41,101.45 175.54,101.57 175.54,107.63 174.59,108.58 174.39,108.58 172.52,110.45 172.26,110.45 170.85,111.86 170.85,112.97 169.4,114.42 168.89,114.42 167.81,115.51 167.81,115.51 167.58,115.74 167.58,116.86 167.78,117.06 167.78,117.72 166.08,119.43 164.43,119.43 164.07,119.78 156.3,119.78 155.77,119.25 155.08,119.25 154.64,119.68 152.44,119.68 152.26,119.5 v5(152.26,119.25)
  BOTTOM w0.114: U35.AD9 151.98,118.85 151.98,119.09 152.14,119.25 v5(152.26,119.25) ; v1(168.21,47.04) 168.21,47.1 167.93,47.38 167.57,47.38 167.46,47.27 167.46,46.62 169.18,44.9 169.18,35.78 173.9,31.06 178.53,31.06 180.05,29.54 185.88,29.54 186.17,29.24 189.23,29.24 193.18,25.29 193.91,25.29 194.73,24.47 194.73,23.08 195.68,22.13 196.99,22.13 198,21.12 198,18.07 198.29,17.78 198.29,16.81 198.92,16.18 214.27,16.18 214.88,16.8 214.88,17.3 215.33,17.74 215.33,17.89 215.38,17.95 CN22.7
USBP4+: length 33.4
  IN2 w0.127: v1(173.57,106.02) 173.42,105.86 173.16,105.86 172.45,105.15 172.12,105.15 171.84,105.43 171.84,109.22 169.24,111.82 168.66,111.82 167.95,112.53 164.48,112.53 163.39,113.62 162.79,113.62 162.32,114.09 160.21,114.09 159.32,114.98 159.32,115.72 158.84,116.2 157.92,116.2 157.9,116.18 157.69,116.18 157.34,115.82 v5(157.34,115.34)
  BOTTOM w0.114: v1(173.57,106.02) 173.7,105.89 175.74,105.89 178,108.15 179.12,108.15 179.2,108.23 CN10.3 ; v5(157.34,115.34) 157.19,115.18 156.47,115.18 U35.AJ2
USBP4-: length 33.3
  IN2 w0.127: v1(173.57,105.36) 173.32,105.61 173.27,105.61 172.55,104.9 172.02,104.9 171.59,105.33 171.59,109.11 169.14,111.56 168.56,111.56 167.84,112.28 164.38,112.28 163.28,113.37 162.68,113.37 162.21,113.84 160.11,113.84 159.07,114.88 159.07,115.61 158.73,115.95 158.03,115.95 158,115.92 157.8,115.92 157.7,115.82 157.7,115.62 v1(157.98,115.34)
  BOTTOM w0.114: v1(157.98,115.34) 157.49,115.82 157.13,115.82 U35.AJ1 ; CN10.5 179.2,107.72 179.02,107.9 178.1,107.9 175.84,105.65 173.81,105.65 173.57,105.41 v1(173.57,105.36)
USBP5+: length 175.5
  TOP w0.114: v1(141.44,199.51) 141.05,199.12 141.05,198.75 141.29,198.51 R4.1
  IN2 w0.127: v1(141.44,199.51) 141.19,199.77 141.19,200.4 141.44,200.66 141.72,200.66 142.07,200.3 142.07,196.32 140.69,194.93 140.59,194.93 134.76,189.1 133.84,189.1 132.19,187.45 131.45,187.45 127.11,183.11 127.11,175.93 124,172.82 119.01,172.82 118.44,172.25 118.44,171.67 118.87,171.23 118.87,154.79 119.88,153.78 120.65,153.78 120.96,153.46 129.07,153.46 131.76,150.77 139.76,150.77 143.43,147.1 143.43,145.96 144.87,144.52 146.02,144.52 147.07,145.58 149.15,145.58 149.97,144.75 149.97,144.29 v1(149.82,144.14) ; v1(164.12,116.3) 164.12,116.56 163.97,116.71 163.77,116.71 163,115.95 162.29,115.95 161.6,116.63 157.72,116.63 157.72,116.63 157.7,116.61 156.98,116.61 156.58,117.01 156.58,117.04 156.07,117.55 155.97,117.55 155.77,117.75 155.13,117.75 154.98,117.6 153.63,117.6 v2(153.12,118.11)
  BOTTOM w0.076: v2(153.12,118.11) 153.43,117.8 U35.AF7
  BOTTOM w0.114: v1(164.12,116.3) 164.12,116.4 164.52,116.8 164.52,116.89 164.77,117.14 166.65,117.14 166.84,116.95 167.63,116.95 168.02,117.34 169.39,117.34 169.77,116.95 170.04,116.95 170.55,117.46 172.18,117.46 173.59,118.87 175.52,118.87 176.57,119.93 176.57,123.82 177.3,124.54 177.3,128.63 176.65,129.28 176.65,130.44 174.9,132.2 174.9,134.5 173.97,135.42 171.16,135.42 170.22,136.36 166.99,136.36 166.64,136.01 166.04,136.01 165.69,136.36 163.74,136.36 161.32,138.78 161.32,140.91 160.01,142.21 157.89,142.21 156.41,143.68 151.78,143.68 151.49,143.39 150.23,143.39 150.01,143.61 150.01,143.95 v1(149.82,144.14)
USBP5-: length 175.5
  TOP w0.114: v1(140.55,199.51) 140.8,199.26 140.8,198.76 R3.1
  IN2 w0.127: v1(164.76,116.4) 164.63,116.43 164.1,116.96 163.66,116.96 162.9,116.2 162.39,116.2 161.71,116.89 157.48,116.89 157.47,116.87 157.47,116.86 157.11,116.86 156.83,117.14 156.83,117.17 156.2,117.8 156.07,117.8 155.87,118 155,118 154.85,117.85 154.01,117.85 v1(153.76,118.11) ; v1(140.55,199.51) 140.93,199.89 140.93,200.51 141.33,200.91 141.82,200.91 142.33,200.4 142.33,196.21 140.79,194.67 140.69,194.67 134.87,188.84 133.95,188.84 132.3,187.19 131.56,187.19 127.37,183 127.37,175.83 124.1,172.57 119.12,172.57 118.69,172.14 118.69,171.77 119.13,171.34 119.13,154.9 119.99,154.03 120.75,154.03 121.07,153.72 129.18,153.72 131.87,151.02 139.87,151.02 143.69,147.21 143.69,146.06 144.97,144.78 145.91,144.78 146.96,145.83 149.25,145.83 150.23,144.86 150.23,144.37 v1(150.46,144.14)
  BOTTOM w0.076: v1(153.76,118.11) 153.76,118.06 154.08,117.73 U35.AF6
  BOTTOM w0.114: v1(164.76,116.4) 164.76,116.79 164.87,116.9 166.55,116.9 166.74,116.71 167.73,116.71 168.12,117.1 169.29,117.1 169.67,116.71 170.14,116.71 170.65,117.22 172.28,117.22 173.69,118.63 175.62,118.63 176.82,119.83 176.82,123.72 177.54,124.44 177.54,128.73 176.89,129.38 176.89,130.54 175.14,132.3 175.14,134.6 174.07,135.66 171.26,135.66 170.32,136.6 166.89,136.6 166.54,136.25 166.14,136.25 165.79,136.6 163.84,136.6 161.56,138.88 161.56,141.01 160.11,142.45 157.99,142.45 156.51,143.93 151.68,143.93 151.39,143.63 150.33,143.63 150.25,143.71 150.25,143.94 v1(150.46,144.14)
USBP6+: length 167.5
  TOP w0.114: v1(132.82,197.63) 133.03,197.84 133.2,197.84 R2.1
  IN2 w0.127: v1(132.82,197.63) 133.08,197.89 137.02,197.89 137.96,196.94 137.96,193.54 134.28,189.86 133.46,189.86 131.94,188.34 131.35,188.34 127.42,184.4 120.76,184.4 116.56,180.2 116.56,175.9 117.18,175.28 117.18,172.71 117.75,172.14 117.75,171.38 118.16,170.97 118.16,154.39 119.91,152.64 120.7,152.64 120.84,152.78 128.77,152.78 131.46,150.08 138.95,150.08 142.16,146.87 142.16,146.05 144.38,143.84 146.35,143.84 147.13,144.62 147.99,144.62 148.09,144.52 148.09,144.34 v1(147.89,144.14)
  BOTTOM w0.114: U35.AH2 156.18,116.51 159.31,116.51 159.87,117.06 160.54,117.06 160.86,117.38 161.74,117.38 162.18,117.83 163.72,117.83 163.77,117.78 164.45,117.78 164.49,117.81 166.41,117.81 166.94,118.35 167.47,118.35 167.7,118.12 171.91,118.12 173.36,119.57 173.93,119.57 174.35,119.98 174.35,120.87 175.91,122.44 175.91,124.09 176.64,124.81 176.64,128.29 175.97,128.95 175.97,130.19 174.22,131.94 174.22,132.57 172.67,134.12 171.35,134.12 170.32,135.15 170.32,135.33 169.95,135.7 167.26,135.7 166.81,135.25 165.87,135.25 165.41,135.7 163.46,135.7 162.76,136.4 162.76,136.4 162.51,136.65 162.51,136.65 160.65,138.51 160.65,140.64 159.74,141.54 157.61,141.54 156.25,142.91 152.15,142.91 151.87,142.63 148.72,142.63 148.09,143.25 148.09,143.94 v1(147.89,144.14)
USBP6+_R: length 7.8
  TOP w0.114: R2.2 134.73,197.87 135.11,197.87 135.36,197.62 135.36,196.86 136.68,195.54 136.68,194.83 v1(136.49,194.64)
  BOTTOM w0.114: CN5.14 138.02,193.56 137.87,193.56 137.12,194.31 136.82,194.31 v1(136.49,194.64)
USBP6-: length 167.5
  TOP w0.114: R1.1 133.11,198.05 133.03,198.05 v1(132.82,198.26)
  IN2 w0.127: v1(132.82,198.26) 132.94,198.14 137.12,198.14 138.21,197.05 138.21,193.44 134.38,189.61 133.57,189.61 132.04,188.08 131.46,188.08 127.52,184.15 120.87,184.15 116.81,180.09 116.81,176 117.44,175.38 117.44,172.82 118.01,172.25 118.01,171.49 118.41,171.08 118.41,154.49 120.02,152.89 120.6,152.89 120.74,153.03 128.87,153.03 131.56,150.34 139.05,150.34 142.42,146.97 142.42,146.16 144.49,144.09 146.24,144.09 147.03,144.88 148.09,144.88 148.35,144.62 148.35,144.32 v1(148.53,144.14)
  BOTTOM w0.114: U35.AH1 156.62,116.3 159.4,116.3 159.92,116.82 160.64,116.82 160.96,117.14 161.84,117.14 162.28,117.59 163.62,117.59 163.67,117.53 164.55,117.53 164.59,117.57 166.51,117.57 167.04,118.11 167.37,118.11 167.6,117.88 172.01,117.88 173.46,119.33 174.03,119.33 174.59,119.88 174.59,120.77 176.16,122.34 176.16,123.99 176.88,124.71 176.88,128.39 176.21,129.05 176.21,130.29 174.46,132.04 174.46,132.67 172.77,134.36 171.45,134.36 170.56,135.25 170.56,135.43 170.05,135.94 167.16,135.94 166.71,135.49 165.97,135.49 165.51,135.94 163.56,135.94 163,136.5 163,136.5 162.61,136.89 162.61,136.89 160.89,138.61 160.89,140.74 159.84,141.79 157.71,141.79 156.35,143.15 152.05,143.15 151.77,142.87 148.82,142.87 148.34,143.35 148.34,143.95 v1(148.53,144.14)
USBP6-_R: length 7.8
  TOP w0.114: R1.2 134.74,198.09 135.2,198.09 135.57,197.71 135.57,196.95 136.89,195.63 136.89,194.99 v1(137.12,194.76)
  BOTTOM w0.114: CN5.13 138.48,193.8 137.97,193.8 137.12,194.65 v1(137.12,194.76)
USBP7+: length 221.6
  TOP w0.114: U26.3 58,25.72 58.33,26.05 v1(58.33,26.58)
  IN2 w0.127: v2(151.85,118.11) 152.11,117.85 152.11,117.8 153.07,116.84 154.85,116.84 155.06,116.63 155.95,116.63 156.64,115.93 156.64,114.97 156.64,114.97 156.64,114.16 157.82,112.98 159.02,112.98 160.11,111.88 161.76,111.88 162.67,110.97 165.44,110.97 165.97,111.5 167.24,111.5 167.88,110.87 168.86,110.87 169,110.73 169,110.73 169.3,110.43 169.27,110.39 169.27,109.82 169.3,109.78 169.25,109.73 169.25,109.52 170.9,107.87 170.9,105.02 172.04,103.88 172.96,103.88 173.27,103.57 173.27,98.88 172.75,98.36 172.75,97.71 171.97,96.94 171.97,94.01 170.13,92.17 168.97,92.17 168.31,91.51 167.66,91.51 164.95,88.8 164.95,76.83 165.46,76.32 165.46,71.61 167.35,69.71 167.35,64.01 166.69,63.35 166.69,52.24 167.35,51.58 167.35,50.74 166.6,49.99 166.6,49.77 166.1,49.27 164.68,49.27 162.68,47.27 101.48,47.27 99.42,45.21 99,45.21 98.85,45.36 98.85,45.54 v1(98.89,45.59)
  BOTTOM w0.114: v2(151.85,118.11) 152.13,117.83 U35.AF9 ; v1(98.89,45.59) 98.82,45.51 98.82,45 96.48,42.67 96.48,30.82 92.75,27.09 89.77,27.09 88.39,25.7 88.39,25.7 88.14,25.46 88.14,25.45 87.04,24.35 64.03,24.35 63.25,25.14 58.94,25.14 58.33,25.76 v1(58.33,26.58)
USBP7-: length 221.7
  TOP w0.114: U26.2 58.5,25.76 58.89,26.16 v1(58.89,26.28)
  IN2 w0.127: v1(98.26,45.59) 98.89,44.95 99.53,44.95 101.59,47.01 162.78,47.01 164.79,49.02 166.2,49.02 166.85,49.67 166.85,49.88 167.6,50.63 167.6,51.69 166.94,52.35 166.94,63.24 167.6,63.9 167.6,69.82 165.71,71.71 165.71,76.42 165.2,76.93 165.2,88.7 167.76,91.26 168.42,91.26 169.08,91.92 170.24,91.92 172.22,93.9 172.22,96.83 173,97.61 173,98.26 173.52,98.78 173.52,103.68 173.06,104.14 172.15,104.14 171.16,105.13 171.16,107.98 169.51,109.63 169.51,109.63 169.62,109.74 169.62,109.82 169.52,109.92 169.52,110.29 169.62,110.39 169.62,110.47 169.11,110.98 169.11,110.98 168.97,111.12 167.98,111.12 167.35,111.76 165.87,111.76 165.33,111.22 162.78,111.22 161.86,112.14 160.21,112.14 159.12,113.23 157.93,113.23 156.9,114.26 156.9,114.86 156.9,116.04 156.05,116.88 155.16,116.88 154.95,117.09 153.17,117.09 152.36,117.9 152.36,117.99 v2(152.48,118.11)
  BOTTOM w0.114: v2(152.48,118.11) 152.48,117.86 152.7,117.63 U35.AF8 ; v1(98.26,45.59) 98.58,45.27 98.58,45.1 96.24,42.77 96.24,30.92 92.65,27.33 89.87,27.33 89.67,27.33 88.29,25.95 88.29,25.95 87.9,25.56 87.9,25.55 86.94,24.6 64.13,24.6 63.35,25.38 59.04,25.38 58.57,25.86 58.57,26.18 58.67,26.28 v1(58.89,26.28)
USBPWR0:
  vias: v1(13.98,31.47) v1(14.24,38.05) v1(14.24,37.41) v1(14.31,32.01) v1(14.9,38.05) v1(14.9,37.41) v3(15.68,36.5)
USBPWR1:
  vias: v1(14.57,51.81) v1(14.57,50.92) v1(17.69,52.02) v1(17.69,51.35) v3(21.55,54.28)
USBPWR2:
  vias: v3(215.13,24.53)
V_BLIGHT:
  vias: v1(126.96,187.7) v1(127.6,187.7) v1(127.6,187.07) v3(125.06,187.85)
VA: length 13.2
  BOTTOM w0.508: 218.53,196.72 218.53,198.37 215.48,201.42 210.17,201.42 v3(210.1,201.34) 209.55,200.79 PR168.1
  vias: v4(219.57,196.92) v4(219.57,196.03) v4(220.46,196.92) v4(220.46,196.03) v4(221.35,196.92) v4(221.35,196.03)
VA1: length 18.2
  TOP w0.508: PR5.2 200.81,195.09 201.72,194.18 202.37,194.18 203.1,193.46 203.1,193.15 203.47,192.78 204.36,192.78 205.02,192.12 207.38,192.12 207.86,191.64 208.8,191.64 209.18,191.26 211.72,191.26 213.88,189.1 216.12,189.1
  vias: v3(216.98,187.98) v4(218.91,189.35) v4(218.88,188.16) v4(219.49,188.72)
VA2: length 31.2
  IN2 w0.254: v1(204.56,201.42) 204.71,201.57 207.72,201.57 208.76,200.53 209.51,200.53 209.99,200.05 209.99,193.12 213.19,189.92 213.19,186.79 216.37,183.61 v1(216.37,182.75)
  BOTTOM w0.178: PR210.2 219.42,178.55 219.42,178.2 219.79,177.83 222.32,177.83 222.47,177.97 PR213.1
  BOTTOM w0.508: v1(204.56,201.42) 204.69,201.29 204.69,201.17 PR166.1
  vias: v3(222.85,181.94)
VCORE_SENSE: length 94.7
  TOP w0.114: PR33.1 137.05,181.53 137.05,179.5 138.3,178.25 138.7,178.25 v3(139.1,177.85) 139.56,178.3 139.79,178.3 v1(139.92,178.18) ; R96.2 147.51,143.67 147.51,143.23 v1(147.69,143.05)
  IN2 w0.127: v1(139.92,178.18) 139.92,178.08 139.97,178.02 140.65,178.02 141.82,176.86 150.84,176.86 151.45,176.25 152.57,176.25 153.23,175.59 153.71,175.59 157.73,171.57 161.92,171.57 164.17,169.32 164.17,159.35 163.79,158.97 163.79,154.05 161.57,151.82 158.32,151.82 155.73,149.23 155.73,148.44 151.4,144.11 151.4,143.84 150.69,143.13 147.77,143.13 v1(147.69,143.05) 147.49,143.05 146.98,142.54 145.56,142.54 136.69,133.67 136.69,132.36 137.63,131.42 137.63,130.17 138.67,129.13 138.67,128.83 v2(139.05,128.44)
  BOTTOM w0.114: U35.E32 138.83,128.22 v2(139.05,128.44)
VCORESS_SENSE: length 93.8
  TOP w0.114: R98.1 146.77,143.12 v1(147.03,143.38) ; v1(139.92,178.81) 139.78,178.67 139.55,178.67 v3(139.1,179.12) 138.61,178.62 138.46,178.62 137.42,179.66 137.42,181.29 137.5,181.38 137.61,181.38 PR38.1
  IN2 w0.127: v1(139.92,178.81) 139.59,178.81 139.41,178.63 139.41,178.05 139.81,177.64 140.49,177.64 141.66,176.48 150.68,176.48 151.29,175.87 152.41,175.87 153.07,175.21 153.56,175.21 157.57,171.19 161.76,171.19 163.79,169.16 163.79,159.51 163.41,159.13 163.41,154.2 161.41,152.21 158.16,152.21 155.35,149.39 155.35,148.6 151.02,144.27 151.02,143.99 150.53,143.51 147.36,143.51 147.23,143.38 v1(147.03,143.38) 147.03,143.13 146.82,142.92 145.4,142.92 136.31,133.83 136.31,132.2 137.25,131.26 137.25,130.01 138.29,128.97 138.29,128.67 v2(138.14,128.52)
  BOTTOM w0.114: v2(138.14,128.52) 137.99,128.52 U35.E33
VGA_MBCLK: length 18.5
  IN1 w0.076: 155.13,123.16 154.9,122.93 152.82,122.93 v2(152.44,122.55)
  IN1 w0.127: v1(168.31,124.56) 167.75,125.12 162.75,125.12 161.49,123.86 159,123.86 158.31,123.16 155.13,123.16
  BOTTOM w0.114: R582.2 167.9,124.97 v1(168.31,124.56) ; 152.42,122.58 152.13,122.86 U35.R9
  BOTTOM w0.127: 152.42,122.58 v2(152.44,122.55)
VGA_MBDATA: length 5.2
  BOTTOM w0.076: 159.15,121.35 158.98,121.35 158.66,121.03 157.31,121.03 157.19,121.15 156.51,121.15 U35.W2
  BOTTOM w0.114: R585.2 160.92,121.36 159.17,121.36 159.15,121.35
VGA_OVT#: length 20.8
  TOP w0.114: Q16.1 196.28,137.18 v1(197.02,137.92) 196.93,138 R111.1
  BOTTOM w0.114: U34.A6 193.03,149.76 193.65,149.14 193.65,149.12 194.54,148.23 194.54,145.49 193.71,144.67 193.71,143.23 192.54,142.06 192.54,140.31 192.77,140.08 192.77,138.39 192.97,138.19 194.1,138.19 v1(194.58,137.71) 194.63,137.66 196.48,137.66 196.74,137.92 v1(197.02,137.92)
VGA_RST: length 3.4
  TOP w0.114: U13.3 18.77,109.58 18.71,109.65 17.82,109.65 v1(17.74,109.72) 17.61,109.85 17.36,109.85 16.88,110.33 R206.2
VGA_RST#: length 9.8
  TOP w0.114: C134.1 168.06,149.6 v1(167.63,149.17) 167.29,148.83 R86.2
  BOTTOM w0.114: U34.AC7 174.55,151.42 174.18,151.06 173.08,151.06 172.81,150.8 172.81,150.47 172.58,150.24 172.33,150.24 172.05,149.96 171.67,149.96 170.88,149.17 v1(167.63,149.17)
VGA_VCCSENSE: length 12.7
  TOP w0.406: v1(187.31,138.07) PR61.2 186.5,136.58 R123.2
  IN2 w0.457: v1(187.31,138.07) 187.39,138.15 187.39,143.05 187.97,143.63 187.97,146.35 188.53,146.91 v1(188.53,146.93)
  BOTTOM w0.406: v1(188.53,146.93) 188.55,146.93 U34.F2
VGA_VSSSENSE: length 11.7
  TOP w0.406: R124.1 189.39,136.77 189.19,136.58 PR62.2 188.48,136.72 188.1,137.11 v1(188.1,138.07)
  IN2 w0.457: v1(188.68,145.97) 188.68,143.34 188.1,142.75 v1(188.1,138.07)
  BOTTOM w0.406: v1(188.68,145.97) 188.68,146.17 188.93,146.42 U34.F1
VGPU_EN: length 66.3
  TOP w0.114: R220.1 v1(175.09,106.8) ; PR111.1 196.1,103.3 v1(196.05,103.25) ; v1(192.24,102.99) 191.78,103.46 191.78,104.02 189.2,106.59 187.17,106.59 186.14,107.62 183.81,107.62 183.22,108.21 183.22,109.11 182.77,109.56 182.77,110.79 v1(182.66,110.89) ; R196.1 161.79,113.84 159.36,113.84 v1(159.18,114.02)
  IN1 w0.127: v1(175.09,106.8) 175.22,106.93 175.22,107.95 174.41,108.76 174.41,112.62 174.83,113.04 174.83,114.84 174.32,115.35 173.48,115.35 173.22,115.08 171.03,115.08 170.5,114.55 159.72,114.55 v1(159.18,114.02) 158.49,113.32 157.75,113.32 157.32,112.9 154.39,112.9 154.01,112.52 153.63,112.52 152.72,113.43 v1(152.72,113.71)
  BOTTOM w0.076: U35.AN8 152.4,114.03 v1(152.72,113.71)
  BOTTOM w0.114: v1(175.09,106.8) 177.25,108.96 v3(177.69,108.96) 177.76,108.96 179.41,110.61 181.14,110.61 181.37,110.84 182.56,110.84 182.61,110.89 v1(182.66,110.89) ; v1(196.05,103.25) 195.8,102.99 v3(193.87,102.99) v1(192.24,102.99)
VL: length 72
  TOP w0.254: v1(61.1,74.09) 62.83,75.81 70.55,75.81 70.96,75.4 PR144.1 71.07,74.94 PR146.1
  TOP w0.508: v1(79.57,45.61) 77.76,45.61 v3(77.51,45.87) 76.52,45.87 76.29,46.1 76.29,46.12 72.28,50.14 70.55,50.14 69.83,49.42 66.24,49.42 65.88,49.78 v1(65.88,51.13)
  IN1 w0.254: v1(83.71,48.84) 83.71,49.12 71.34,61.49 70.02,61.49 62.27,69.24 62.27,72.92 v1(61.1,74.09)
  IN2 w0.508: v1(79.57,45.61) 82.79,48.84 v1(83.71,48.84)
  BOTTOM w0.203: v1(65.88,51.13) 65.77,51.23 PU6010.13
VMA_CLK0: length 80.7
  TOP w0.114: U4.J7 202.07,167.14 202.21,167.28 202.49,167.28 202.64,167.12 202.64,166.96 202.58,166.9 202.58,166.43 202.83,166.17 203.16,166.17 v1(203.39,165.94) ; R75.1 208.83,157.78 208.83,164.8 209.26,165.22 209.57,165.22 v1(209.79,165) ; v1(215.62,166.94) 215.62,166.97 215.39,167.2 214.63,167.2 214.57,167.26 214.18,167.26 U5.J7
  IN1 w0.127: v1(215.62,166.94) 215.4,167.16 214.33,167.16 213.73,167.76 212.36,167.76 212.1,167.51 212.1,167 211.17,166.07 211.17,165.6 210.81,165.23 210.02,165.23 v1(209.79,165) 209.75,165.05 209.21,165.05 208.88,164.71 208.19,164.71 208.06,164.59 208.06,163.86 208.19,163.74 210.14,163.74 210.27,163.87 210.27,164.37 210.57,164.66 211.09,164.66 211.39,164.37 211.39,162.94 211.09,162.64 207.99,162.64 207.86,162.52 207.86,162.14 208.09,161.91 208.09,160.85 207.94,160.7 207.94,159.72 206.9,158.68 206.9,157.03 206.58,156.71 199.68,156.71 198.79,157.6 198.79,158.53 196.16,161.16 193.74,161.16 193.56,160.98 193.56,157.79 193.3,157.53 192.63,157.53 192.37,157.79 192.37,160.93 191.71,161.59 191.71,165.07 191.33,165.45 191.17,165.45 191.04,165.31 v1(191.04,165.09)
  IN2 w0.127: v1(209.79,165) 209.64,165.16 209.13,165.16 208.79,164.82 208.07,164.82 206.64,166.25 203.69,166.25 v1(203.39,165.94)
  BOTTOM w0.114: v1(191.04,165.09) 190.63,165.49 U34.D24 ; v1(215.62,166.94) 215.83,167.15 216,167.15 216.13,167.02 216.48,167.02 216.78,167.31 216.95,167.31 217.14,167.13 U32.J7 ; v1(203.39,165.94) 203.66,166.21 203.83,166.21 204.89,167.26 205.07,167.26 205.27,167.06 U31.J7
VMA_CLK0#: length 81.1
  TOP w0.114: R75.2 208.62,157.73 208.62,164.89 209.17,165.44 209.56,165.44 v1(209.79,165.66) ; U5.K7 214.28,167.48 214.66,167.48 214.72,167.42 215.49,167.42 v1(215.65,167.58) ; v1(203.36,166.6) 203.15,166.39 202.92,166.39 202.79,166.52 202.79,166.81 202.86,166.87 202.86,167.21 202.58,167.49 202.27,167.49 202.07,167.69 U4.K7
  IN1 w0.127: v1(191.03,165.94) 191.03,165.87 191.22,165.68 191.42,165.68 191.94,165.17 191.94,161.69 192.6,161.03 192.6,157.88 192.72,157.76 193.21,157.76 193.33,157.88 193.33,161.08 193.64,161.39 196.26,161.39 199.02,158.62 199.02,157.7 199.78,156.94 206.49,156.94 206.67,157.12 206.67,158.77 207.71,159.81 207.71,160.8 207.86,160.95 207.86,161.81 207.63,162.04 207.63,162.61 207.89,162.87 211,162.87 211.16,163.04 211.16,164.27 211,164.44 210.67,164.44 210.5,164.27 210.5,163.78 210.24,163.51 208.1,163.51 207.84,163.77 207.84,164.68 208.1,164.94 208.78,164.94 209.11,165.27 209.4,165.27 v1(209.79,165.66) 209.99,165.46 210.71,165.46 210.94,165.69 210.94,166.17 211.87,167.1 211.87,167.6 212.26,167.99 213.82,167.99 214.42,167.39 215.47,167.39 v1(215.65,167.58)
  IN2 w0.127: v1(209.79,165.66) 209.51,165.38 209.04,165.38 208.7,165.05 208.16,165.05 206.73,166.48 203.49,166.48 v1(203.36,166.6)
  BOTTOM w0.114: v1(215.65,167.58) 215.86,167.37 216.09,167.37 216.22,167.24 216.39,167.24 216.69,167.53 216.99,167.53 217.14,167.68 U32.K7 ; v1(203.36,166.6) 203.54,166.43 203.74,166.43 204.8,167.48 204.93,167.48 205.27,167.82 U31.K7 ; v1(191.03,165.94) 190.94,165.94 190.63,166.25 U34.D25

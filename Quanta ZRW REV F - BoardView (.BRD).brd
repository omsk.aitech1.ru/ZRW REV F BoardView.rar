# Allegro board Quanta ZRW REV F - BoardView (.BRD).brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
FBA_CMD11: length 117.7
  TOP w0.114: v1(174.26,182.14) 174.53,182.14 174.73,181.94 174.73,181.94 174.76,181.91 174.97,181.91 175.08,181.8 175.08,181.54 175.2,181.43 175.41,181.43 175.53,181.54 175.53,181.79 175.73,181.99 176.25,181.99 U2.J3 ; v1(204.27,168.04) 204.2,167.98 204.2,166.64 204.32,166.53 204.65,166.53 204.76,166.64 204.76,166.91 204.87,167.02 U4.J3 ; U5.J3 217.5,167.02 217.61,166.91 217.61,166.69 217.5,166.58 216.52,166.58 216,166.06 v1(215.69,166.06) ; v1(187.21,182.16) 187.21,181.92 187.1,181.81 186.89,181.81 186.78,181.69 186.78,181.44 186.89,181.33 187.6,181.33 187.72,181.44 187.72,181.78 187.83,181.9 U3.J3
  TOP w0.127: v1(197.19,174.97) 196.94,175.22 196.94,176.4 196.56,176.78 R62.2 196.44,177.03 196.18,177.29 194.79,177.29 R61.1
  IN1 w0.127: v1(209.05,168.8) 208.97,168.88 206.41,168.88 206.29,169.01 206.29,169.41 206.16,169.54 205.85,169.54 205.73,169.41 205.73,168.52 205.6,168.4 205.3,168.4 205.17,168.52 205.17,169.26 205.05,169.38 204.15,169.38 204.14,169.38 203.56,169.38 203.39,169.54 201.99,169.54 200.67,170.86 199.97,170.86 199.44,171.4 199.3,171.4 198.78,171.92 198.55,171.92 198.43,171.79 198.25,171.79 198.02,172.01 198.02,172.22 198.59,172.79 198.59,172.97 198.41,173.15 198.23,173.15 197.72,172.63 197.54,172.63 197.36,172.81 197.36,172.99 197.88,173.5 197.88,173.68 197.7,173.86 197.52,173.86 197.11,173.46 196.93,173.46 196.74,173.65 196.74,173.83 197.45,174.54 197.45,174.71 v1(197.19,174.97) 196.28,176.33 193.34,180.21 193.34,181.04 193.07,181.55 191.33,183.28 189.06,183.48 187.71,183.72 186.65,183.72 186.14,183.69 184.26,183.69 183.05,183.55 181.31,182.96 v1(180.3,182.39)
  IN2 w0.127: v1(187.21,182.16) 187.16,182.22 185.28,182.22 185.13,182.37 185.13,182.55 184.77,182.9 183.63,182.9 182.99,182.27 182.02,182.27 181.68,181.92 180.77,181.92 v1(180.3,182.39) 180.09,182.39 179.82,182.13 179.58,182.13 179.46,182.01 179.46,181.24 179.35,181.12 179.07,181.12 178.96,181.24 178.96,182.01 178.84,182.13 174.27,182.13 v1(174.26,182.14) ; v1(204.27,168.04) 204.3,168.08 204.56,168.08 204.66,167.99 204.66,167.89 204.77,167.77 204.94,167.77 205.09,167.92 205.09,168.11 205.22,168.23 206.36,168.23 206.46,168.33 206.46,168.67 206.56,168.78 206.82,168.78 206.92,168.67 206.92,168.22 207.03,168.1 207.21,168.1 207.33,168.22 207.33,168.66 207.44,168.78 207.64,168.78 207.76,168.66 207.76,168.22 207.87,168.1 208.08,168.1 208.18,168.2 208.18,168.65 208.3,168.78 209.03,168.78 v1(209.05,168.8) 209.13,168.8 209.86,168.08 210.27,168.08 210.48,167.87 213.35,167.87 214.5,166.73 215.24,166.73 215.51,166.46 215.51,166.24 v1(215.69,166.06)
  BOTTOM w0.114: v1(215.69,166.06) 215.48,165.85 214.95,165.85 214.66,166.13 214.66,167.02 214.55,167.14 214.33,167.14 214.21,167.02 U32.J3 ; U28.J3 173.14,181.76 173.7,181.2 174.02,181.2 174.13,181.31 174.13,181.54 174.02,181.66 173.86,181.66 173.75,181.77 173.75,182.03 173.86,182.14 v1(174.26,182.14) ; U31.J3 202.16,166.93 202.75,166.93 202.88,167.06 203.64,167.06 204.27,167.68 v1(204.27,168.04) ; v1(187.21,182.16) 187.21,182.09 186.32,181.2 185.71,181.2 U29.J3
  BOTTOM w0.127: U34.G24 188.58,165.97 188.58,168.07 189.12,168.62 189.36,168.62 190.77,170.02 192.67,170.02 197.15,174.51 197.15,174.93 v1(197.19,174.97)
FBA_CMD12: length 141.4
  TOP w0.114: U3.T7 185.01,189.34 v1(186.61,190.94) ; v1(173.34,190.9) 173.55,190.7 173.55,190.04 173.39,189.89 173,189.89 172.89,189.77 172.89,189.49 173.14,189.24 U2.T7 ; U4.T7 202.07,175.18 202.18,175.29 202.44,175.29 202.55,175.4 202.55,175.68 202.44,175.8 202.39,175.8 202.27,175.91 v1(202.27,176.21) ; v1(215,175.14) 214.82,175.14 214.69,175.01 214.69,174.77 214.95,174.52 214.95,174.38 214.84,174.27 214.84,173.99 214.72,173.87 214.58,173.87 214.42,174.02 214.28,174.02 214.07,173.82 214.07,173.67 214.23,173.51 214.23,173.35 214.07,173.18 213.92,173.18 213.8,173.07 213.8,172.76 U5.T7
  IN1 w0.127: v1(215,175.14) 215,175.35 215.01,175.36 215.01,175.78 214.38,176.41 214.2,176.41 214.18,176.38 214,176.38 213.82,176.56 213.82,176.74 214.17,177.1 214.17,177.27 213.99,177.45 213.81,177.45 213.46,177.1 213.28,177.1 213.1,177.28 213.1,177.46 213.47,177.83 213.47,178.01 213.29,178.19 213.11,178.19 212.74,177.82 212.56,177.82 212.38,178 212.38,178.18 212.41,178.2 212.41,178.38 212.17,178.62 210.35,178.62 v1(210.07,178.89) 210.05,178.92 210.05,179.05 208.72,180.37 208.72,180.49 204.57,184.65 204.38,184.65 204.25,184.52 204.25,184.25 204.13,184.12 203.82,184.12 203.7,184.25 203.7,184.52 203.57,184.65 203.26,184.65 203.14,184.52 203.14,184.25 203.01,184.12 202.68,184.12 202.55,184.25 202.55,184.98 202.09,185.44 201.79,185.44 201.47,185.12 201.29,185.12 200.9,185.52 200.9,185.7 201.09,185.89 201.09,186.07 200.91,186.25 200.73,186.25 200.52,186.05 200.35,186.05 200.17,186.23 200.17,186.41 200.37,186.61 200.37,186.79 200.19,186.97 200.01,186.97 199.81,186.77 199.63,186.77 199.45,186.95 199.45,187.13 199.65,187.33 199.65,187.51 199.47,187.69 199.29,187.69 199.23,187.63 199.05,187.63 v1(198.67,188.01) 197.59,188.32 194.74,191.17 191.98,192.17 189.72,192.17 188.22,193.67 184.26,193.67 182.6,193.38 182.15,192.93 v1(181.21,192.93)
  IN2 w0.127: v1(202.27,176.21) 203.07,175.41 204.18,175.41 204.77,176 205.39,176 206.3,176.92 206.7,176.92 207.26,177.47 207.49,177.47 208.95,178.93 210.03,178.93 v1(210.07,178.89) ; v1(173.34,190.9) 173.34,191.33 173.55,191.54 174.33,191.54 176.49,193.7 180.45,193.7 v1(181.21,192.93) 181.88,192.93 182.33,192.48 182.46,192.48 182.59,192.6 182.59,192.91 182.71,193.04 182.96,193.04 183.07,192.92 183.07,192.77 183.18,192.65 183.44,192.65 183.55,192.77 183.55,192.92 183.67,193.04 183.98,193.04 184.1,192.92 184.1,192.19 184.21,192.07 184.45,192.07 184.57,192.19 184.57,192.91 184.7,193.04 184.92,193.04 185.05,192.91 185.05,192.17 185.17,192.06 185.33,192.06 185.96,191.42 186.41,191.42 186.61,191.22 v1(186.61,190.94)
  BOTTOM w0.114: U2.T7 173.14,189.33 173.01,189.45 172.86,189.45 172.73,189.58 172.73,189.81 172.86,189.94 173.14,189.94 173.34,190.14 v1(173.34,190.9) ; U5.T7 213.94,173.55 214.11,173.72 214.65,173.72 214.77,173.83 214.77,174.03 214.65,174.15 214.39,174.15 214.26,174.27 214.26,174.5 214.39,174.63 214.79,174.63 215,174.83 v1(215,175.14) ; U4.T7 202.07,175.13 202.18,175.24 202.33,175.24 202.45,175.35 202.45,175.56 202.33,175.67 202.23,175.67 202.12,175.79 202.12,176.06 v1(202.27,176.21) ; U3.T7 185.01,188.57 185.39,189.87 186.45,190.93 186.6,190.93 v1(186.61,190.94)
  BOTTOM w0.127: U34.F27 189.25,167.92 191,169.67 192.78,169.67 197.68,174.57 197.68,175 198.32,175.64 199.18,175.64 199.43,175.89 199.43,178.5 199.1,178.83 199.1,179.78 199.5,180.18 199.5,183.5 197.93,185.07 197.93,186.48 198.67,187.22 v1(198.67,188.01) 198.87,188.21 R455.2 200.05,187.63 200.55,187.63 201.13,188.21 R456.1
FBA_CMD13: length 126.8
  TOP w0.114: v1(189.41,185.5) 189.41,185.02 189.57,184.86 189.57,184.68 189.43,184.54 189.25,184.54 189.13,184.65 188.84,184.65 188.71,184.78 188.71,184.97 188.84,185.1 U3.N2 ; U5.N2 218.22,170.22 218.35,170.35 218.35,170.54 218.22,170.67 216.85,170.67 216.63,170.89 216.27,170.89 216.14,171.01 216.14,171.2 216.27,171.32 v1(216.27,171.32) ; v1(174.98,187.44) 175.52,186.71 175.52,186.24 176.2,185.56 176.56,185.4 176.7,185.26 U2.N2 ; U4.N2 206.19,170.1 206.41,170.1 206.53,170.23 206.53,170.49 206.34,170.68 205.1,170.68 204.4,171.39 v1(204.34,171.39)
  TOP w0.127: v1(197.48,181.77) 197.48,182.07 198.41,183 198.41,184.36 R24.2 200.61,186.25 200.94,185.92 202.14,185.92 R25.1
  IN1 w0.127: v1(210.61,173.66) 209.7,174.57 209.49,174.57 209.28,174.77 208.9,174.77 208.7,174.57 208.34,174.57 208.22,174.7 208.22,175.18 208.11,175.28 207.81,175.28 207.68,175.15 207.68,174.93 207.54,174.79 207.36,174.79 207.04,175.12 207.04,175.3 207.23,175.48 207.23,175.78 206.63,176.38 205.85,176.38 204.05,178.18 203.08,178.18 202.5,178.76 201.49,178.76 200.42,179.83 200.42,180.51 199.54,181.39 199.19,181.39 199,181.2 198.64,181.2 198.46,181.38 198.46,181.52 198.33,181.66 197.59,181.66 v1(197.48,181.77) 197.06,182.18 196.82,182.55 196.34,183.34 191.32,188.36 191.23,188.44 188.41,188.44 188.01,188.84 185.88,188.84 183.71,188.46 182.89,188.46 v1(181.8,188.26)
  IN2 w0.127: v1(216.27,171.32) 216.57,171.32 216.7,171.2 216.7,170.86 216.57,170.73 215.95,170.73 215.77,170.56 215.17,170.56 214.97,170.76 214.39,170.76 211.66,173.49 210.79,173.49 v1(210.61,173.66) 210.61,173.35 210.48,173.21 210.16,173.21 209.82,172.86 209.48,172.86 209.36,172.74 209.36,172.27 209.23,172.14 208.43,172.14 208.33,172.04 207.35,172.04 206.97,172.42 206.97,172.54 206.84,172.67 206.61,172.67 206.49,172.54 206.49,172.45 206.36,172.32 206,172.32 205.27,171.59 204.54,171.59 v1(204.34,171.39) ; v1(174.98,187.44) 175.02,187.4 175.7,187.4 175.83,187.52 175.83,187.65 175.96,187.78 176.16,187.78 176.29,187.65 176.29,187.57 176.42,187.45 176.59,187.45 176.72,187.58 176.72,188.36 176.95,188.59 179.7,188.59 179.9,188.39 180.62,188.39 180.63,188.38 181.69,188.38 v1(181.8,188.26) 181.94,188.12 184.89,188.12 186.48,186.53 188.25,186.53 189.29,185.5 v1(189.41,185.5)
  BOTTOM w0.114: U3.N2 188.8,184.88 188.8,184.75 188.91,184.63 189.15,184.63 189.32,184.47 189.49,184.47 189.61,184.59 189.61,184.77 189.47,184.91 189.47,185.09 189.39,185.17 189.39,185.48 v1(189.41,185.5) ; U5.N2 217.94,170.39 217.67,170.67 216.94,170.67 216.28,171.32 v1(216.27,171.32) ; U2.N2 176.66,185.3 176.5,185.45 176.2,185.56 175.49,186.27 175.49,186.74 v1(174.98,187.44) ; v1(204.34,171.39) 205.08,170.64 205.65,170.64 U4.N2
  BOTTOM w0.127: v1(197.48,181.77) 197.69,181.99 198.06,181.99 198.84,181.2 198.84,180.46 198.44,180.06 198.44,178.49 198.77,178.16 198.77,176.58 v1(198.64,176.45) 198.51,176.32 197.14,176.32 195.13,174.32 194.3,174.32 191,171.01 190.25,171.01 187.55,168.31 187.55,167.37 187.65,167.27 187.65,166.92 188.13,166.43 U34.G25
FBA_CMD14: length 144
  TOP w0.114: U5.T3 217.42,172.62 217.54,172.73 217.54,172.87 217.14,173.26 217.14,174.4 216.71,174.83 216.38,174.83 216.24,174.69 216,174.69 215.84,174.85 215.84,175.02 v1(215.96,175.14) ; U3.T3 188.21,188.27 188.31,188.37 188.31,189.61 187.72,190.2 187.72,190.77 v1(187.9,190.95) ; U4.T3 205.27,174.58 v1(203.67,176.19) ; v1(174.7,190.78) 174.41,190.49 174.41,190.27 176.24,188.44 176.24,187.6 U2.T3
  IN1 w0.127: v1(179.82,192.92) 180.31,193.4 181.34,193.87 182.58,194.33 188.5,194.33 189.99,192.83 192.26,192.83 195.12,191.83 v1(198.18,189.35) 198.74,189.35 200.63,187.47 200.81,187.47 201.1,187.76 201.28,187.76 201.46,187.58 201.46,187.4 201.17,187.11 201.17,186.93 201.64,186.46 202.01,186.46 202.24,186.22 202.42,186.22 202.64,186.44 202.82,186.44 203,186.26 203,186.08 202.78,185.86 202.78,185.68 203.16,185.31 203.34,185.31 203.57,185.54 203.78,185.54 204.02,185.31 205.7,185.31 205.93,185.07 205.93,184.89 205.69,184.65 205.69,184.47 205.87,184.29 206.05,184.29 206.29,184.53 206.47,184.53 206.65,184.35 206.65,184.18 206.41,183.93 206.41,183.75 206.59,183.57 206.77,183.57 207.01,183.82 207.19,183.82 210.1,180.91 210.1,180.05 v1(209.88,179.84)
  IN2 w0.127: v1(187.9,190.95) 187.12,190.16 186.29,190.16 185.05,191.4 182.48,191.4 181.76,192.12 180.87,192.12 180.59,192.4 180.43,192.4 179.91,192.92 v1(179.82,192.92) 179.82,192.53 180.19,192.16 180.19,191.98 180.1,191.89 179.85,191.89 179.4,192.35 179.4,192.59 179.29,192.71 179.29,192.91 179.17,193.02 178.97,193.02 177.21,193.02 176.75,193.02 176.29,192.57 176.29,192.38 176.01,192.1 176.01,191.94 176.2,191.75 176.2,191.57 176.02,191.39 175.84,191.39 175.64,191.59 175.51,191.59 v1(174.7,190.78) ; v1(203.67,176.19) 203.71,176.19 204.48,176.96 204.76,176.96 205.02,176.7 205.15,176.7 205.41,176.96 205.41,177.1 205.18,177.32 205.18,177.5 205.36,177.68 205.54,177.68 205.75,177.48 205.93,177.48 206.11,177.66 206.11,177.84 206,177.94 206,178.12 206.18,178.3 206.54,178.3 206.9,178.66 206.9,178.76 207.15,179.02 207.28,179.11 208.1,179.5 208.37,179.5 208.58,179.71 208.86,179.71 208.99,179.84 v1(209.88,179.84) 210.42,179.84 210.63,179.62 210.63,179.47 210.81,179.29 212.43,179.29 212.51,179.22 212.81,178.91 213.07,178.91 213.22,178.76 213.22,178.5 213.57,178.16 213.8,178.16 213.93,178.02 213.93,177.79 214.29,177.44 214.52,177.44 214.64,177.31 214.64,177.08 214.7,177.02 215.53,176.19 215.89,176.19 216.01,176.06 216.01,175.19 v1(215.96,175.14)
  BOTTOM w0.114: v1(215.96,175.14) 215.96,174.76 216.07,174.65 216.41,174.65 216.5,174.73 216.5,174.92 216.61,175.04 217.03,175.04 217.14,174.92 U5.T3 ; U3.T3 188.21,188.1 188.31,188.2 188.31,189.79 187.72,190.38 187.72,190.77 v1(187.9,190.95) ; U4.T3 205.23,172.66 205.23,174.63 v1(203.67,176.19) ; U2.T3 176.34,188.36 174.41,190.29 174.41,190.49 v1(174.7,190.78)
  BOTTOM w0.127: R452.1 201.12,189.86 199.86,189.86 199.47,189.47 R451.2 v1(198.18,189.35) 198.26,189.28 198.26,188.51 198.13,188.38 198.13,187.33 197.6,186.8 197.6,184.93 199.17,183.36 199.17,180.33 198.77,179.92 198.77,178.63 199.1,178.3 199.1,176.12 198.97,175.99 197.37,175.99 196.76,175.38 196.76,174.65 192.47,170.35 190.54,170.35 188.13,167.95 U34.G27
FBA_CMD15: length 111
  TOP w0.114: v1(186.45,182.75) 186.45,182.69 186.56,182.57 186.73,182.57 186.95,182.79 186.95,182.87 187.06,182.98 187.16,182.98 187.34,182.79 187.47,182.79 187.52,182.84 187.69,182.84 187.81,182.72 187.81,182.58 187.91,182.48 188,182.48 U3.K3 ; v1(215.08,166.3) 215.31,166.53 215.89,166.53 217.14,167.78 U5.K3 ; U2.K3 176.34,182.96 176.23,183.08 176,183.08 175.88,182.96 175.88,182.66 175.77,182.55 175.59,182.55 175.48,182.66 175.48,182.86 175.36,182.98 175.11,182.98 174.99,182.86 v1(174.99,182.57) ; v1(202.97,168.14) 203.61,168.14 203.94,168.48 204.61,168.48 U4.K3
  TOP w0.127: v1(196.33,174.82) 196.58,175.07 196.58,175.5 R64.2 195.86,175.06 194.86,175.06 R63.1
  IN1 w0.127: v1(208.62,168.33) 208.28,167.99 207.84,167.99 207.71,168.12 207.71,168.4 207.58,168.52 207.33,168.52 207.2,168.4 207.2,168.12 207.07,167.99 206.82,167.99 206.69,168.12 206.69,168.4 206.57,168.52 206.31,168.52 206.18,168.4 206.18,168.12 206.06,167.99 204.95,167.99 204.45,168.49 204.08,168.49 204.03,168.44 203.4,168.44 203.21,168.63 202.44,168.63 201.21,169.85 200.77,169.85 200.13,170.5 199.07,170.5 196.33,173.24 196.33,173.6 196.2,173.73 195.21,173.73 195.08,173.86 195.08,174.11 195.21,174.24 196.2,174.24 196.33,174.37 v1(196.33,174.82) 195.75,176.44 193.01,180.06 193.01,180.9 192.74,181.41 191.31,182.83 187.85,182.83 186.99,182.58 186.63,182.22 184.85,181.87 183.48,181.87 181.89,182.16 v1(181.27,182.34) 181.55,182.62 183.17,182.62 183.3,182.75 183.3,183.03 183.43,183.16 183.76,183.16 183.88,183.03 183.88,182.88 184.01,182.75 184.24,182.75 184.37,182.88 184.37,183.03 184.49,183.16 184.7,183.16 184.82,183.03 184.82,182.75 184.95,182.62 185.18,182.62 185.31,182.75 185.31,183.19 185.43,183.32 185.95,183.32 186.45,182.83 v1(186.45,182.75)
  IN2 w0.127: v1(174.99,182.57) 175.11,182.46 178.61,182.46 178.75,182.6 178.75,182.72 178.87,182.84 179.07,182.84 179.18,182.72 179.18,182.57 179.3,182.46 179.6,182.46 180.15,183 180.61,183 v1(181.27,182.34) ; v1(215.08,166.3) 214.96,166.42 214.34,166.42 213.22,167.54 210.2,167.54 209.99,167.75 209.64,167.75 209.06,168.33 v1(208.62,168.33) 208.77,168.18 208.77,167.87 208.63,167.73 206.81,167.73 206.64,167.9 205.48,167.9 205.02,167.44 204.13,167.44 203.72,167.85 203.72,168.22 203.6,168.33 203.16,168.33 v1(202.97,168.14)
  BOTTOM w0.102: U28.K3 173.67,183.23 174.33,183.23 174.48,183.08 174.48,182.62 174.64,182.47 174.89,182.47 v1(174.99,182.57)
  BOTTOM w0.114: v1(202.97,168.14) 202.97,167.99 203.09,167.87 203.3,167.87 203.41,167.76 203.41,167.51 203.3,167.39 202.18,167.39 202.07,167.51 U31.K3 ; v1(215.08,166.3) 214.95,166.43 214.95,166.73 215.12,166.91 215.12,167.26 215.03,167.36 214.05,167.36 213.94,167.47 U32.K3 ; U29.K3 185.01,182.49 185.15,182.34 185.62,182.34 185.98,181.99 186.36,181.99 186.45,182.08 v1(186.45,182.75)
  BOTTOM w0.127: v1(196.33,174.82) 196.33,174.68 195.28,173.63 194.93,173.63 194.59,173.97 194.42,173.97 194.2,173.75 194.2,173.58 194.62,173.15 194.62,172.97 194.44,172.79 v1(194.26,172.79) 193.84,173.22 193.67,173.22 193.48,173.03 193.48,172.86 193.9,172.44 193.9,172.26 193.72,172.08 193.54,172.08 193.18,172.44 192.89,172.44 192.3,171.85 192.3,171.67 192.65,171.32 192.65,171.14 192.47,170.96 192.29,170.96 191.94,171.31 191.76,171.31 191.16,170.71 191.15,170.71 191.12,170.68 190.39,170.68 187.78,168.07 187.78,167.78 188.13,167.42 U34.G26
FBA_CMD16: length 82.7
  TOP w0.114: v1(173.96,182.82) 174.41,182.82 174.58,182.66 174.58,182.4 174.82,182.16 175.16,182.16 175.25,182.24 176.36,182.24 176.75,182.63 176.75,182.78 177,183.03 177.28,183.03 177.62,182.7 U2.K1 ; v1(185.76,182.88) 186.04,182.6 186.04,182.58 186.28,182.34 186.8,182.34 187.04,182.58 187.41,182.58 187.72,182.27 188.26,182.27 188.67,182.68 188.67,182.84 188.87,183.03 189.47,183.03 U3.K1
  TOP w0.127: v1(192.37,180.53) 192.37,180.87 192.88,181.38 R47.1
  IN1 w0.165: v1(192.37,180.53) 191.74,180.53 191.58,180.36 191.58,178.19 191.74,178.02 192.66,178.02 192.82,177.86 192.82,177.5 192.66,177.34 191.51,177.34 190.92,177.93 190.92,180.63 191.21,180.92 191.21,181.4 190.62,181.99 188.22,181.99 187.55,181.33 186.53,181.33 186.35,181.15 182.66,181.15 182.53,181.01 179.63,181.01 179.03,181.61 179.03,182.71 178.87,182.88 177.88,182.88 177.71,183.04 177.71,183.4 177.88,183.56 179.26,183.56 v1(179.49,183.33)
  IN2 w0.102: 185.38,167.99 184.6,167.21 184.28,167.21 183.88,166.82 183.88,166.26 v1(183.56,165.94)
  IN2 w0.127: v1(173.96,182.82) 174.15,183.02 175.97,183.02 176.29,183.33 176.62,183.33 176.95,183 177.23,183 177.56,183.33 177.76,183.33 177.89,183.21 177.89,182.91 178.02,182.79 178.24,182.79 178.37,182.91 178.37,183.21 178.5,183.33 v1(179.49,183.33) 180.76,183.33 181.27,182.82 182.1,182.82 182.31,183.03 182.9,183.03 183.14,183.27 184.95,183.27 185.17,183.04 185.6,183.04 v1(185.76,182.88)
  IN2 w0.165: 185.38,167.99 185.76,168.37 185.76,169.44 191.73,175.42 191.73,179.44 192.37,180.08 v1(192.37,180.53)
  BOTTOM w0.114: v1(173.96,182.82) 173.96,182.6 173.67,182.32 172.94,182.32 172.75,182.5 172.75,182.96 172.64,183.08 170.94,183.08 170.83,182.97 170.83,182.81 170.94,182.7 U28.K1 ; U29.K1 183.22,182.51 183.22,182.23 183.11,182.11 182.88,182.11 182.72,182.27 182.72,182.88 182.97,183.13 185.05,183.13 185.31,182.88 v1(185.76,182.88) ; U34.M24 v1(183.56,165.94)
FBA_CMD17: length 72.6
  TOP w0.114: U2.L2 177.32,183.5 177.76,183.05 178.23,183.05 178.35,183.17 178.35,183.7 178.46,183.82 178.87,183.82 178.98,183.7 178.98,183.09 178.57,182.69 178.57,182.44 178.83,182.19 178.95,182.19 180.56,183.81 180.56,183.81 180.8,184.04 180.99,184.04 181.17,183.87 181.17,183.61 180.49,182.93 180.24,182.93 179.71,182.4 179.71,182.07 179.61,181.96 179.61,181.67 179.8,181.48 v1(180.01,181.48) 180.01,181.48 180.42,181.88 180.42,181.91 180.84,182.32 180.84,182.51 181.49,183.16 182.15,183.16 182.82,183.83 185.32,183.83 185.42,183.73 185.43,183.73 185.78,183.73 186.02,183.97 186.02,184.32 186.28,184.58 186.65,184.58 187.39,183.84 188.56,183.84 188.9,183.5 U3.L2
  IN2 w0.165: v1(184.42,164.28) 185.24,165.11 185.24,167.33 186.12,168.21 186.12,169.29 192.15,175.32 192.15,177.58 193.5,178.93 193.5,179.43 193.33,179.6 192.95,179.6 192.79,179.76 192.79,180.08 192.95,180.24 193.33,180.24 193.5,180.41 193.5,180.7 193.19,181.02 191.73,181.02 191.41,181.33 191.41,181.87 191.58,182.04 193.5,182.04 193.67,182.2 193.67,182.6 193.84,182.76 194.13,182.76 194.3,182.93 194.3,183.34 194.13,183.51 193.84,183.51 193.67,183.67 193.67,184.88 193.84,185.05 194.1,185.05 194.26,185.21 194.26,185.76 194.1,185.92 193.21,185.92 192.99,185.71 192.99,182.86 192.82,182.7 191.22,182.7 190.72,182.19 188.61,182.19 187.88,181.46 186.74,181.46 186.61,181.59 182.14,181.59 181.52,180.97 180.51,180.97 v1(180.01,181.48)
  BOTTOM w0.102: U34.M23 v1(184.42,164.28)
FBA_CMD18: length 72.9
  IN2 w0.165: v1(180.83,181.48) 181.62,181.48 182,181.86 186.86,181.86 186.99,181.73 187.39,181.73 187.81,182.15 187.81,182.49 188.51,183.18 191.39,183.18 192.35,184.14 192.35,188.24 192.51,188.4 192.91,188.4 193.08,188.24 193.08,186.75 193.24,186.58 193.65,186.58 193.81,186.75 193.81,187.56 193.98,187.73 194.4,187.73 194.57,187.56 194.57,186.75 194.73,186.58 195.11,186.58 195.28,186.75 195.28,187.63 195.44,187.79 195.91,187.79 196.08,187.63 196.08,186.65 196.77,185.96 196.77,183.25 196.52,183 196.52,182.29 195.59,181.37 195.59,179.98 192.89,177.27 192.89,175.01 187.6,169.72 187.6,168.41 186.05,166.86 v1(186.05,165.94)
  BOTTOM w0.102: 175.2,184.25 174.82,183.87 174.54,183.87 174.1,183.43 173.54,183.43 173.28,183.17 172.87,183.17 172.54,183.5 U28.L2 ; U34.K24 185.65,165.55 v1(186.05,165.94)
  BOTTOM w0.114: 175.2,184.25 175.2,184.25 175.83,184.25 176.19,183.89 178.19,183.89 180.2,181.89 180.42,181.89 v1(180.83,181.48) 180.83,182.67 180.51,183 180.05,183 179.97,183.08 179.97,183.51 180.07,183.61 181.09,183.61 181.72,182.98 181.72,182 181.84,181.89 181.99,181.89 182.23,182.13 182.23,183.46 182.71,183.94 184.1,183.94 184.21,183.83 U29.L2
FBA_CMD19: length 78.5
  TOP w0.114: v1(174.94,183.46) 174.91,183.43 173.55,183.43 173.28,183.16 172.33,183.16 172.11,182.95 171.79,182.95 U2.K9 ; U3.K9 183.82,183.1 184.34,183.1 184.47,183.23 184.8,183.23 184.92,183.1 185.23,183.1 185.42,183.3 186.77,183.3 v1(186.78,183.29)
  TOP w0.127: v1(192.01,181.5) 193.03,182.52 R43.2
  IN1 w0.165: v1(192.01,181.5) 191.63,181.5 190.77,182.36 188.06,182.36 187.38,181.68 186.32,181.68 186.23,181.59 181.38,181.59 181.03,181.94 180.64,181.94 180.63,181.93 180.11,181.93 179.84,182.2 179.84,182.59 179.95,182.7 179.95,184.16 v1(179.95,184.17)
  IN2 w0.102: 185.89,165.27 186.04,165.12 v1(186.05,165.12)
  IN2 w0.127: v1(186.78,183.29) 186.7,183.37 185.31,183.37 185.08,183.6 183,183.6 182.77,183.36 182.13,183.36 181.92,183.15 181.41,183.15 180.9,183.66 180.45,183.66 v1(179.95,184.17) 179.57,183.79 178.22,183.79 178.09,183.92 178.09,184.3 177.97,184.43 177.76,184.43 177.63,184.3 177.63,183.79 177.51,183.66 177.3,183.66 177.18,183.79 177.18,184.27 177.05,184.4 176.85,184.4 176.72,184.27 176.72,183.92 176.5,183.7 176.11,183.7 175.76,183.35 175.06,183.35 v1(174.94,183.46)
  IN2 w0.165: v1(192.01,181.5) 192.04,181.48 193.52,181.48 194.24,182.21 195.02,182.21 195.37,182.56 195.37,183.12 194.49,184 194.49,184.3 194.69,184.51 194.93,184.51 196,183.43 196,182.31 195.37,181.68 194.69,181.68 193.87,180.86 193.87,178.77 192.52,177.43 192.52,175.16 186.52,169.16 186.52,168.04 185.61,167.13 185.61,165.55 185.89,165.27
  BOTTOM w0.102: v1(186.05,165.12) 185.65,164.73 U34.K23
  BOTTOM w0.114: U28.K9 177.81,182.7 177.38,183.13 176.19,183.13 175.83,182.77 175.45,182.77 174.94,183.28 v1(174.94,183.46) ; v1(186.78,183.29) 186.78,183.28 186.78,183.1 187.26,182.62 187.66,182.62 188.07,183.03 189.47,183.03 U29.K9
FBA_CMD20: length 147.5
  TOP w0.114: U2.T2 176.86,188.4 176.74,188.73 175.98,190.58 175.92,190.7 175.72,191.08 175.6,191.2 v1(174.16,192.02) ; v1(203.47,177.08) 203.58,177.08 205.5,175.16 205.5,174.64 205.65,174.49 205.65,174.06 205.5,173.91 205.5,173.19 U4.T2
  TOP w0.127: v1(216.48,175.52) 215.99,176.01 215.99,176.19 216.28,176.49 216.46,176.49 217.08,175.87 217.08,175.11 217.46,174.72 217.46,173.25 217.94,172.78 U5.T2 ; v1(186.5,191.87) 186.87,191.5 187.36,191.38 188.06,191.38 188.3,191.13 189.21,189.11 189.24,188.95 U3.T2
  IN1 w0.127: v1(181.9,193.39) 182.69,194 188.36,194 189.86,192.5 192.12,192.5 194.94,191.5 v1(197.79,188.81) 198.82,188.81 201.67,185.96 202.04,185.96 203.02,184.98 204.72,184.98 206.69,183.01 206.87,183.01 207.11,183.25 207.29,183.25 207.47,183.07 207.47,182.89 207.23,182.65 207.23,182.47 207.41,182.29 207.59,182.29 207.83,182.53 208.01,182.53 208.19,182.35 208.19,182.17 207.95,181.93 207.95,181.75 208.13,181.57 208.31,181.57 208.55,181.81 208.73,181.81 208.91,181.63 208.91,181.45 208.67,181.21 208.67,181.03 209.08,180.62 209.49,180.62 v1(209.61,180.74)
  IN2 w0.127: v1(216.48,175.52) 216.19,176.78 216,177.1 213.86,179.25 212.86,180.01 212.25,180.4 211.51,180.68 210.91,180.77 210.78,180.77 v1(209.61,180.74) 207.42,180.74 205.86,179.18 205.27,178.87 204.38,177.98 204.2,177.98 203.79,178.39 203.61,178.39 203.43,178.22 203.43,178.04 203.84,177.62 203.84,177.44 v1(203.47,177.08) ; v1(186.5,191.87) 185.99,191.87 185.56,192.3 185.56,192.81 185.73,192.97 185.73,193.2 185.53,193.39 184.72,193.39 184.52,193.59 184.52,193.92 184.39,194.05 184.16,194.05 184.04,193.92 184.04,193.52 183.91,193.39 183.6,193.39 183.48,193.52 183.48,193.94 183.36,194.05 183.11,194.05 182.99,193.94 182.99,193.51 182.88,193.39 182.6,193.39 182.49,193.51 182.49,193.94 182.37,194.05 182.04,194.05 181.93,193.94 181.93,193.42 v1(181.9,193.39) 181.27,193.39 181.09,193.57 181.09,193.77 180.84,194.03 180.59,194.03 180.31,194.03 180.31,194.03 176.35,194.03 174.34,192.02 v1(174.16,192.02)
  BOTTOM w0.114: v1(216.48,175.52) 215.6,176.07 215.35,176.08 214.64,176.06 214.4,176.02 214.08,175.8 213.97,175.61 213.48,174.57 213.25,173.93 U32.T2 ; U28.T2 172.15,187.69 172.15,189.77 172.68,190.3 172.68,191.05 173.65,192.02 v1(174.16,192.02) ; U31.T2 201.82,176.35 202.14,176.66 203.06,176.66 v1(203.47,177.08) ; v1(186.5,191.87) 184.73,190.1 184.73,189.16 184.24,188.67 184.24,188.13 184.37,188.01 184.52,188.01 184.65,187.88 184.65,187.62 184.52,187.5 U29.T2
  BOTTOM w0.127: U34.M27 184.37,168.32 184.37,168.47 184.63,168.74 184.63,170.14 188.5,174.01 189.79,174.01 194.13,178.35 194.13,180.03 194.02,180.14 194.02,182.6 195.08,183.66 195.08,184.2 195.87,184.98 195.87,186.94 196.73,187.8 196.78,187.8 v1(197.79,188.81) 197.62,188.97 R453.1
FBA_CMD21: length 144.2
  TOP w0.114: U5.R8 213.53,172.51 213.53,173.15 213.74,173.93 214,174.19 v1(214.56,175.6) ; U2.R8 172.12,186.7 172,186.82 172,187.02 172.12,187.14 172.48,187.14 172.68,187.34 172.68,187.91 172.55,188.03 172.4,188.03 172.28,188.16 172.28,188.41 172.4,188.54 172.78,188.54 172.91,188.67 172.91,188.9 172.78,189.02 v1(172.56,189.02) ; v1(183.78,190.45) 184.04,190.19 184.04,189.38 183.78,189.12 183.78,187.13 U3.R8 ; U4.R8 200.93,172.16 200.93,172.97 201.05,173.1 201.31,173.1 201.43,173.22 201.43,173.4 201.31,173.53 200.88,173.53 200.75,173.66 200.75,173.88 200.88,174.01 200.98,174.01 201.1,174.14 v1(201.1,174.67)
  TOP w0.127: v1(196.91,187.37) 196.46,187.83 R21.2 196.19,187.71 195.67,187.19 194.66,187.19 R20.1
  IN1 w0.127: v1(209.18,178.49) 209.18,178.97 207.29,180.87 207.11,180.87 206.98,180.74 206.8,180.74 206.62,180.92 206.62,181.1 206.75,181.23 206.75,181.41 206.57,181.59 206.39,181.59 206.09,181.29 205.94,181.29 205.66,181.01 205.5,181.01 205.24,181.27 205.24,181.43 205.45,181.64 205.72,181.64 206.03,181.95 206.03,182.13 205.85,182.31 205.67,182.31 205.52,182.15 205.34,182.15 205.16,182.33 205.16,182.51 205.31,182.66 205.31,182.84 205.11,183.04 204.93,183.04 204.81,182.93 204.61,182.93 204.46,183.08 203.95,183.08 203.81,182.94 203.81,182.8 203.68,182.67 203.39,182.67 203.26,182.8 203.26,183.25 203.09,183.42 202.03,183.42 199.15,186.3 198.62,186.3 198.46,186.46 198.46,186.89 198.34,187.02 198.11,187.02 197.98,186.89 197.98,186.58 197.85,186.46 197.64,186.46 197.4,186.69 197.4,187.12 197.28,187.24 197.04,187.24 v1(196.91,187.37) 193.78,190.51 191.71,191.51 189.45,191.51 187.95,193.01 185.92,193.01 182.9,192.71 182.35,192.16 180.76,192.16 179.71,192.39 178.83,192.64 178.54,192.64 178.31,192.59 v1(177.86,192.25)
  IN2 w0.127: v1(214.56,175.6) 214.77,175.81 214.77,175.97 213.72,177.02 213.45,177.02 213.17,176.73 212.99,176.73 212.81,176.91 212.81,177.09 213.14,177.42 213.14,177.6 212.96,177.78 212.78,177.78 212.52,177.53 212.34,177.53 212.17,177.71 212.17,177.89 212.37,178.09 212.37,178.27 212.19,178.45 212.01,178.45 211.81,178.25 211.63,178.25 211.24,178.63 210.6,178.63 210.26,178.29 209.38,178.29 v1(209.18,178.49) 208.52,177.93 207.73,177.14 207.4,177.14 206.84,176.59 206.44,176.59 205.52,175.67 204.91,175.67 204.32,175.08 202.83,175.08 v1(201.1,174.67) ; v1(172.56,189.02) 172.94,188.64 173.21,188.64 173.32,188.76 173.32,189.89 173.55,190.11 174,190.11 174.23,189.89 174.23,189.63 174.36,189.51 174.66,189.51 174.79,189.63 174.79,190.17 174.92,190.29 175.25,190.29 175.37,190.17 175.37,189.86 175.5,189.73 175.86,189.73 175.98,189.86 175.98,190.2 177.74,191.96 177.74,192.12 v1(177.86,192.25) 178.22,191.89 178.22,191.28 178.09,191.16 177.91,191.16 177.79,191.03 177.79,190.75 177.91,190.62 178.65,190.62 178.78,190.75 178.78,191.51 178.88,191.61 179.2,191.61 179.34,191.48 179.34,191.36 179.46,191.23 180.68,191.23 180.75,191.16 181.52,191.16 181.94,190.74 183.68,190.74 183.78,190.64 v1(183.78,190.45)
  BOTTOM w0.114: U4.R8 200.93,172.16 200.93,172.92 200.8,173.05 200.39,173.05 200.27,173.17 200.27,173.45 200.39,173.58 200.8,173.58 200.93,173.71 200.93,173.96 201.1,174.14 v1(201.1,174.67) ; v1(172.56,189.02) 172.73,189.02 172.89,188.87 172.89,188.59 172.76,188.46 172.55,188.46 172.43,188.34 172.43,188.08 172.55,187.96 172.61,187.96 172.73,187.83 172.73,187.24 172.61,187.12 172.02,187.12 171.89,186.99 171.89,186.82 172.02,186.7 U2.R8 ; v1(183.78,190.45) 184.01,190.22 184.01,189.05 183.78,188.82 183.78,187.13 U3.R8 ; U5.R8 213.52,172.61 213.52,172.89 213.57,173.41 213.91,174.67 v1(214.56,175.6)
  BOTTOM w0.127: U34.M26 184.18,167.33 184.21,167.33 184.82,167.95 184.82,168.27 185.13,168.58 185.13,169.7 188.78,173.35 190.06,173.35 194.79,178.08 194.79,180.25 195.21,180.66 195.21,181.57 196.01,182.37 196.01,183.43 196.56,183.98 196.56,187.02 v1(196.91,187.37)
FBA_CMD22: length 141.6
  TOP w0.114: v1(187.39,187.4) 187.39,187.16 187.27,187.04 186.99,187.04 186.86,186.91 186.86,186.75 186.97,186.64 187.34,186.64 187.44,186.74 187.69,186.74 188.08,186.35 188.25,186.35 188.5,186.1 188.68,186.1 188.93,186.35 189.36,186.35 189.47,186.24 189.47,186.01 189.37,185.91 189.02,185.91 U3.P2 ; v1(216.43,173.05) 216.32,172.94 216.32,172.66 216.8,172.17 216.8,171.68 217,171.48 217.21,171.48 217.42,171.27 217.69,171.27 217.91,171.48 218.11,171.48 218.29,171.66 218.42,171.66 218.6,171.49 218.6,171.36 218.4,171.16 218.4,171.15 218.37,171.13 218.37,171.04 218.25,170.91 218.05,170.91 U5.P2 ; U2.P2 177.27,185.9 177.38,185.78 177.38,185.58 177.27,185.47 176.87,185.47 176.7,185.64 176.7,185.97 176.95,186.22 176.95,186.36 176.82,186.48 176.62,186.48 176.49,186.36 176.21,186.36 176,186.56 176,187.05 175.79,187.27 175.79,187.8 175.58,188.01 v1(175.58,188.03) ; v1(203.69,174.64) 203.69,174.23 204.72,173.2 204.72,172.31 204.93,172.1 204.93,171.68 205.17,171.45 205.64,171.45 U4.P2
  TOP w0.127: R29.1 194.03,185.15 194.65,184.53 195.55,184.53 R30.2 196.19,184.37 v1(196.13,184.31)
  IN1 w0.127: v1(175.58,188.03) 175.58,186.52 175.69,186.41 175.97,186.41 176.09,186.52 176.09,186.77 176.2,186.89 176.48,186.89 176.59,186.77 176.59,186.42 176.71,186.3 176.96,186.3 177.08,186.42 177.08,186.81 177.23,186.97 177.66,186.97 178.07,186.56 179.39,186.56 179.55,186.72 179.55,188.32 v1(180.1,188.87) 183.91,189.01 184.01,189.01 185.95,189.78 187.85,189.78 188.5,189.4 190.23,189.4 191.32,188.98 193.96,186.33 194.96,186.11 195.22,185.85 v1(196.13,184.31) 196.13,184.03 197.14,183.01 197.14,182.73 197.58,182.29 197.74,182.29 197.74,182.29 198.16,182.29 198.73,181.72 199.68,181.72 200.75,180.65 200.75,179.96 201.62,179.09 202.64,179.09 203.22,178.51 204.19,178.51 205.99,176.71 206.03,176.71 206.76,176.71 207.81,175.66 208.42,175.66 208.55,175.54 208.55,175.23 208.67,175.1 208.98,175.1 209.1,175.23 v1(209.1,175.94)
  IN2 w0.127: v1(216.43,173.05) 216.24,173.24 216.24,173.27 215.94,173.57 215.35,173.57 215.15,173.77 214.75,173.77 211.73,176.79 210.63,176.79 210.45,176.97 210.02,176.97 209.55,176.49 209.55,176.39 v1(209.1,175.94) 209,176.04 209,176.31 209.1,176.41 209.1,176.61 209,176.71 208.7,176.71 208.43,176.44 208.43,176.29 208.63,176.09 208.63,175.93 208.52,175.82 208.36,175.82 208.16,176.02 208.01,176.02 207.89,175.9 207.89,175.75 208.13,175.51 208.13,175.36 208.02,175.24 207.86,175.24 207.62,175.48 207.49,175.48 207.38,175.36 207.38,175.1 207.26,174.99 205.19,174.99 204.9,174.69 204.9,174.49 204.6,174.19 203.89,174.19 203.69,174.39 v1(203.69,174.64) ; v1(187.39,187.4) 187.73,187.4 187.85,187.29 187.85,186.98 187.73,186.86 186.62,186.86 185.03,188.45 182.28,188.45 182,188.73 181.1,188.73 180.96,188.87 v1(180.1,188.87)
  BOTTOM w0.114: U3.P2 189.28,185.9 189.4,186.01 189.4,186.24 189.28,186.35 188.09,186.35 187.86,186.11 187.12,186.11 187.01,186.23 187.01,186.5 187.12,186.61 187.41,186.61 187.57,186.77 187.57,187.22 v1(187.39,187.4) ; v1(175.58,188.03) 175.73,187.88 175.73,187.68 175.63,187.57 175.63,187.41 176,187.04 176,186.56 176.21,186.36 176.49,186.36 176.58,186.44 176.74,186.44 176.87,186.31 176.87,186.15 176.72,186 176.72,185.64 176.9,185.47 177.32,185.47 177.43,185.58 177.43,185.78 177.32,185.9 U2.P2 ; U4.P2 205.61,171.48 205.13,171.48 204.93,171.68 204.93,171.91 204.53,172.31 204.53,172.97 204.36,173.15 204.36,173.97 v1(203.69,174.64) ; U5.P2 217.94,170.73 218.05,170.62 218.24,170.62 218.35,170.73 218.35,171.37 218.24,171.48 217.84,171.48 217.69,171.33 217.44,171.33 217.28,171.48 217,171.48 216.8,171.68 216.8,172.17 216.29,172.69 216.29,172.92 v1(216.43,173.05)
  BOTTOM w0.127: v1(196.13,184.31) 196.13,184.01 195.68,183.57 195.68,182.51 v1(194.73,181.56) 194.35,181.17 194.35,180.28 194.46,180.16 194.46,178.22 189.93,173.68 188.64,173.68 184.87,169.92 184.87,168.65 184.59,168.37 184.59,168.11 184.35,167.87 184.34,167.85 184.34,167.79 184.11,167.56 183.91,167.56 183.62,167.27 183.62,166.68 U34.M25
FBA_CMD23: length 142.5
  TOP w0.114: v1(187.26,190.95) 187.26,190.28 188.1,189.45 188.1,188.55 187.98,188.44 187.83,188.44 187.67,188.27 187.67,187.89 187.86,187.7 187.86,187.19 188.21,186.84 U3.R3 ; U2.R3 176.34,187.02 176.2,187.16 176,187.36 176,188.27 174.03,190.24 v1(174.03,190.83) ; v1(204.38,174.64) 204.82,174.64 204.93,174.52 204.93,174.24 204.82,174.12 204.49,174.12 204.38,174.01 204.38,173.85 204.51,173.72 204.82,173.72 204.93,173.6 204.93,173.29 204.93,172.48 205.17,172.24 205.59,172.24 205.7,172.13 205.7,171.93 205.59,171.82 U4.R3 ; U5.R3 217.14,172.14 216.8,172.48 216.8,172.76 216.84,172.8 216.84,173.37 216.73,173.49 216.32,173.49 216.24,173.56 215.64,173.56 215.53,173.68 215.53,173.91 215.64,174.02 215.92,174.02 216.04,174.13 216.04,174.21 216.2,174.38 216.47,174.38 216.63,174.21 v1(216.63,173.94)
  TOP w0.127: R17.1 194.03,189.11 194.37,189.45 195.7,189.45 R18.2 196.2,188.97 v1(197.55,187.63)
  IN1 w0.127: v1(210.95,177.51) 211.06,177.63 211.06,178.08 210.93,178.2 210.45,178.2 210.32,178.08 210.32,177.87 210.2,177.75 209.82,177.75 209.69,177.87 209.69,178.65 209.51,178.82 209.51,179.11 205.21,183.41 204.84,183.41 204.71,183.54 204.71,183.66 204.58,183.79 204.25,183.79 204.13,183.66 204.13,183.59 203.97,183.43 203.54,183.43 203.23,183.75 202.16,183.75 198.35,187.56 197.61,187.56 v1(197.55,187.63) 194.34,190.84 191.84,191.84 189.58,191.84 188.09,193.34 184.37,193.34 182.76,193.04 182.21,192.49 180.97,192.49 v1(180.52,192.95)
  IN2 w0.127: 210.95,177.53 211.35,177.12 211.87,177.12 212.94,176.04 213.12,176.04 213.31,176.23 213.49,176.23 213.67,176.05 213.67,175.87 213.48,175.69 213.48,175.51 214.76,174.22 216.35,174.22 v1(216.63,173.94) ; 210.95,177.53 210.72,177.3 209.89,177.3 209.45,176.87 209.32,176.87 209.14,177.04 208.56,177.04 206.84,175.32 205.06,175.32 v1(204.38,174.64) ; 210.95,177.53 v1(210.95,177.51) ; v1(187.26,190.95) 186.81,190.5 186.42,190.5 185.19,191.73 182.62,191.73 181.89,192.45 181.01,192.45 v1(180.52,192.95) 180.1,193.37 176.62,193.37 175.96,192.7 175.96,192.52 175.57,192.13 175.39,192.13 175.09,191.84 175.09,191.65 174.79,191.35 174.79,191.34 174.78,191.33 174.59,191.33 174.08,190.83 v1(174.03,190.83)
  BOTTOM w0.114: U5.R3 217.14,172.14 216.8,172.48 216.8,172.76 216.84,172.8 216.84,173.34 216.7,173.49 216.32,173.49 216.2,173.6 215.62,173.6 215.5,173.72 215.5,173.98 215.62,174.09 215.97,174.09 216.09,174.2 216.09,174.24 216.2,174.35 216.52,174.35 216.63,174.24 v1(216.63,173.94) ; U3.R3 187.87,187.03 187.87,187.65 187.57,187.96 187.57,188.28 188.1,188.81 188.1,189.53 187.26,190.37 v1(187.26,190.95) ; U2.R3 176.34,187.02 176,187.36 176,188.25 174.03,190.23 v1(174.03,190.83) ; U4.R3 205.64,171.82 205.75,171.93 205.75,172.13 205.64,172.25 204.91,172.25 204.79,172.37 204.79,172.71 204.94,172.86 204.94,173.04 204.82,173.16 204.7,173.16 204.58,173.27 204.58,173.52 204.97,173.91 204.97,174.52 204.85,174.64 v1(204.38,174.64)
  BOTTOM w0.127: v1(197.55,187.63) 197.55,187.24 196.89,186.58 196.89,183.84 196.61,183.56 196.61,180.79 195.52,179.7 195.52,177.87 190.34,172.69 189.05,172.69 185.59,169.23 185.59,168.36 185.3,168.07 185.3,167.78 185.65,167.42 U34.K26
FBA_CMD24: length 128.2
  TOP w0.114: U2.P7 173.69,186.45 173.69,186.96 173.91,187.18 173.91,187.76 v1(174.13,187.98) ; U4.P7 202.59,171.54 202.59,171.55 202.84,171.79 203.42,171.79 203.9,172.27 203.9,173.01 v1(203.55,173.36) ; U5.P7 214.08,171.02 215.1,172.04 215.1,172.49 215.35,172.74 215.35,172.9 215.15,173.1 v1(215.06,173.1) ; v1(187.68,189.28) 187.68,188.91 185.64,186.86 185.64,186.52 U3.P7
  TOP w0.127: v1(197.65,182.85) 197.11,183.39 R40.2 195.42,183.64 R39.1
  IN1 w0.127: v1(215.06,173.1) 214.9,173.1 214.72,173.28 214.42,173.28 214.02,172.89 213.84,172.89 213.66,173.06 213.66,173.24 214.1,173.69 214.1,173.85 213.88,174.07 213.72,174.07 213.35,173.69 213.19,173.69 212.98,173.9 212.98,174.06 213.37,174.45 213.37,174.63 213.23,174.77 211.34,174.77 210.53,175.59 210.53,175.7 v1(210.41,175.81) 210.22,175.81 210.1,175.69 210.1,175.36 210.81,174.65 210.81,174.47 210.63,174.29 210.45,174.29 209.59,175.15 209.59,176.23 209.39,176.42 208.92,176.42 208.52,176.02 207.92,176.02 206.9,177.04 206.13,177.04 204.32,178.84 203.46,178.84 202.25,180.06 201.26,180.06 201.08,180.23 201.08,180.79 199.82,182.05 198.91,182.05 198.34,182.62 197.88,182.62 v1(197.65,182.85) 197.65,182.98 196.8,183.83 196.8,184.75 194.73,186.81 193.95,186.81 191.03,189.73 188.64,189.73 188.27,190.11 185.82,190.11 183.98,189.49 181.44,189.49 v1(181.43,189.51)
  IN2 w0.102: v1(186.05,164.28) 186.5,164.73 186.5,166.34 186.52,166.37
  IN2 w0.127: v1(210.41,175.81) 210.07,175.81 209.52,175.26 209.42,175.16 209.03,175.16 208.44,174.58 208.2,174.58 207.95,174.33 205.67,174.33 204.88,173.53 203.72,173.53 v1(203.55,173.36) ; v1(187.68,189.28) 187.91,189.28 188.07,189.11 188.07,188.81 187.95,188.69 186.88,188.69 186.72,188.53 185.88,188.53 185.3,189.11 182.55,189.11 182.19,189.48 181.45,189.48 v1(181.43,189.51) 181.01,189.92 180.44,189.92 180.21,189.7 179.47,189.7 179.39,189.62 177.39,189.62 177.13,189.89 176.56,189.89 176.01,189.34 175.43,189.34 174.13,188.04 v1(174.13,187.98)
  IN2 w0.165: v1(197.65,182.85) 197.49,183.02 197.05,183.02 196.89,182.85 196.89,180.75 193.26,177.12 193.26,174.86 188.01,169.61 188.01,168.3 186.52,166.81 186.52,166.37
  BOTTOM w0.102: U34.K22 v1(186.05,164.28)
  BOTTOM w0.114: v1(187.68,189.28) 187.68,188.94 185.72,186.98 185.72,186.61 U3.P7 ; U4.P7 202.07,171.04 202.87,171.84 203.48,171.84 203.59,171.95 203.59,172.17 203.44,172.32 203.44,172.64 203.74,172.94 203.74,173.16 v1(203.55,173.36) ; v1(215.06,173.1) 215.15,173.1 215.33,172.93 215.33,172.72 215.1,172.49 215.1,172.01 214.11,171.02 U5.P7 ; U2.P7 173.72,186.47 173.72,186.77 173.91,186.97 173.91,187.76 v1(174.13,187.98)
FBA_CMD25: length 105.8
  TOP w0.114: U5.L3 216.23,168.62 215.65,169.2 v1(215.65,169.45) ; v1(175.5,183.84) 175.4,183.74 175.4,183.31 175.55,183.16 175.77,183.16 175.91,183.3 175.91,183.54 176.01,183.64 176.2,183.64 U2.L3 ; U4.L3 205.05,168.84 205.05,169.11 204.8,169.35 204.42,169.35 203.96,169.82 v1(203.96,169.82) ; v1(187.49,183.26) 187.67,183.08 188.54,183.08 188.66,183.19 188.66,183.38 188.54,183.5 U3.L3
  TOP w0.127: R56.1 202.27,179.07 201.76,178.56 201.12,178.56 R55.2 199.45,177.9 196.78,177.9 v1(196.65,178.04)
  IN1 w0.127: v1(209.79,170.95) 209.58,170.73 205.45,170.73 204.79,171.4 204.79,171.6 204.48,171.9 201.38,171.9 199.3,173.98 199.3,174.25 199.3,174.57 196.81,177.06 196.51,177.06 196.46,177.01 196.28,177.01 196.05,177.24 196.05,177.44 v1(196.65,178.04) 195.84,178.22 193.68,180.39 193.68,181.18 193.4,181.68 191.51,183.57 189.34,183.8 187.85,184.08 187.57,184.08 186.91,184.33 186.65,184.59 185.34,184.59 183.27,184.02 v1(181.69,183.65)
  IN2 w0.127: v1(215.65,169.45) 215.55,169.35 215.18,169.35 214.99,169.54 214.11,169.54 213.06,170.59 212.61,170.59 211.7,171.51 211.33,171.51 211.17,171.35 210.3,171.35 209.89,170.95 v1(209.79,170.95) 209.64,171.1 209.46,171.1 209.37,171.01 209,171.01 208.92,170.92 208.72,170.92 208.59,171.05 206.79,171.05 206.59,171.25 206.42,171.25 206.31,171.14 206.31,170.96 206.2,170.85 205.99,170.85 205.88,170.73 205.88,170.68 205.76,170.57 205.12,170.57 204.84,170.28 204.12,170.28 204.02,170.18 204.02,169.88 v1(203.96,169.82) ; v1(187.49,183.26) 187.3,183.45 187.22,183.45 186.94,183.72 186.59,183.72 186.57,183.7 185.45,183.7 185.22,183.93 183.21,183.93 183.07,184.07 182.85,184.07 182.74,183.96 182.74,183.8 182.63,183.69 182.37,183.69 182.26,183.8 182.26,183.96 182.14,184.07 181.8,184.07 181.69,183.96 v1(181.69,183.65) 181.38,183.65 181.03,183.99 180.78,183.99 180.16,184.62 179.5,184.62 179.35,184.76 176.68,184.76 175.76,183.84 v1(175.5,183.84) ; v1(186.91,165.12) 186.91,166.04 187.86,166.99
  IN2 w0.165: 187.86,166.99 187.86,167.63 188.38,168.15 188.38,169.46 193.62,174.7 193.62,176.97 194.4,177.75 196.36,177.75 v1(196.65,178.04)
  BOTTOM w0.114: U3.L3 187.99,183.5 187.72,183.76 187.37,183.76 187.32,183.81 187.18,183.81 187.08,183.71 187.08,183.57 187.2,183.46 187.4,183.26 v1(187.49,183.26) ; U4.L3 205.05,168.84 205.05,169.11 204.8,169.35 204.42,169.35 203.96,169.82 v1(203.96,169.82) ; U34.J23 186.48,164.72 186.88,165.12 v1(186.91,165.12) ; v1(175.5,183.84) 175.37,183.71 175.37,183.22 175.49,183.1 175.7,183.1 175.83,183.23 175.83,183.37 176,183.54 176.3,183.54 U2.L3 ; v1(215.65,169.45) 215.65,169.2 216.23,168.62 U5.L3
FBA_CMD26: length 150.2
  TOP w0.114: v1(214.69,172.56) 214.58,172.45 214.58,171.82 214.23,171.48 212.94,171.48 212.74,171.28 212.74,170.71 212.85,170.59 213.38,170.59 213.5,170.71 213.5,170.91 213.38,171.02 U5.P8 ; U4.P8 200.96,171.02 200.85,171.13 200.85,171.36 200.96,171.47 202.2,171.47 202.44,171.71 202.44,172.2 202.6,172.37 203.05,172.37 203.16,172.48 203.16,172.71 203.05,172.83 202.92,172.83 202.81,172.94 202.81,173.26 v1(202.91,173.36) ; U3.P8 184.67,186.36 185.15,186.36 185.38,186.59 185.38,187.04 187.05,188.71 v1(187.05,189.33) ; U2.P8 172.8,186.36 173.28,186.36 173.48,186.56 173.48,187.05 173.7,187.27 173.7,188.16 174.03,188.49 174.5,188.49 174.61,188.6 174.61,188.91 174.5,189.02 v1(174.28,189.02)
  TOP w0.127: R26.1 194.03,186.31 194.52,186.81 195.68,186.81 R27.2 197.27,185.22 197.27,184.65 v1(197.57,184.35)
  IN1 w0.127: 197.57,184.37 197.57,184.91 194.92,187.56 194.19,187.56 191.23,190.52 189.01,190.52 188.11,191.42 185.53,191.42 184.17,191 181.27,190.31 180.76,190.24 180.05,190.24 v1(179.95,190.14) 179.93,190.13 179.93,189.47 179.16,188.69 179.16,187.96 179.03,187.83 178.78,187.83 178.65,187.96 178.65,188.21 178.52,188.34 178.24,188.34 178.12,188.21 178.12,187.93 177.99,187.8 177.69,187.8 177.56,187.93 177.56,188.21 177.43,188.34 177.1,188.34 176.97,188.21 176.97,187.83 176.85,187.7 176.36,187.7 176.19,187.88 176.19,188.21 175.37,189.02 v1(174.28,189.02) ; 197.57,184.37 v1(197.57,184.35) ; 197.57,184.37 199.24,182.71 199.5,182.71 199.82,183.03 200.06,183.03 200.19,182.9 200.19,182.61 201.42,181.38 201.69,181.38 201.82,181.5 201.82,181.66 201.94,181.78 202.22,181.78 202.35,181.66 202.35,181.22 202.53,181.05 203.05,181.05 204.19,179.9 204.38,179.9 204.61,180.13 204.89,180.13 205,180.03 205.32,179.7 205.32,179.42 205.12,179.22 205.12,178.98 205.47,178.63 207.66,178.63 207.82,178.47 207.82,178.24 207.67,178.09 207.67,177.91 207.85,177.73 208.03,177.73 208.31,178.01 208.49,178.01 208.7,177.8 208.7,177.62 208.51,177.43 208.51,177.22 208.65,177.08 210.24,177.08 210.79,176.53 211.23,176.53 211.36,176.4 v1(211.36,175.85)
  IN2 w0.127: v1(187.05,189.33) 187.05,189.13 186.93,189.02 186.74,189.02 186.58,188.86 186.02,188.86 185.44,189.44 182.69,189.44 182.27,189.86 181.75,189.86 181.34,190.27 180.48,190.27 180.47,190.27 180.47,190.27 179.84,190.9 179.53,190.9 179.41,190.79 179.41,190.52 179.79,190.14 v1(179.95,190.14) ; v1(202.91,173.36) 203.36,172.92 203.83,172.92 204.12,173.2 205.01,173.2 205.81,173.99 208.09,173.99 208.34,174.25 208.58,174.25 209.16,174.83 209.56,174.83 210.01,175.29 210.81,175.29 v1(211.36,175.85) 211.2,175.85 211.08,175.96 211.08,176.34 211.2,176.46 211.59,176.46 211.82,176.23 211.82,175.88 211.94,175.77 212.28,175.77 212.41,175.64 212.41,175.48 212.18,175.24 212.18,175.08 212.4,174.86 212.57,174.86 212.77,175.07 212.93,175.07 213.13,174.87 213.13,174.71 212.82,174.4 212.82,174.24 213.02,174.04 213.18,174.04 213.52,174.37 213.68,174.37 213.88,174.17 213.88,174.01 213.54,173.68 213.54,173.52 213.74,173.32 213.9,173.32 214.22,173.64 214.39,173.64 214.58,173.44 214.58,173.28 214.37,173.06 214.37,172.88 v1(214.69,172.56)
  BOTTOM w0.114: U3.P8 184.67,186.36 185.15,186.36 185.51,186.72 185.51,187.21 187.05,188.75 v1(187.05,189.33) ; v1(174.28,189.02) 174.28,188.84 173.7,188.26 173.7,187.17 173.48,186.95 173.48,186.56 173.28,186.36 172.19,186.36 172.07,186.25 172.07,185.98 172.15,185.9 U2.P8 ; v1(214.69,172.56) 214.46,172.34 214.46,171.87 214.07,171.48 212.8,171.48 212.69,171.36 212.69,170.71 212.8,170.59 213.36,170.59 213.47,170.71 213.47,170.91 213.36,171.02 U5.P8 ; v1(202.91,173.36) 202.74,173.36 202.63,173.25 202.63,173.04 202.74,172.93 202.94,172.93 203.06,172.81 203.06,172.59 202.94,172.47 202.82,172.47 202.7,172.36 202.7,171.98 202.21,171.48 200.99,171.48 200.87,171.37 200.87,171.18 200.99,171.07 201.22,171.07 U4.P8
  BOTTOM w0.127: v1(197.57,184.35) 197.22,183.99 197.22,183.7 196.94,183.42 196.94,180.62 196.13,179.8 196.13,179.37 196.61,178.89 196.61,178.63 196.18,178.2 196.18,177.6 195.54,176.96 195.54,176.14 195.11,175.71 194.29,175.71 190.61,172.03 189.32,172.03 186.1,168.81 186.1,166.68 U34.J25
FBA_CMD27: length 113.7
  TOP w0.127: v1(196.66,179.69) 196.66,180.21 198.77,182.32 198.77,183.94 199.99,185.16 R31.2 201.12,185.67 202.26,185.67 R32.1
  IN1 w0.127: v1(209.86,172.2) 209.75,172.31 209.54,172.31 209.31,172.08 209.11,172.08 208.88,172.31 208.7,172.31 208.57,172.18 208.57,171.85 208.45,171.73 208.11,171.73 207.99,171.85 207.99,171.97 207.86,172.09 207.53,172.09 207.4,171.97 207.4,171.85 207.28,171.73 206.95,171.73 206.82,171.85 206.82,172.31 206.69,172.44 206.46,172.44 206.34,172.31 206.34,171.85 206.21,171.73 205.93,171.73 205.8,171.85 205.8,172.23 205.6,172.44 205.35,172.44 204.89,172.89 201.79,172.89 200.29,174.39 200.29,175.05 198.06,177.29 198.06,178.52 197.57,179.01 197.34,179.01 197.1,179.25 197.1,179.48 196.89,179.69 v1(196.66,179.69) 195.46,180.89 194.39,182.17 194.13,182.43 193.5,183.15 191.12,185.55 190.14,185.8 187.81,186.6 185.31,186.6 183.83,185.77 181.9,185.77 181.46,186.21 181.05,186.21 v1(179.82,185.29)
  IN2 w0.127: v1(185.61,184.14) 185.49,184.26 184.56,184.26 184.33,184.49 184.18,184.49 183.94,184.26 183.78,184.26 183.65,184.38 183.65,184.53 183.51,184.68 183.35,184.68 183.22,184.55 183.22,184.53 183.1,184.4 182.71,184.4 182.59,184.27 182.41,184.27 182.28,184.4 181.91,184.4 181.8,184.51 181.8,184.55 181.69,184.66 181.38,184.66 181.27,184.55 181.27,184.46 181.13,184.32 180.92,184.32 180.69,184.56 180.69,184.76 180.42,185.04 180.28,185.04 180.19,184.95 179.97,184.95 179.82,185.1 v1(179.82,185.29) 179.48,185.29 179.45,185.26 176.21,185.26 176.01,185.06 176.01,184.6 175.7,184.3 175.25,184.3 174.85,183.9 174.38,183.9 174.19,183.71 173.91,183.71 173.78,183.84 v1(173.78,184.4) ; v1(203.24,170.44) 203.74,170.94 204.56,170.94 204.87,171.25 205.4,171.25 206.13,171.99 206.93,171.99 207.21,171.71 209.13,171.71 209.23,171.81 209.46,171.81 v1(209.86,172.2) 209.98,172.2 210.09,172.32 210.09,172.67 210.3,172.88 210.5,172.88 210.6,172.78 210.6,172.67 210.72,172.56 211.05,172.56 211.16,172.45 211.16,172.31 211.28,172.19 211.64,172.19 211.83,172.38 211.98,172.38 212.06,172.3 212.06,172.07 212.2,171.94 212.33,171.94 212.45,172.05 212.63,172.05 212.77,171.92 212.77,171.76 212.66,171.65 212.66,171.48 212.81,171.33 212.94,171.33 213.04,171.43 213.15,171.43 214.38,170.2 214.67,170.2 v1(214.78,170.32)
  BOTTOM w0.114: U28.M3 173.02,184.3 172.91,184.18 172.91,184.02 173.02,183.9 173.71,183.9 173.82,184.02 173.82,184.36 v1(173.78,184.4) ; U31.M3 202.24,169.42 202.54,169.72 202.95,169.72 203.24,170.01 v1(203.24,170.44) ; U29.M3 184.76,184.3 184.65,184.18 184.65,183.96 184.76,183.84 185.41,183.84 185.61,184.04 v1(185.61,184.14) ; v1(214.78,170.32) 214.3,169.83 213.79,169.83 213.68,169.71 213.68,169.53 213.79,169.42 U32.M3
  BOTTOM w0.127: U34.J24 186.45,165.82 186.81,166.18 186.81,168.11 186.72,168.21 186.72,168.77 187.08,169.14 187.82,169.14 190.06,171.37 190.88,171.37 194.34,174.82 v1(194.55,174.82) 194.73,174.65 194.99,174.65 197.06,176.71 198.24,176.71 198.44,176.91 198.44,177.93 198.04,178.33 198.04,180.02 197.78,180.29 197.78,181.17 197.65,181.3 197.4,181.3 197.27,181.17 197.27,180.48 196.66,179.87 v1(196.66,179.69)
FBA_CMD28: length 108.6
  TOP w0.102: U5.L7 214.12,168.62 214.26,168.76 214.26,168.89 214.61,169.24 214.77,169.24 214.91,169.1 214.91,168.94 v1(214.69,168.72)
  TOP w0.114: U4.L7 201.83,168.62 201.71,168.73 201.71,168.97 201.83,169.08 202.85,169.08 v1(202.86,169.09) ; U3.L7 185.32,183.5 185.33,183.51 186.02,183.51 186.45,183.94 v1(186.45,184.16) ; v1(174.64,184.35) 174.02,183.73 173.38,183.73 U2.L7
  TOP w0.127: v1(196.08,178.77) 195.78,179.07 R54.2 194.15,178.8 194.28,178.68 R57.1
  IN1 w0.127: v1(210.28,170.13) 210.28,169.85 210.16,169.72 209.89,169.72 209.77,169.85 209.77,170.29 210.3,170.83 210.3,171.07 209.97,171.39 209.61,171.39 209.28,171.06 205.63,171.06 205.12,171.57 205.12,171.74 204.62,172.23 201.51,172.23 199.63,174.11 199.63,174.72 196.96,177.39 196.96,177.64 197.09,177.77 197.09,178.22 196.83,178.48 196.37,178.48 v1(196.08,178.77) 194.52,180.01 194.01,180.52 194.01,181.31 193.73,181.82 191.72,183.83 189.38,184.15 188.13,184.85 187.85,185.34 187.59,185.81 187.37,185.9 187.06,185.84 186.86,185.75 186.47,185.37 185.59,185.09 182.92,184.36 182.33,184.36 180.3,184.61 179.66,184.82 179.31,185.17 179.31,185.67 v1(179.26,185.72) 179.03,185.72 178.9,185.59 178.9,184.96 178.78,184.83 178.55,184.83 178.42,184.96 178.42,185.34 178.3,185.47 178.04,185.47 177.91,185.34 177.91,184.43 177.79,184.3 177.56,184.3 177.43,184.43 177.43,184.93 177.3,185.06 177.06,185.06 176.95,184.95 176.95,184.41 176.83,184.3 174.69,184.3 v1(174.64,184.35)
  IN2 w0.127: v1(214.69,168.72) 214.74,168.67 214.74,168.46 214.62,168.33 214.35,168.33 214.23,168.45 214.23,168.77 214.12,168.88 213.75,168.88 213.53,169.1 213.53,169.18 213.29,169.42 213.07,169.42 212.91,169.27 212.62,169.27 212.29,169.59 212.29,169.71 212.19,169.81 211.97,169.81 211.67,169.51 211.67,169.18 211.55,169.07 211.38,169.07 211.26,169.18 211.26,169.64 211.16,169.74 210.96,169.74 210.86,169.64 210.86,169.41 210.74,169.3 210.61,169.3 210.53,169.37 210.37,169.37 210.15,169.6 210.15,169.73 210.32,169.91 210.32,170.1 v1(210.28,170.13) 210.12,170.13 210.06,170.07 208.63,170.07 208.35,170.35 207.21,170.35 206.67,169.8 205.29,169.8 204.87,169.38 204.45,169.38 204.43,169.37 203.28,169.37 203.01,169.09 v1(202.86,169.09) ; v1(179.26,185.72) 179.31,185.77 180.15,185.77 180.93,184.99 181.72,184.99 182.05,185.33 183.08,185.33 183.4,185.01 183.64,185.01 183.83,184.82 184.46,184.82 184.7,184.59 185.79,184.59 186.21,184.16 v1(186.45,184.16)
  BOTTOM w0.114: U4.L7 202.07,168.47 202.17,168.37 202.31,168.37 202.57,168.63 202.57,168.77 202.44,168.9 202.44,169.01 202.63,169.2 202.75,169.2 v1(202.86,169.09) ; v1(186.45,184.16) 186.45,183.94 186,183.5 U3.L7 ; v1(214.69,168.72) 214.93,168.96 214.93,169.11 214.75,169.29 214.59,169.29 213.94,168.64 U5.L7 ; v1(174.64,184.35) 173.98,183.69 173.33,183.69 U2.L7
  BOTTOM w0.127: U34.K27 185.81,168.08 185.81,168.99 189.19,172.36 190.47,172.36 195.85,177.73 195.85,178.54 v1(196.08,178.77)

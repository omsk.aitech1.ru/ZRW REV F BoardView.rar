# Allegro board Quanta ZRW REV F - BoardView (.BRD).brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
CLK_PCI_LPC_C: length 2.5
  BOTTOM w0.114: R694.1 178.1,91.61 179.02,91.61 179.41,91.23 CN10.71
CLK_PCIE_LAN_REQ#: length 177.2
  TOP w0.114: R229.1 170.42,101.85 v1(170.55,101.72) ; R276.2 36.92,80 R281.2 37.16,78.54 37.6,78.1 38.7,78.1 40.09,79.5 Q25.3 41.62,78.35 v3(41.62,77.31) 41.62,70.73 v1(43.01,69.34)
  IN1 w0.127: v1(170.55,101.72) 171.28,101.72 171.86,101.15 171.86,98.36 v1(172.3,97.91)
  IN2 w0.127: v1(43.01,69.34) 44.95,71.27 62.24,71.27 62.52,70.99 68.08,70.99 68.36,71.27 73.14,71.27 74.41,72.54 83.58,72.54 91.17,80.13 93.14,80.13 95.85,82.84 v1(95.85,86.36) ; v1(164.49,82.09) 164.49,88.99 166.2,90.71 166.2,92.25 166.59,92.63 169.94,92.63 171.42,94.12 171.42,97.04 v1(172.3,97.91)
  BOTTOM w0.114: v1(164.49,82.09) 164.47,82.06 149.62,82.06 145.28,86.41 95.9,86.41 v1(95.85,86.36)
CLK_PCIE_LANN: length 133.1
  TOP w0.114: v1(42.99,84.5) 42.76,84.27 39.99,84.27 v1(39.46,84.81) 38.93,84.27 38.24,84.27 38.01,84.04 37.34,84.04 37.22,84.16 37.22,84.27 37.3,84.35 U15.16
  IN2 w0.127: v1(132.64,131.46) 132.45,131.64 132.1,131.64 131.89,131.44 130.52,131.44 130.01,130.93 129.19,130.93 127.97,132.15 127.69,132.15 127.26,132.58 125.92,132.58 122.92,135.58 119.62,135.58 119.57,135.63 115.66,135.63 115.53,135.5 111.87,135.5 111.49,135.89 108.29,135.89 106.91,134.5 106.37,134.5 102.78,130.91 101.4,130.91 100.88,130.39 100.02,130.39 95.69,126.07 95.69,118.07 92.61,114.99 88.9,114.99 87.72,113.81 87.72,110.36 86.17,108.81 82.5,108.81 76.03,102.35 74.08,102.35 73.08,101.34 55.08,101.34 45.17,91.44 45.17,89.68 43.14,87.65 43.14,86.12 42.38,85.36 42.38,84.43 42.54,84.27 42.76,84.27 v1(42.99,84.5)
  BOTTOM w0.114: U35.B40 133.16,130.6 133.16,131.34 133.04,131.46 v1(132.64,131.46)
CLK_PCIE_LANP: length 134.1
  TOP w0.114: U15.15 36.9,84.35 36.98,84.27 36.98,84.06 37.24,83.8 38.11,83.8 38.34,84.03 38.96,84.03 v1(39.46,83.54) 39.95,84.03 42.72,84.03 v1(42.96,83.79)
  IN2 w0.127: v1(132.64,132.1) 132.44,131.9 131.99,131.9 131.79,131.69 130.41,131.69 129.9,131.19 129.3,131.19 128.08,132.41 127.8,132.41 127.37,132.84 126.02,132.84 123.02,135.84 119.73,135.84 119.68,135.89 115.55,135.89 115.43,135.76 111.98,135.76 111.59,136.14 108.19,136.14 106.8,134.76 106.27,134.76 102.67,131.16 101.29,131.16 100.78,130.64 99.91,130.64 95.44,126.17 95.44,118.18 92.5,115.24 88.79,115.24 87.46,113.91 87.46,110.46 86.06,109.06 82.39,109.06 75.93,102.6 73.97,102.6 72.97,101.6 54.97,101.6 44.92,91.54 44.92,89.78 42.89,87.75 42.89,86.23 42.13,85.47 42.13,84.32 42.43,84.02 42.74,84.02 v1(42.96,83.79)
  BOTTOM w0.114: v1(132.64,132.1) 133.04,131.7 133.14,131.7 133.4,131.44 133.4,131.01 U35.A40
CLK_PCIE_REQ0#: length 25.8
  TOP w0.114: v2(151.86,112.33) 152.29,111.91 152.29,109.69 154.66,107.32 160.81,107.32 161.28,106.84 162.17,106.84 162.41,106.59 162.79,106.22 164.38,106.22 166.66,103.94 166.66,103.7 167.07,103.28 167.07,102 v3(167.93,101.14) 168.36,100.72 R234.1 R235.2
  BOTTOM w0.076: U35.AR10 151.46,112.73 v2(151.86,112.33)
CLK_PCIE_REQ1#: length 17
  TOP w0.114: v2(152.78,112.41) 153.78,111.4 153.78,111.25 154.44,110.59 155.38,110.59 155.54,110.43 160.27,110.43 161.35,109.34 163.07,109.34 163.63,108.78 164.54,108.78 164.89,109.13 164.9,109.13 164.91,109.14 165.29,109.14 165.98,108.45 TP22.1 166.23,108.53 R215.1
  BOTTOM w0.127: v2(152.78,112.41) U35.AT7
CLK_PCIE_REQ2#: length 23.3
  TOP w0.114: TP25.1 169.12,103.76 R227.1 168.62,102.87 168.24,103.25 168.24,104.77 167.35,105.66 166.91,105.66 165.31,107.27 162.99,107.27 162.53,107.73 161.65,107.73 161.17,108.21 155.03,108.21 154.01,109.22 154.01,110.46 152.78,111.69 v1(152.78,111.76)
  BOTTOM w0.127: v1(152.78,111.76) U35.AT8
CLK_PCIE_REQ3#: length 14.7
  IN1 w0.127: v1(159.6,109.5) 159.12,109.5 158.58,108.96 158.58,108.54 158,107.95 157.31,107.95 155.54,109.72 155.54,110.82 154.9,111.45 153.84,111.45 153.06,110.68 152.6,110.68 152.35,110.93 152.35,111.24 v2(151.87,111.71)
  BOTTOM w0.076: 160.36,109.47 159.63,109.47 v1(159.6,109.5) ; v2(151.87,111.71) 151.5,112.08 U35.AT10
  BOTTOM w0.114: 160.36,109.47 TP73.1 160.9,109.72 R618.1
CLK_PCIE_REQ4#: length 25.6
  TOP w0.114: v2(152.78,111.11) 152.78,110.43 v3(152.82,110.38) 152.82,109.78 154.84,107.76 160.99,107.76 161.47,107.28 162.35,107.28 162.86,106.77 162.93,106.71 165.24,106.71 165.7,106.24 165.7,105.53 166.33,104.9 167.47,104.9 167.78,104.6 167.78,102.77 168.69,101.85 R229.2 169.12,102.17 169.24,102.29 170.23,102.29 170.8,102.87 R228.1
  BOTTOM w0.127: v2(152.78,111.11) U35.AU8
CLK_PCIE_REQ5#: length 23.7
  TOP w0.114: R224.2 172.66,104.39 172.53,104.26 R223.1 171.93,104.76 171.67,105.02 168.87,105.02 167.58,106.32 167.58,106.96 167.35,107.18 166.31,107.18 165.29,108.2 163.39,108.2 163.23,108.35 161.66,108.35 160.95,109.06 159.42,109.06 159.22,109.27 v3(155.55,109.27) v2(154.68,110.14)
  BOTTOM w0.089: U35.AU7 153.92,110.74 153.92,110.64 154.43,110.14 v2(154.68,110.14)
CLK_PCIE_VGA: length 57.8
  IN2 w0.127: v1(173.62,151.84) 173.82,151.63 174.01,151.63 174.16,151.49 174.16,151.15 171.44,148.43 164.93,148.43 164.1,147.6 164.08,147.6 163.82,147.33 162.62,147.33 162.2,146.91 160.53,146.91 159.87,146.25 159.18,146.25 155.49,142.56 155.49,141.55 155.15,141.22 155.15,140.96 154.42,140.23 144.35,140.23 137.58,133.46 137.58,132.81 137.45,132.69 v1(137.17,132.69)
  BOTTOM w0.076: 134.45,133.15 134.44,133.15 134.37,133.22 132.55,133.22 132.23,132.9 132.23,131.76 132.06,131.59 132.06,130.82 132.09,130.76 132.09,130.47 132.06,130.4 132.06,130.21 132.15,129.99 132.15,129.68 132.19,129.64 U35.C42
  BOTTOM w0.114: 134.45,133.15 135.98,133.15 136.18,133.35 137.33,133.35 137.58,133.09 137.58,132.81 137.45,132.69 v1(137.17,132.69) ; v1(173.62,151.84) 173.14,151.84 173.01,151.96 173.01,152.17 173.11,152.26 U34.AE8
CLK_PCIE_VGA#: length 57.8
  IN2 w0.127: v1(174.43,151.84) 174.43,151.04 171.55,148.15 165.05,148.15 164.21,147.32 164.2,147.32 163.93,147.05 162.74,147.05 162.32,146.63 160.64,146.63 159.98,145.97 159.29,145.97 155.77,142.44 155.77,141.43 155.43,141.1 155.43,140.85 154.54,139.95 144.46,139.95 137.86,133.35 137.86,132.84 v5(138.01,132.69)
  BOTTOM w0.076: U35.D42 131.98,129.35 131.98,129.96 131.89,130.18 131.89,130.43 131.93,130.51 131.93,130.72 131.9,130.79 131.9,130.79 131.9,131.66 132.07,131.83 132.07,132.97 132.48,133.38 134.37,133.38 134.44,133.45 134.45,133.45
  BOTTOM w0.114: v5(138.01,132.69) 137.88,132.81 137.88,133.22 137.45,133.65 136.05,133.65 135.85,133.45 134.45,133.45 ; U34.AD8 174.21,152.09 174.21,152.07 v1(174.43,151.84)
CLK_PCIE_WLANN: length 108.8
  IN2 w0.127: v1(181.55,123.06) 181.85,123.36 181.85,123.54 181.32,124.07 181.32,124.3 181.03,124.59 181.03,129.19 180.3,129.91 180.3,130.48 180.66,130.84 180.66,133.75 178.26,136.14 177.96,136.14 174.89,139.21 174.89,139.84 174.63,140.1 174.23,140.1 172.14,142.19 171.69,142.19 168.54,145.33 166.48,145.33 166.28,145.54 165.55,145.54 165.35,145.33 164.99,145.33 164.53,144.88 161.94,144.88 158.92,141.85 158.17,141.85 157.44,141.13 157.44,140.38 156.25,139.19 144.85,139.19 139.84,134.18 139.84,133.68 140.04,133.47 140.04,129.66 140.02,129.64 140.02,128.14 139.51,127.63 137.76,127.63 137.17,127.05 136.09,127.05 135.58,127.55 134.48,127.55 134.2,127.83 134.2,128.01 133.74,128.47 v2(133.57,128.47)
  BOTTOM w0.114: U35.E40 133.78,128.47 v2(133.57,128.47) ; CN10.49 181.02,96.72 181.15,96.85 182.04,96.85 183.48,98.29 183.48,100.22 182.55,101.15 182.55,106.55 183.46,107.46 183.46,109.71 184.39,110.63 184.39,115.56 182.79,117.16 182.79,119.83 v3(183.07,120.11) 182.77,120.42 182.77,122.41 182.36,122.82 181.79,122.82 v1(181.55,123.06)
CLK_PCIE_WLANP: length 108.8
  IN2 w0.127: v1(181.57,122.42) 182.11,122.96 182.11,123.64 181.57,124.18 181.57,124.41 181.28,124.7 181.28,129.29 180.56,130.02 180.56,130.37 180.91,130.73 180.91,133.85 178.37,136.39 178.07,136.39 175.15,139.31 175.15,139.95 174.74,140.36 174.33,140.36 172.25,142.44 171.8,142.44 168.65,145.59 166.59,145.59 166.38,145.79 165.44,145.79 165.24,145.59 164.89,145.59 164.43,145.13 161.83,145.13 158.81,142.11 158.06,142.11 157.19,141.23 157.19,140.49 156.14,139.44 144.74,139.44 139.59,134.29 139.59,133.57 139.79,133.37 139.79,129.77 139.76,129.74 139.76,128.24 139.41,127.88 137.65,127.88 137.07,127.3 136.2,127.3 135.69,127.81 134.58,127.81 134.45,127.94 v2(134.45,128.55)
  BOTTOM w0.114: v2(134.45,128.55) 134.62,128.55 U35.E38 ; CN10.47 181.02,97.23 181.15,97.1 181.94,97.1 183.24,98.39 183.24,100.12 182.31,101.05 182.31,106.65 183.22,107.56 183.22,109.81 184.15,110.73 184.15,115.46 182.55,117.06 182.55,119.36 v3(181.8,120.11) 182.52,120.84 182.52,122.31 182.26,122.58 181.72,122.58 v1(181.57,122.42)
CLK_PCIE_XDPN: length 23.5
  IN2 w0.127: v1(130.14,143.47) 130.43,143.18 133.32,143.18 134.43,142.07 134.43,130.7 133.24,129.51 132.89,129.51 132.27,128.89 132.27,127.71 v1(131.74,127.17)
  BOTTOM w0.114: v1(130.14,143.47) 129.86,143.19 129.84,143.19 129.35,142.69 129.24,142.69 129.12,142.81 TP93.1 ; U35.F43 132.03,127.39 131.96,127.39 v1(131.74,127.17)
CLK_PCIE_XDPP: length 22
  IN2 w0.127: v1(130.14,142.6) 130.43,142.9 133.2,142.9 134.15,141.95 134.15,130.82 133.12,129.79 132.78,129.79 131.99,129 131.99,127.99 131.84,127.83 v1(131.74,127.83)
  BOTTOM w0.114: TP94.1 129.12,142.27 129.24,142.39 129.48,142.39 129.69,142.6 v1(130.14,142.6) ; v1(131.74,127.83) 131.82,127.83 U35.E43
CLK_PEGA_REQ#: length 106.4
  TOP w0.114: R92.2 171.79,143.61 v1(172.28,143.12) 172.78,143.63 Q10.3 ; R235.1 170.91,99.94 v3(171.13,99.72) 171.54,99.31 171.54,96.77 171.28,96.52 170.52,96.52 170.14,96.13 170.14,93.59 172.76,90.97 174.12,90.97 174.13,90.98 181.37,90.98 181.83,90.52 181.83,89.05 183.96,86.91 191.48,86.91 191.95,87.38 192.41,87.38 193.59,88.57 193.59,90.52 193.99,90.93 v1(194.6,90.93)
  IN1 w0.127: v1(193.74,97.81) 194.12,97.81 194.91,97.02 194.91,91.23 v1(194.6,90.93)
  IN2 w0.127: v1(172.28,143.12) 173.04,142.36 174.64,142.36 175.15,141.85 175.15,140.85 177.62,138.38 178.19,138.38 178.55,138.02 178.55,137.31 181.71,134.15 181.71,124.9 182,124.61 182,124.38 182.54,123.85 182.54,122.66 183.55,121.64 183.55,116.86 187.01,113.41 187.41,113.41 195.54,105.28 195.54,102.99 195.67,102.87 195.67,99.74 v1(193.74,97.81)
CLK_SCLK: length 163.2
  TOP w0.114: R329.1 195.72,55.8 195.51,55.59 v1(194.42,55.59)
  IN1 w0.127: v1(164.3,43.68) 164.3,43.94 164.67,44.31 165.3,44.31 165.61,44 176.57,44 177.27,44.7 184.96,44.7 186.88,46.62 186.88,47.11 v1(186.73,47.27) ; v1(194.42,55.59) 194.22,55.39 194.01,55.39 193.88,55.52 193.88,59.05 194.55,59.72 195.1,59.72 196.04,60.66 196.04,62.11 196.74,62.81 196.74,69.8 195.48,71.06 195.48,75.23 190.93,79.78 187.39,79.78 186.27,80.89 186.27,83.58 184.87,84.97 184.87,86.44 182.18,89.13 182.18,103.36 178.24,107.3 178.24,108.86 177.18,109.93 177.18,111.46 178.57,112.86 178.57,116.12 177.88,116.82 177.88,120.4 177.52,120.76 177.52,121.49 175.95,123.06 174,123.06 172.68,124.38 172.68,127.38 171.64,128.42 171.64,128.77 171.26,129.15 171.03,129.15 v1(170.8,129.38)
  BOTTOM w0.114: JDIM1.202 163.94,58.89 164.35,58.49 166.89,58.49 167.35,58.03 167.35,55.12 164.41,52.18 163.91,52.18 163.16,51.43 163.16,50.16 163.94,49.37 JDIM2.202 163.94,44.01 164.27,43.68 v1(164.3,43.68) ; v1(170.8,129.38) 170.8,129.33 169.99,128.52 169.51,128.52 169,129.03 R572.1 168.11,128.15 167.11,128.15 166.88,127.92 165.53,127.92 165.42,127.81 165.42,126.82 164.89,126.3 Q32.1 ; v1(194.42,55.59) 194.24,55.41 191.8,55.41 186.91,50.51 186.91,47.44 v1(186.73,47.27)
CLK_SDATA: length 172.4
  TOP w0.114: R336.1 198.73,51.68 195.44,54.96 v1(194.42,54.96)
  IN1 w0.127: v1(170.83,128.75) 170.95,128.88 171.14,128.88 171.36,128.66 171.36,128.31 172.4,127.26 172.4,124.26 173.89,122.78 175.84,122.78 177.24,121.38 177.24,120.65 177.6,120.29 177.6,116.7 178.3,116.01 178.3,112.98 176.9,111.58 176.9,109.81 177.97,108.74 177.97,107.18 181.9,103.25 181.9,89.02 184.59,86.32 184.59,84.86 185.99,83.46 185.99,80.78 187.27,79.5 190.82,79.5 195.2,75.12 195.2,70.94 196.46,69.69 196.46,62.93 195.76,62.23 195.76,60.78 194.98,60 194.44,60 193.6,59.17 193.6,55.41 193.89,55.11 194.27,55.11 v1(194.42,54.96) ; v1(187.39,47.24) 187.16,47.01 187.16,46.5 185.08,44.42 177.38,44.42 176.68,43.72 171.59,43.72 171.44,43.57 171.44,42.99 171.28,42.83 171.07,42.83 170.92,42.99 170.92,43.57 170.76,43.72 170.55,43.72 170.39,43.57 170.39,42.99 170.24,42.83 170.03,42.83 169.87,42.99 169.87,43.57 169.72,43.72 169.51,43.72 169.35,43.57 169.35,42.99 169.2,42.83 168.98,42.83 168.83,42.99 168.83,43.57 168.68,43.72 168.46,43.72 168.31,43.57 168.31,42.99 168.16,42.83 167.94,42.83 167.79,42.99 167.79,43.57 167.64,43.72 167.23,43.72 167.08,43.57 167.08,43.02 166.92,42.87 166.71,42.87 166.56,43.02 166.56,43.57 166.4,43.72 166.07,43.72 165.87,43.53 165.87,42.9 165.8,42.82 164.53,42.82 v1(163.66,43.68)
  BOTTOM w0.114: v1(163.66,43.68) 163.66,45.72 163.34,46.04 JDIM2.200 163.34,49.6 162.89,50.05 162.89,51.54 163.8,52.45 164.3,52.45 167.08,55.23 167.08,57.92 166.78,58.23 164.24,58.23 163.34,59.12 JDIM1.200 ; Q32.4 166.93,127.6 167.22,127.88 168.5,127.88 168.62,127.76 R576.1 169.01,127.76 169.51,128.25 170.1,128.25 170.6,128.75 v1(170.83,128.75) ; v1(194.42,54.96) 194.24,55.14 191.91,55.14 187.17,50.4 187.17,47.46 v1(187.39,47.24)
CLKRUN#: length 137
  TOP w0.114: 193.67,44.13 193.65,44.15 193.18,44.15 192.91,44.42 192.91,45.44 192.5,45.85 192.5,46.08 191.72,46.85 191.72,58.92 185.21,65.42 184.93,65.42 184.12,66.23 184.12,71.36 182.25,73.23 179.44,73.23 177.88,74.79 175.09,74.79 174.56,75.32 172.32,75.32 171.31,76.33 169.31,76.33 167.22,78.42 167.22,87.87 167.65,88.31 168.79,88.31 169.89,89.4 169.89,91.24 167.78,93.35 166.99,93.35 166.67,93.67 166.67,94.24 166.75,94.33 166.75,94.97 166.75,95.34 166.99,95.58 167.32,95.58 167.78,96.03 167.78,97.15 167.53,97.4 167.25,97.4 166.73,97.92 166.73,100.03 166.85,100.15 166.85,103.18 166.43,103.6 166.43,103.85 164.29,105.99 160.26,105.99 v1(159.98,106.27) ; 193.67,44.13 193.7,44.15 194.48,44.15 195.76,45.43 198.66,45.43 199.35,46.12 203.91,46.12 204.76,45.27 208.42,45.27 208.99,45.83 212.41,45.83 214.55,43.68 216.85,43.68 v1(217.39,44.22) ; 193.67,44.13 v1(193.67,44.15)
  BOTTOM w0.076: 158.54,105.83 157.89,106.48 155.16,106.48 154.66,106.98 153.83,106.98 153.64,107.17 152.58,107.17 152.27,107.48 151.54,107.48 151.39,107.62 150.55,107.62 150.25,107.93 150.25,108.95 150.35,109.05 150.35,109.87 150.64,110.15 U35.AW11
  BOTTOM w0.114: U45.93 193.3,42.71 193.67,43.09 v1(193.67,44.15) ; v1(217.39,44.22) 217.41,44.22 217.93,44.22 v3(218.56,44.85) R743.2 220.16,46.22 C807.2 ; 158.54,105.83 159.49,105.83 159.91,106.24 159.98,106.24 ; v1(159.98,106.27) 159.98,106.24 ; 159.98,106.24 160.29,106.55 R630.2
CODEC_VREF: length 2.7
  TOP w0.203: C535.2 30.95,29.18 v1(31.08,29.31) 31.28,29.51 31.28,29.64 31.6,29.96 U23.28
CPU_DRAMRST#: length 17.6
  TOP w0.114: v1(154.27,99.06) 154.01,99.06 151.47,101.6 151.47,103.12 151.75,103.4 v3(151.75,107.21) 151.75,109.07 151.17,109.65 151.17,110.16 150.46,110.87 150.46,111.33 v2(150.03,111.76)
  BOTTOM w0.114: R679.2 154.78,98.18 R670.2 154.78,98.59 154.32,99.06 v1(154.27,99.06)
  BOTTOM w0.127: v2(150.03,111.76) U35.AT13
CPU_THRMTRIP#: length 16.4
  BOTTOM w0.076: U35.C63 121.2,129.77 121.2,129.9 121.36,130.23 121.36,130.31 121.29,130.54 121.29,130.73 121.35,130.9 121.35,131.61 121.01,131.96
  BOTTOM w0.089: 121.01,131.96 121.01,132.46 119.22,134.26
  BOTTOM w0.114: R529.2 R530.2 117.51,141.98 117.34,141.8 117.34,139.9 118.21,139.02 118.21,135.26 119.22,134.26
CPUFAN#: length 202.6
  TOP w0.114: U12.4 51.27,111.5 51.02,111.25 v3(51.02,104.34) 51.02,99.18 v1(52.29,97.91)
  IN1 w0.127: v1(194.02,38.1) 194.02,39.24 192.44,40.81 179.84,40.81 179.73,40.7 179.73,38.79 177.63,36.7 170.65,36.7 167.91,39.44 101.23,39.44 78.63,62.05 77.28,62.05 73.04,66.29 68.43,66.29 65.29,69.43 65.29,72.23 64.25,73.27 64.25,74.06 60.87,77.44 59.64,77.44 56.71,80.37 56.71,80.66 52,85.37 50.11,85.37 49.62,85.85 49.62,86.86 52.48,89.72 52.48,97.68 52.29,97.87 v1(52.29,97.91)
  BOTTOM w0.114: U45.81 193.07,37.91 193.38,38.22 193.89,38.22 v1(194.02,38.1)
CRT_11: length 3.7
  BOTTOM w0.114: CN7.11 5.59,107.95 7.23,106.32 TP75.1
CRT_AUX#_C: length 18.6
  IN2 w0.127: v2(128.99,128.47) 128.85,128.33 128.73,128.33 128.56,128.5 128.56,129.6 126.97,131.19 126.33,131.19 122.9,134.62 119.04,134.62 118.68,134.26 116.73,134.26 116.55,134.44 116.55,134.77 116.83,135.05 v1(117.06,135.05)
  BOTTOM w0.114: U35.E48 129.46,128.52 129.36,128.62 129.15,128.62 v2(128.99,128.47) ; v1(117.06,135.05) 116.74,135.05 C671.1
CRT_AUX_C: length 18.6
  IN2 w0.127: v1(115.81,134.87) 116.16,134.87 116.29,134.74 116.29,134.33 116.62,134.01 118.79,134.01 119.14,134.36 122.79,134.36 126.22,130.93 126.87,130.93 128.31,129.49 128.31,128.39 128.62,128.08 128.75,128.08 v2(128.99,127.83)
  BOTTOM w0.114: v2(128.99,127.83) 129.25,127.57 U35.F48 ; v1(115.81,134.87) 115.71,134.97 115.7,134.97 C670.1
CRT_AUXN: length 116.9
  TOP w0.114: v1(28.28,102.99) 28.47,103.18 28.47,103.6 28.34,103.74 27.78,103.74 v3(27.29,103.25) 26.8,103.74 26.24,103.74 C343.2
  IN2 w0.127: v1(28.28,102.99) 28.49,103.2 28.49,103.7 29.17,104.39 40.83,104.39 42.69,102.54 72.83,102.54 74.07,103.77 75.77,103.77 82,110 85.59,110 86.5,110.92 86.5,114.3 88.43,116.23 92.16,116.23 94.5,118.57 94.5,126.77 99.56,131.82 100.19,131.82 100.47,132.1 102.28,132.1 107.21,137.03 113.9,137.03 114.55,137.68 115.67,137.68 115.94,137.41 115.94,136.93 v1(116.09,136.77)
  BOTTOM w0.114: C671.2 116.09,136.48 v1(116.09,136.77) 116.09,137.07 R533.2
CRT_AUXN_C: length 4
  TOP w0.114: U13.18 22.93,105.33 23.01,105.25 23.01,104.56 24,103.58 24.9,103.58 C343.1
CRT_AUXP: length 116.7
  TOP w0.114: C341.2 26.29,103.98 26.75,103.98 v3(27.29,104.52) 27.83,103.98 28.44,103.98 28.71,103.7 28.71,103.2 v1(28.92,102.99)
  IN2 w0.127: v1(115.4,136.77) 115.68,137.05 115.68,137.31 115.57,137.42 114.66,137.42 114.01,136.77 107.32,136.77 102.39,131.85 100.57,131.85 100.29,131.57 99.66,131.57 94.75,126.66 94.75,118.46 92.26,115.97 88.54,115.97 86.75,114.19 86.75,110.81 85.69,109.75 82.11,109.75 75.87,103.51 74.17,103.51 72.94,102.28 42.58,102.28 40.73,104.14 29.28,104.14 28.74,103.6 28.74,103.17 v1(28.92,102.99)
  BOTTOM w0.114: R532.1 v1(115.4,136.77) 115.46,136.77 115.74,136.5 115.74,136.37 115.52,136.15 C670.2
CRT_AUXP_C: length 4
  TOP w0.114: U13.19 23.33,105.33 23.25,105.25 23.25,104.66 24.1,103.82 24.95,103.82 25.1,103.97 C341.1
CRT_B1: length 11.2
  TOP w0.114: v1(9.92,110.38) 9.92,110.05 11.2,108.78 C319.2 L5.2
  BOTTOM w0.114: CN7.3 5.66,111.83 6.18,111.83 7.13,110.89 7.13,110.59 7.3,110.42 U38.5 U38.6 9.09,110.42 v1(9.33,110.66) 9.46,110.79 9.79,110.79 9.92,110.66 v1(9.92,110.38)
CRT_BLU: length 5.7
  TOP w0.114: U13.7 18.79,107.98 18.53,107.72 18.15,107.72 17.95,107.92 17.59,107.92 v1(17.13,108.38) 16.73,108.78 R213.1 C320.2 L5.1
CRT_CLK: length 18.1
  IN1 w0.127: v1(167.86,125.95) 167.37,126.44 163.84,126.44 163.03,125.62 162.09,125.62 162.01,125.7 161.61,125.7 160.36,124.46 158.71,124.46 157.98,123.72 153.89,123.72 v2(153.7,123.53)
  BOTTOM w0.076: U35.N7 153.71,123.75 153.71,123.54 v2(153.7,123.53)
  BOTTOM w0.114: R577.1 168.08,126.74 v1(168.03,126.69) 167.77,126.42 167.77,126.04 v1(167.86,125.95)
CRT_DATA: length 14
  TOP w0.114: v1(161.94,126.49) 161.94,127.07 v3(162.32,127.45) 163.13,128.27 R152.1
  IN1 w0.076: 155.16,124.03 153.02,124.03 v2(152.46,123.47)
  IN1 w0.127: 155.16,124.03 155.58,124.46 155.9,124.46 156.74,125.3 160.32,125.3 161.25,126.23 161.68,126.23 v1(161.94,126.49)
  BOTTOM w0.114: v2(152.46,123.47) 152.46,123.71 U35.N8
CRT_G1: length 11.5
  TOP w0.114: L6.2 C333.2 11.19,107.52 11.06,107.4 11.06,107.11 10.91,106.96 10.68,106.96 10.58,107.06 10.58,107.46 10.48,107.56 v1(10.12,107.56)
  BOTTOM w0.114: v1(10.12,107.56) 10.12,107.82 10.05,107.9 9.84,107.9 9.66,107.71 9.54,107.71 9.46,107.79 9.46,108.53 9.07,108.92 U38.9 U38.2 7.32,108.92 6.07,110.17 5.04,110.17 CN7.2
CRT_GRE: length 5.4
  TOP w0.114: U13.8 18.77,107.58 18.53,107.34 v1(17.87,107.34) 17.03,107.34 16.84,107.52 R219.1 C334.2 L6.1
CRT_HPD: length 204.8
  TOP w0.114: U13.33 22.93,112.37 23.15,112.59 23.15,112.64 v3(23.66,113.15) 23.96,113.46 v1(23.96,114.04) ; v1(129.5,151.38) 128.72,152.16 121.34,152.16 121,151.82 117.04,151.82 115.28,150.06 115.28,146 114.69,145.41 108.88,145.41 107.08,143.61 107.08,141.66 106.09,140.67 106.03,140.67 103.97,138.61 103.97,135.21 103.47,134.7 102.7,134.7 99.36,131.36 97.42,131.36 93.62,127.56 93.62,119.67 92.76,118.81 89.55,118.81 v1(89.5,118.87)
  IN1 w0.127: v1(89.5,118.87) 89.24,119.12 88.47,119.12 84.16,114.82 84.16,113.03 82.66,111.53 79.65,111.53 74.95,106.83 59.25,106.83 57.61,108.47 51.41,108.47 49.75,106.8 29.7,106.8 28.54,107.97 28.54,108.58 23.99,113.13 23.99,114.02 v1(23.96,114.04) ; v2(153.76,124.58) 154.17,124.99 154.39,124.99 156.54,127.14 160.38,127.14 163.28,130.03 163.28,130.69 v1(163.27,130.71) 163.28,130.73 163.28,130.81 161.1,132.99 161.1,133.5 158.23,136.37 158.23,137.66 157.19,138.7 155.89,138.7 155.89,138.71 153.38,138.71 151.68,140.41 142.48,140.41 142.04,139.96 139.73,139.96 137.15,142.54 134.4,142.54 132.17,144.78 132.17,148.71 v1(129.5,151.38)
  BOTTOM w0.076: v2(153.76,124.58) 153.76,124.64 U35.L7
  BOTTOM w0.114: v1(163.27,130.71) 163.27,131.03 R564.2
CRT_R1: length 11.1
  TOP w0.114: L7.2 C336.2 10.8,105.49 v1(10.12,106.17)
  BOTTOM w0.114: CN7.1 5.02,109.54 5.81,109.54 6.93,108.42 U38.1 U38.10 8.81,108.42 8.98,108.25 8.98,107.31 v1(10.12,106.17)
CRT_RED: length 5.9
  TOP w0.114: L7.1 C337.2 R222.1 16.3,105.49 16.71,105.9 16.94,105.9 v1(17.23,106.19) 17.72,106.68 18.33,106.68 18.83,107.18 U13.9
CRT_TXN0: length 132
  TOP w0.114: v1(32.4,109.09) 32.66,109.09 32.79,108.96 32.79,107.84 31.69,106.74 28.27,106.74 28.16,106.84 C331.2
  IN2 w0.127: v1(128.1,133.09) 127.85,133.09 127.67,133.27 127.67,133.6 127.17,134.11 127.17,134.45 126.91,134.7 126.49,134.7 123.91,137.28 120.63,137.28 119.49,138.43 117.85,138.43 117.41,138.87 106.71,138.87 104.74,136.9 104.41,136.9 102.84,135.33 102.84,134.71 101.68,133.55 99.01,133.55 93.05,127.59 93.05,119.17 91.56,117.67 87.8,117.67 85.05,114.93 85.05,112.14 84.37,111.45 81.3,111.45 76.14,106.29 34.25,106.29 32.78,107.77 32.78,108.96 32.65,109.09 v1(32.4,109.09)
  BOTTOM w0.076: U35.C50 128.71,129.85 128.71,130.06 128.79,130.23 128.79,130.31 128.73,130.54 128.73,130.73 128.79,130.9 128.79,131.19 128.49,131.49 128.49,133.01 128.4,133.09 v1(128.1,133.09)
CRT_TXN0_C: length 3.3
  TOP w0.114: U13.23 25.2,107.58 25.28,107.5 25.55,107.5 26.13,106.92 27,106.92 C331.1
CRT_TXN1: length 127.9
  TOP w0.114: C315.2 28.16,109.22 28.32,109.06 29.33,109.06 v1(29.64,109.36)
  IN2 w0.127: v1(126.96,133.47) 126.63,133.8 126.43,133.8 123.46,136.77 120.46,136.77 119.32,137.92 116.8,137.92 116.28,138.44 112.8,138.44 112.15,137.79 106.64,137.79 101.89,133.04 99.25,133.04 93.56,127.35 93.56,118.96 91.77,117.17 88.02,117.17 85.56,114.7 85.56,111.88 84.62,110.94 81.61,110.94 75.38,104.71 50.7,104.71 49.76,105.65 34.01,105.65 30.62,109.04 29.96,109.04 v1(29.64,109.36)
  BOTTOM w0.076: U35.C52 127.19,129.83 127.19,129.99 127.1,130.21 127.1,130.4 127.14,130.47 127.14,130.76 127.11,130.82 127.11,131.33 127.27,131.49 127.27,132.49 126.96,132.79 126.96,133.22
  BOTTOM w0.114: 126.96,133.22 v1(126.96,133.47)
CRT_TXN1_C: length 3.2
  TOP w0.114: U13.26 25.2,108.78 25.28,108.7 25.74,108.7 26.1,109.06 26.98,109.06 C315.1
CRT_TXP0: length 132
  TOP w0.114: C335.2 28.37,106.5 31.79,106.5 33.03,107.74 33.03,108.89 v1(33.24,109.09)
  IN2 w0.127: v1(33.24,109.09) 33.03,108.89 33.03,107.87 34.36,106.55 76.03,106.55 81.19,111.71 84.26,111.71 84.8,112.24 84.8,115.04 87.69,117.93 91.45,117.93 92.8,119.27 92.8,127.69 98.91,133.8 101.58,133.8 102.59,134.82 102.59,135.44 104.31,137.15 104.63,137.15 106.6,139.12 117.51,139.12 117.96,138.68 119.6,138.68 120.74,137.54 124.02,137.54 126.6,134.96 127.02,134.96 127.42,134.56 127.42,134.22 127.91,133.73 v1(128.1,133.73)
  BOTTOM w0.076: U35.D50 128.51,129.21 128.88,129.59 128.88,130.02 128.96,130.2 128.96,130.33 128.89,130.56 128.89,130.7 128.95,130.87 128.95,131.26 128.65,131.56 128.65,133.08 128.47,133.26 128.47,133.36 v1(128.1,133.73)
CRT_TXP0_C: length 3.3
  TOP w0.114: C335.1 27,106.68 26.03,106.68 25.45,107.26 25.28,107.26 25.2,107.18 U13.22
CRT_TXP1: length 127.9
  TOP w0.114: C329.2 28.53,108.82 29.37,108.82 v1(29.64,108.56)
  IN2 w0.127: v1(29.64,108.56) 29.86,108.78 30.51,108.78 33.91,105.39 49.65,105.39 50.59,104.45 75.48,104.45 81.72,110.69 84.73,110.69 85.81,111.78 85.81,114.6 88.13,116.91 91.88,116.91 93.81,118.85 93.81,127.24 99.36,132.79 102,132.79 106.75,137.54 112.25,137.54 112.9,138.18 116.18,138.18 116.7,137.66 119.21,137.66 120.36,136.52 123.35,136.52 126.33,133.55 v1(126.33,133.35)
  BOTTOM w0.076: U35.D52 127.03,129.35 127.03,129.96 126.93,130.18 126.93,130.43 126.97,130.51 126.97,130.72 126.94,130.79 126.94,130.79 126.94,131.4 127.1,131.56 127.1,132.42 126.33,133.19 126.33,133.22
  BOTTOM w0.114: 126.33,133.22 v1(126.33,133.35)
CRT_TXP1_C: length 3.2
  TOP w0.114: U13.25 25.2,108.38 25.28,108.46 25.84,108.46 26.2,108.82 27.02,108.82 C329.1
CRTHSYNC: length 11
  BOTTOM w0.114: CN7.13 5.62,113.3 6.84,112.08 U36.1 U36.10 v1(9.39,112.08) 9.54,112.08 C718.2 10.62,110.62 11.14,110.1 12.28,110.1 12.87,109.52 13.27,109.52 13.4,109.39 13.4,109.22 13.27,109.09 13.04,109.09 12.93,108.97 U40.4
CRTVDD5: length 15.3
  TOP w0.762: v1(17.49,112.8) 18.07,112.8 18.68,113.41 R203.2
  IN1 w0.762: v1(12.33,112.85) 14.52,112.85 15.48,113.81 16.47,113.81 v1(17.49,112.8)
  IN2 w0.762: v1(11.01,108.2) 11.01,111.53 v1(12.33,112.85)
  BOTTOM w0.203: v1(6.97,112.59) 6.99,112.58 U36.2 U36.9
  BOTTOM w0.508: R620.2 11.52,108.71 v1(11.01,108.2)
  vias: v3(10.58,111.81)
CRTVSYNC: length 15.3
  BOTTOM w0.114: CN7.14 5.59,116.12 5.8,116.33 6.08,116.33 6.44,115.97 6.44,114.52 7.38,113.58 U36.4 U36.7 9.18,113.58 C716.2 11.28,111.48 13.65,111.48 13.8,111.63 13.8,112.44 14.24,112.87 v3(14.36,112.87) 15.46,112.87 15.57,112.76 U37.4
CTL2: length 7
  TOP w0.114: R360.2 26.01,43.91 v1(23.69,43.91) 23.41,43.91 23.1,44.22 22.19,44.22 22.01,44.04 21.02,44.04 20.41,43.43 U22.7
CTL3: length 7.5
  TOP w0.114: R356.2 v1(24.78,44.7) 24.52,44.7 24.27,44.45 22.09,44.45 21.91,44.27 20.61,44.27 19.91,43.57 U22.8
DAC_VDDC: length 1.6
  BOTTOM w0.508: L21.2 16.66,106.91 16.62,106.88 16.42,106.88 v3(15.81,106.27)
  vias: v1(18.35,109.01) v1(18.38,108.35)
DC-DET: length 12.6
  TOP w0.114: v1(33.11,43.56) 33.34,43.79 v3(33.34,46.25) 32.93,46.66 32.81,46.66 R350.2 R344.1 ; v1(34.51,39.75) 33.95,39.19 33.95,38.17 33.6,37.83 U23.4
  IN1 w0.127: v1(34.51,39.75) 34.51,40.64 33.11,42.03 v1(33.11,43.56)
DCPRTC: length 11.3
  BOTTOM w0.076: 160.36,107.46 160.01,107.46 159.72,107.18 155.4,107.18 154.94,107.64 154.2,107.64 154,107.83 152.88,107.83 152.57,108.14 152.57,108.24 152.17,108.64 U35.BB10
  BOTTOM w0.114: 160.36,107.46 161.4,107.46 C732.1
DDCCLK: length 30.4
  TOP w0.114: R225.1 18.87,101.93 15.38,101.93 13.04,104.26 v1(13.04,104.52)
  IN2 w0.127: v1(13.86,113.89) 13.6,113.64 13.6,109.52 12.53,108.45 12.53,107.56 11.9,106.93 11.9,106.04 12.79,105.15 12.79,104.77 v1(13.04,104.52)
  BOTTOM w0.114: CN7.15 5.59,117.45 6.82,116.23 6.82,114.68 7.42,114.08 U36.5 U36.6 9.3,114.08 9.36,114.02 v1(9.39,114.02) 10.22,114.02 10.26,114.05 C714.2 R601.1 12.53,114.05 12.79,113.79 13.75,113.79 v1(13.86,113.89)
DDCCLK_R: length 8.3
  TOP w0.114: U13.12 20.53,104.37 R225.2 20.49,103.25 v1(20.56,103.25) ; U13.17 22.53,103.18 v1(22.62,103.09)
  IN2 w0.127: v1(20.56,103.25) 22.47,103.25 v1(22.62,103.09)
DDCDAT: length 30.4
  TOP w0.114: v1(12.31,104.54) 12.33,104.54 15.2,101.67 19.86,101.67 R226.1
  BOTTOM w0.114: v1(12.31,104.54) 11.47,104.54 11.34,104.67 11.34,104.95 11.47,105.08 13.75,105.08 13.88,105.2 13.88,105.51 13.75,105.63 v3(11.65,105.63) 10.76,105.63 10.63,105.76 10.63,107.21 10.76,107.34 12.2,107.34 12.33,107.46 12.33,108.79 R620.1 C724.1 10.19,109.92 U38.7 U38.4 7.21,109.92 6.12,111.01 CN7.12
DDCDAT_R: length 5.8
  TOP w0.114: U13.16 22.13,105.19 22.29,105.03 22.29,103.91 22.15,103.76 v1(22.1,103.76) R226.2 20.79,104.14 20.79,105.25 20.93,105.4 U13.13
DDR3_DRAMRST#: length 137.4
  TOP w0.114: v1(116.17,44.95) 116.17,46.1 115.02,47.24 109.61,47.24 C465.2 109.15,49.1 v1(109.47,49.43) 109.98,49.93 109.98,50.33 110.96,51.3 v3(110.96,55.62) 110.96,56.89 110.62,57.24 110.62,57.57 v1(109.67,58.51) 109.67,60.53 C415.2
  IN1 w0.127: v1(116.17,44.95) 124,44.95 124.8,45.75 127.05,45.75 127.85,44.95 131.53,44.95 132.3,44.19 137.12,44.19 137.7,44.77 156.88,44.77 158.25,46.15 160.88,46.15 165.01,50.28 165.01,58.29 167.78,61.06 167.78,67.86 167.73,67.92 167.73,71.08 163.97,74.84 163.97,78.67 161.19,81.45 161.19,84.26 161.53,84.61 161.53,85.51 158.97,88.08 v1(158.97,88.16)
  BOTTOM w0.114: v1(158.97,88.16) 158.97,88.46 158.46,88.97 157.66,88.97 152.24,94.38 152.24,95.93 152.7,96.39 C750.1 152.99,96.89 153.38,97.28 153.38,97.79 154,98.41 R670.1
  BOTTOM w0.127: v1(109.67,58.51) 109.94,58.78 JDIM1.30 ; v1(109.47,49.43) 109.47,48.75 109.94,48.28 JDIM2.30
DDR_VTT_CTRL: length 24.8
  BOTTOM w0.076: 112.42,108.85 112.45,108.89 115.18,108.89 115.46,109.17 116.01,109.17 116.05,109.12 116.38,109.12 116.49,109.23 116.49,109.84 116.62,109.98 116.93,109.98 117.1,109.8 117.39,109.8 117.56,109.98 117.56,110.23 117.69,110.36 118.38,110.36 U35.AW67
  BOTTOM w0.114: Q35.1 102.35,103.15 v3(107,107.8) 110.79,107.8 111.08,108.09 111.66,108.09 R621.2 112.42,108.85
DDR_VTTT_PG_CTRL: length 158.6
  IN1 w0.127: v1(92.42,73.55) 92.42,61.95 91.64,61.17 91.64,57.06 94.95,53.76 94.95,52.87 101.63,46.19 131.7,46.19 133.18,44.7 135.22,44.7 136.99,46.48 160.74,46.48 164.68,50.41 164.68,58.44 167.45,61.21 167.45,67.71 v1(166.84,68.32)
  BOTTOM w0.114: v1(92.42,73.55) 91.17,74.8 91.17,75.57 87.89,78.85 87.89,87.39 89.73,89.23 92.51,89.23 93.32,90.04 94.83,90.04 97.62,92.83 v3(97.62,95.14) 97.62,95.37 98.51,96.25 R682.2 99.75,96.16 Q35.3 ; v1(166.84,68.32) 167.23,68.71 PR298.1
DEVSLP0: length 142.9
  TOP w0.114: v1(200.12,47.02) 200.58,47.47 211.02,47.47 211.65,46.84 215.79,46.84 216.85,45.78 217.58,45.78 218.78,46.99 v3(222.77,46.99) R351.1
  IN1 w0.127: v1(174.23,127.3) 174.82,126.72 175.06,126.72 176.92,124.86 176.92,124.61 179.3,122.24 179.3,121.55 179.65,121.2 179.65,117.56 180.37,116.85 180.37,112.68 181.57,111.47 181.57,110.94 182.93,109.58 182.93,107.8 184.81,105.92 184.81,105.33 185.89,104.24 185.89,94.97 185.01,94.09 185.01,91.96 186.88,90.09 186.88,85.48 191.06,81.3 192.26,81.3 193.62,79.94 194.43,79.94 196.58,77.79 196.58,73.9 198.27,72.21 198.27,63.09 196.93,61.74 196.93,60.2 196.28,59.56 196.28,56.8 195.48,56 195.48,53.1 196.35,52.23 197.1,52.23 198.01,51.33 198.01,50.39 198.74,49.65 199.78,49.65 200.69,48.75 200.69,47.46 200.25,47.02 v1(200.12,47.02)
  IN2 w0.127: v1(159.35,127.59) 159.35,127.61 160.34,128.6 163.89,128.6 164.17,128.32 165.8,128.32 166.41,128.93 166.56,128.93 166.66,129.03 169.25,129.03 170.14,128.14 172.17,128.14 172.89,127.43 174.1,127.43 v1(174.23,127.3)
  BOTTOM w0.114: U35.J1 156.81,126.21 157.59,127 158.71,127 159.3,127.58 v1(159.35,127.59) 159.94,126.99 R573.1
DEVSLP0_R: length 3.9
  TOP w0.114: CN14.9 228.67,46.99 v3(226.07,46.99) R351.2
DGPU_D: length 8.7
  TOP w0.114: PR161.2 77.74,15.56 77.74,15.87 75.93,17.67 PQ19.2 75.76,18.06 74.94,18.87 v3(74.76,18.87) ; PR161.2 PC113.2 ; PR161.2 78.41,14.82 77.18,13.58
DGPU_EDIDCLK: length 13.2
  BOTTOM w0.114: R505.2 196.39,141.65 196.3,141.74 196.3,148.74 194.66,150.37 194.66,151.46 193.03,153.09 U34.A9
DGPU_EDIDDATA: length 15.8
  BOTTOM w0.102: U34.B9 192.89,152.45 193.09,152.45 194.24,151.3 194.24,150.15 194.27,150.12
  BOTTOM w0.114: R523.2 195.52,139.49 194.99,140.02 194.99,140.45 195.07,140.53 195.07,142.35 195.77,143.04 195.77,148.62 194.27,150.12
DGPU_EVENT#: length 72
  TOP w0.114: v1(175.98,133.22) 175.73,132.96 174.08,132.96 173.7,133.35 173.7,133.84 173.43,134.11 171.6,134.11 171.34,134.36 170.27,134.36 169.89,133.98 169.67,133.98 169.23,134.42 169.23,136.11 169.66,136.54 169.66,138.83 169.24,139.25 168.9,139.25 168.52,139.63 R106.2 ; v1(153.73,113.05) 153.99,112.8 155.51,112.8 156.34,111.97 159.05,111.97 159.5,111.52 161.52,111.52 162.38,110.66 164.63,110.66 164.83,110.87 166.59,110.87 167.02,111.31 167.54,111.31 167.65,111.2 174.41,111.2 174.87,110.74 v1(177.66,110.74)
  BOTTOM w0.076: v1(153.73,113.05) 153.82,113.05 U35.AP5
  BOTTOM w0.114: v1(177.66,110.74) 177.84,110.56 178.73,110.56 179.36,111.2 180.07,111.2 180.53,111.65 v3(182.05,111.65) 182.21,111.65 182.84,112.29 182.84,114.92 181.94,115.82 179.95,115.82 177.92,117.85 177.92,123.73 178.19,124 178.19,124.15 178.83,124.79 178.83,128.36 177.54,129.65 177.54,130.81 176.19,132.17 176.19,133.02 v1(175.98,133.22)
DGPU_HOLD_RST#: length 60.9
  TOP w0.114: v1(153.63,113.71) 153.63,113.76 153.17,114.23 153.17,114.54 153.43,114.8 153.87,114.8 154.71,113.96 155.56,113.96 156.86,112.66 159.34,112.66 159.79,112.21 161.83,112.21 162.69,111.35 164.09,111.35 164.88,112.14 164.88,112.57 164.58,112.88 164.58,113.18 164.85,113.45 165.7,113.45 166.27,112.88 170.55,112.88 v1(170.8,113.13) 171.36,113.69 171.72,113.69 173.04,112.37 175.44,112.37 R208.1 175.98,112.91 175.98,113.28 174.89,114.38 174.89,115.46 175.89,116.46 175.89,117.69 174.67,118.91 174.67,121.78 175.6,122.72 175.6,125.15 175.87,125.41 176.36,125.41 176.75,125.02 176.75,124.73 177.33,124.15 177.33,123.54 177.62,123.26 179.14,123.26 179.32,123.43 179.32,127.29 176.57,130.04 176.57,131.49 176.36,131.69 174.71,131.69 174.32,132.09 U10.1
  BOTTOM w0.076: U35.AP7 153.56,113.71 v1(153.63,113.71)
DGPU_OPP#: length 160
  TOP w0.114: v1(188.91,142.24) 189.83,142.24 190.85,143.26 Q9.3 ; v1(194.09,32.89) 194.2,32.99 194.2,33.88 v1(194.75,34.44) 194.93,34.62 R382.1
  IN1 w0.127: v1(188.91,142.24) 189.75,141.4 191.68,141.4 192.06,141.02 196.13,141.02 199.33,137.82 199.33,135.05 199.56,134.82 199.56,134.18 201.69,132.05 206.06,132.05 206.72,132.71 208.82,132.71 209.58,131.96 209.58,122.41 210.46,121.52 210.46,119.44 213.07,116.84 213.07,107.79 208.56,103.29 208.56,96.33 208.55,96.31 208.55,71.7 212.61,67.64 212.61,66.49 215.1,64 215.1,60.15 214.72,59.77 214.72,57.65 213.26,56.19 213.26,53.15 211.82,51.72 211.82,49.73 210.57,48.48 210.57,48.47 210.31,48.22 210.31,46.07 209.54,45.29 209.54,43 211.62,40.92 211.62,39.49 210.84,38.71 207.64,38.71 205.96,40.39 v1(205.96,40.69)
  BOTTOM w0.114: v1(205.96,40.69) 205.22,39.95 205.22,38.59 204.19,37.56 203.26,37.56 202.9,37.2 201.35,37.2 198.58,34.43 197.63,34.43 197.27,34.07 195.81,34.07 194.63,32.89 v1(194.09,32.89) 194.02,32.89 193.84,32.71 U45.68
DGPU_OTP#: length 112.2
  TOP w0.114: Q16.3 197.29,134.01 199.35,131.95 207.12,131.95 208.27,130.81 v1(208.67,130.81)
  IN1 w0.127: v1(208.67,130.81) 209.32,130.16 209.32,122.31 210.21,121.42 210.21,118.75 212.81,116.15 212.81,108 212.69,107.87 212.69,107.79 208.29,103.4 208.29,71.57 211.7,68.17 211.7,68.12 212.34,67.47 212.34,66.4 214.85,63.89 214.85,60.26 214.46,59.88 214.46,57.76 213,56.3 213,54.72 212.84,54.55 212.84,53.56 v1(212.81,53.54)
  BOTTOM w0.114: U45.124 204.71,46.29 205.19,46.77 R740.1 205.7,49.26 205.7,50.97 205.63,51.05 205.63,51.53 205.93,51.84 207.83,51.84 208.82,52.83 v3(210.12,52.83) 212.05,52.83 212.69,53.46 212.74,53.46 v1(212.81,53.54)
DGPU_PGOK-1: length 9.2
  TOP w0.114: Q12.2 168.52,142.21 168.36,142.36 168.36,144.01 169.13,144.78 Q7.3 169.13,146.78 v1(169.61,147.27) 170.67,148.32 C141.1 170.55,148.63 R82.1
DGPU_POK2: length 4.9
  TOP w0.114: Q7.2 166.46,147.21 166.08,147.6 C139.1 165.84,148.58 R83.1 v3(165.06,150.77)
DGPU_PSI: length 86.4
  TOP w0.254: PR124.2 195.13,99.84 PR125.2 v1(196.24,100.48) 196.24,100.64 196.13,100.76 PR120.1 197.07,102.08 PR116.1
  IN1 w0.127: v1(207.73,99.82) 207.86,99.94 207.86,101.49 208.01,101.64 208.01,103.5 212.43,107.92 212.43,108 212.56,108.12 212.56,115.59 209.96,118.19 209.96,121.31 209.07,122.2 209.07,128.84 206.11,131.8 201.56,131.8 199.3,134.06 199.3,134.69 199.07,134.92 199.07,137.69 196,140.76 192.11,140.76 v1(191.66,140.31)
  IN2 w0.127: v1(196.24,100.48) 196.89,100.48 198.44,98.93 206.72,98.93 207.61,99.82 v1(207.73,99.82)
  BOTTOM w0.114: U34.B4 192.41,148.92 192.79,148.54 193.13,148.54 193.85,147.82 193.85,145.78 193.03,144.95 193.03,143.51 191.81,142.29 191.81,140.46 v1(191.66,140.31) 190.53,140.31 R518.1
DGPU_PW_CTRL#: length 85.5
  TOP w0.114: R127.2 166.83,136.56 166.97,136.7 168.2,136.7 v1(168.61,137.11) 168.23,137.49 R115.1 ; v1(176.24,101.49) 176.74,102 176.74,103.88 180.53,107.67 180.53,110.49 180.61,110.56 v1(180.61,111.12)
  IN1 w0.127: v1(176.24,101.49) 176.01,101.49 175.58,101.06 174.51,101.06 173.16,102.41 172.74,102.41 171.47,103.67 171.47,104.4 170.27,105.6 170.27,106.68 170.07,106.87 170.07,109.11 169.51,109.67 169.51,110.34 169.03,110.82 167.93,110.82 167.42,110.31 166.33,110.31 165.49,109.47 164.5,109.47 164.05,109.03 163.6,109.03 163.4,109.23 160.32,109.23 v1(159.73,108.63)
  BOTTOM w0.076: U35.BA5 154.35,109 154.74,108.62 155.16,108.62 155.38,108.39 155.38,108.1 155.81,107.67 159.2,107.67 159.53,108 159.53,108.43 v1(159.73,108.63)
  BOTTOM w0.114: v1(168.61,137.11) 168.69,137.03 174.64,137.03 v3(174.99,136.67) 175.32,136.67 176.42,135.58 176.42,132.26 177.77,130.91 177.77,129.74 179.06,128.45 179.06,124.68 178.42,124.05 178.42,123.91 178.15,123.63 178.15,118 180.07,116.07 182.01,116.07 183.07,115.01 183.07,111.96 182.23,111.12 v1(180.61,111.12)
DGPU_PWR_EN: length 237.1
  TOP w0.114: PR160.1 79.57,8.84 80.43,7.97 81.98,7.97 83.3,9.29 83.3,18.5 92.67,27.87 92.67,41.91 84.01,50.57 84.01,55.01 82.41,56.62 82.41,58.94 v3(82.9,59.44) v1(83.53,60.07) ; v1(161.89,88.13) 163.5,88.13 165.58,90.21 R256.1 R257.2
  IN1 w0.127: v1(162.27,81.25) 162.27,80.73 163.45,79.55 164.22,78.77 164.22,74.95 168.03,71.14 168.03,49.96 165.44,47.37 163.03,47.37 158.71,43.05 103.21,43.05 98.77,47.49 96.1,47.49 v1(83.53,60.07)
  IN2 w0.127: v1(162.27,81.25) 162.27,81.28 162,81.54 162,83.32 161.81,83.51 161.81,87.17 161.89,87.24 v1(161.89,88.13) 161.89,88.9 161.81,88.97 161.81,95.42 158.09,99.14 158.09,102.73 158.23,102.87 158.23,104.52 151.38,111.36 151.38,113.29 v1(151.8,113.71)
  BOTTOM w0.076: U35.AP8 152.13,113.38 v1(151.8,113.71)
DGPU_PWROK: length 75
  TOP w0.114: v2(154.39,115.18) 154.39,114.93 154.77,114.55 155.78,114.55 157.22,113.11 159.6,113.11 159.73,112.98 159.87,112.85 162.19,112.85 162.74,113.4 163.19,113.4 163.37,113.22 164.01,113.22 164.33,113.53 164.33,113.91 164.74,114.33 165.25,114.33 165.49,114.09 165.49,114 166.39,113.11 170.17,113.11 170.98,113.91 171.82,113.91 173.12,112.62 174.69,112.62 175.08,113.01 175.08,113.73 174.66,114.15 174.66,115.55 175.66,116.56 175.66,117.59 174.44,118.81 174.44,121.88 175.35,122.79 175.35,125.22 175.78,125.64 176.45,125.64 176.98,125.12 176.98,124.82 178.11,123.69 v1(178.83,123.69) ; Q12.3 167.25,142.52 165.91,141.18 165.91,140.45 166.42,139.94 R105.2 167.45,139.94 R108.1 167.5,139.14 167.88,138.76 R110.1 168.23,138.4 167.65,137.82 v1(167.65,137.13)
  BOTTOM w0.076: v2(154.39,115.18) 154.15,114.94 U35.AM5
  BOTTOM w0.114: v1(167.65,137.13) 167.93,137.13 168.33,137.53 168.96,137.53 169.2,137.29 172.34,137.29 172.35,137.28 175.09,137.28 176.67,135.71 176.67,132.33 177.76,131.24 178.02,131.24 179.11,130.15 v3(179.11,129.71) 179.29,129.54 179.29,124.51 178.83,124.05 v1(178.83,123.69)
DIMM0_SA0: length 4.4
  TOP w0.114: R332.1 v3(162.01,56.89) v1(161.51,57.4)
  BOTTOM w0.114: JDIM2.197 162.44,56.46 v1(161.51,57.4)
DIMM0_SA1: length 2.6
  TOP w0.114: R335.1 163.54,53.62 v1(163.64,53.72)
  BOTTOM w0.114: JDIM2.201 163.64,53.72 v1(163.64,53.72)
DIMM1_SA0: length 7.8
  TOP w0.114: R323.1 162.9,61.84 162.52,62.23 v1(162.39,62.23)
  BOTTOM w0.114: v1(162.39,62.23) 162.78,62.61 162.78,67.18 162.44,67.51 JDIM1.197
DIMM1_SA1: length 3.4
  TOP w0.508: v1(163.64,69.87) 164.5,69.87 v3(164.53,69.9) 164.82,70.19 R305.1
  BOTTOM w0.305: v1(163.64,69.87) 163.64,69.87 JDIM1.201
DMIC_CLK: length 2
  TOP w0.203: U23.3 34,37.72 34.37,38.09 R370.2
DMIC_CLK0_L: length 86.9
  TOP w0.114: v1(180.58,128.32) 181.17,127.73 181.17,124.4 182.84,122.73 182.84,116.35 183.93,115.26 183.93,109.5 185.15,108.28 v1(185.48,108.28) ; R772.1 v1(209.31,84.79)
  IN1 w0.127: v1(180.58,128.32) 180.38,128.52 176.44,128.52 175.76,129.21 173.44,129.21 v1(173.16,128.93)
  BOTTOM w0.114: R769.1 167.36,131.53 168.07,132.23 168.07,132.32 168.61,132.86 169.75,132.86 172.07,130.54 172.07,130.22 172.87,129.42 172.87,129.22 v1(173.16,128.93) ; v1(209.31,84.79) 209.82,85.3 209.82,86.13 208.39,87.55 208.39,88.46 210.25,90.32 210.25,92.76 208.65,94.36 201.21,94.36 198.73,96.83 198.73,99.07 197.98,99.82 193.33,99.82 191.07,102.08 186.42,102.08 183.38,105.13 183.38,105.81 185.48,107.92 v1(185.48,108.28)
DMIC_CLK0_R: length 20.4
  IN1 w0.127: v1(165.42,131.42) 166.79,130.04 166.79,128.9 165.95,128.06 165.01,128.06 162.83,125.88 162.2,125.88 162.12,125.95 161.35,125.95 160.24,124.84 158.58,124.84 158.33,124.58 v1(158.08,124.58)
  BOTTOM w0.076: v1(158.08,124.58) 157.57,124.07 157.06,124.07 156.68,124.46 155.41,124.46 155.16,124.71 155.16,124.9 154.96,125.09 154.77,125.09 154.52,125.34 154.52,125.85 154.15,126.22 U35.H5
  BOTTOM w0.114: v1(165.42,131.42) 165.95,131.42 166.18,131.19 R769.2
DMIC_CLK_L: length 220.8
  TOP w0.114: R370.1 35.15,39.89 C488.1 35.26,39.88 v1(35.78,39.37) ; R266.1 R270.1 211.3,81.05 v3(211.22,80.97) 210.79,80.54 210.79,71.89 206.72,67.81 v1(206.46,67.81)
  IN2 w0.127: v1(189.01,48.64) 189.47,48.18 189.47,47.77 189.06,47.36 189.06,46.22 184.89,42.05 178.69,42.05 175.5,38.86 175.5,37.99 168.52,31 168.52,31.01 168.36,30.86 95.34,30.86 94.88,31.31 89.24,31.31 88.02,30.09 68.72,30.09 67.96,29.33 57.11,29.33 56.55,29.89 55.33,29.89 55.05,30.17 55.05,33.12 49.01,39.16 36.61,39.16 36.41,39.37 v1(35.78,39.37)
  BOTTOM w0.114: v1(189.01,48.64) 189.01,49.99 192.59,53.56 195.41,53.56 197.85,56.01 197.85,60.89 200.36,63.4 200.36,63.4 203.51,66.56 205.21,66.56 v1(206.46,67.81)
DMIC_CLK_L1: length 265.1
  TOP w0.114: v1(132.55,25.01) 132.55,16.76 v1(131.66,15.87) ; R270.2 210.52,82.77 210.3,82.55 210.3,72.88 205.67,68.26 205.67,67.75 209.68,63.74 209.68,63.26 212.9,60.04 212.9,56.34 217.51,51.72 v1(217.51,51.69) ; v1(80.99,80.39) C378.1 D4.1 79.97,82.45 80.24,82.72 U16.4
  IN1 w0.127: v1(217.51,51.69) 217.54,51.67 217.54,45.03 216.31,43.8 216.31,33.34 212.64,29.67 212.64,25.44 213.89,24.18 213.89,19.11 208.43,13.64 195.34,13.64 194.78,13.08 194.78,10.79 192.88,8.89 173.83,8.89 166.6,16.12 131.91,16.12 v1(131.66,15.87)
  BOTTOM w0.114: v1(132.55,25.01) 132.55,26.03 113.64,44.93 101.92,44.93 92.04,54.81 92.04,60.01 83.91,68.14 83.48,68.57 83.48,71.67 83.91,72.11 83.91,77.47 v3(81.5,79.88) v1(80.99,80.39)
DMIC_CLK_L2: length 18.8
  TOP w0.114: U17.4 207.02,88.51 210.2,88.51 210.52,88.19 D3.1 C374.1 R772.2 v1(209.31,85.57)
  BOTTOM w0.114: v3(205.37,91.97) 207.56,91.97 208.04,91.49 208.04,87.37 209.31,86.1 v1(209.31,85.57)
DMIC_CS: length 7.1
  TOP w0.114: U17.2 204.18,84.45 v3(204.18,81.15) R286.2 R287.1 R288.1
DMIC_DAT: length 3.2
  TOP w0.203: U23.2 34.4,37.61 34.63,37.84 34.94,37.84
  TOP w0.254: R371.2 35.95,38.86 34.94,37.84
DMIC_DAT_L: length 228.8
  TOP w0.114: v1(37.17,39.62) 37.31,39.48 R371.1 ; R254.1 208.46,93.44 209.69,93.44 212.84,90.29 v3(212.84,87.85) 212.84,76.53 212.46,76.15 212.46,73.18 211.54,72.26 206.84,67.56 v1(206.84,67.31)
  IN2 w0.127: v1(189.01,48) 189.01,47.71 188.79,47.48 188.79,46.34 184.77,42.33 178.56,42.33 175.22,38.98 175.22,38.12 168.24,31.14 95.52,31.14 95.06,31.59 88.96,31.59 87.77,30.4 68.62,30.4 67.83,29.61 57.42,29.61 55.61,31.42 55.61,32.97 48.96,39.62 v1(37.17,39.62)
  BOTTOM w0.114: v1(189.01,48) 189.45,48.43 189.45,49.02 189.32,49.14 189.32,49.91 189.45,50.03 189.45,50.05 192.7,53.3 195.53,53.3 196.46,54.22 196.46,54.24 198.15,55.93 198.15,60.82 200.62,63.29 203.62,66.29 205.32,66.29 206.34,67.31 v1(206.84,67.31)
DMIC_DAT_L1: length 266.8
  TOP w0.114: v1(83.02,80.39) C379.1 D5.1 81.89,79.87 U16.5 ; v1(133.31,25.01) 133.11,24.81 133.11,16.05 v1(131.66,14.6) ; v1(206.21,78.35) R288.2
  IN1 w0.127: v1(213.4,73.35) 213.4,72.28 216.65,69.03 216.65,67.81 220.69,63.78 220.69,52.73 218.95,50.99 218.95,43.77 216.81,41.64 216.81,33.13 213.14,29.46 213.14,25.65 214.4,24.4 214.4,17.59 209.95,13.13 195.57,13.13 195.29,12.85 195.29,10.54 192.88,8.13 173.44,8.13 166.59,14.98 132.04,14.98 v1(131.66,14.6)
  BOTTOM w0.114: v1(213.4,73.35) 212.48,72.77 208.55,72.77 206.21,75.1 v1(206.21,78.35) ; v1(133.31,25.01) 133.31,25.62 113.77,45.16 102.01,45.16 92.29,54.88 92.29,60.12 83.76,68.65 83.76,71.6 84.16,72 84.16,77.54 83.02,78.68 v3(83.02,79.68) v1(83.02,80.39)
DMIC_DAT_L2: length 9.6
  TOP w0.114: v1(207.43,91.39) 207.63,91.39 207.86,91.61 R771.2 C357.1 D2.1 203.91,90.27 U17.5
  BOTTOM w0.114: v1(207.43,91.39) v3(206.67,91.39)
DMIC_DATA0_L: length 74.3
  TOP w0.114: v1(184.47,108.33) 184.47,108.58 183.68,109.37 183.68,115.03 182.61,116.1 182.61,122.63 181.67,123.57 v1(181.14,123.57) ; v1(209.69,92.58) 209.17,92.06 R771.1
  IN1 w0.127: v1(174.28,128.75) 175.76,128.75 176.24,128.27 178.07,128.27 180.28,126.06 180.28,125.03 180.94,124.37 180.94,123.77 v1(181.14,123.57)
  BOTTOM w0.114: v1(174.28,128.75) 173.75,129.28 173.42,129.28 172.33,130.37 172.33,130.54 172.31,130.56 172.31,130.63 169.85,133.09 168.52,133.09 167.98,132.56 167.71,132.56 R770.1 ; v1(209.69,92.58) 209.69,92.83 208.47,94.05 201.18,94.05 198.44,96.8 198.44,98.9 197.78,99.56 193.23,99.56 190.94,101.85 186.32,101.85 183.12,105.05 183.12,105.96 184.47,107.31 v1(184.47,108.33)
DMIC_DATA0_R: length 15.4
  BOTTOM w0.076: 158.05,130.93 156.35,130.93 156.03,130.61 155.34,130.61 154.73,130 154.48,130 153.47,128.99 U35.D7
  BOTTOM w0.114: 158.05,130.93 160.27,133.15 161.96,133.15 162.04,133.07 162.04,133.07 162.06,133.04 163.75,133.04 164.58,132.2 v3(164.93,132.2) R770.2
DNBSWON#: length 95.4
  TOP w0.114: v1(191.3,46.25) 191.77,45.78 191.77,45.55 192.16,45.16 192.16,44.14 193.07,43.23 194.71,43.23 196.17,44.69 199.35,44.69 200.05,45.4 203.61,45.4 v1(204.64,44.37)
  IN2 w0.127: v1(191.3,46.25) 191.1,46.45 191.1,49.4 189.83,50.67 186.83,50.67 185.9,51.6 185.9,54.49 187.21,55.8 187.21,63.01 184.26,65.96 184.26,71.29 181.9,73.66 v1(180.89,73.66)
  BOTTOM w0.114: v1(204.64,44.37) 204.31,44.69 U45.123 ; v1(180.89,73.66) 182.03,74.8 182.03,81.96 179.16,84.83 178.89,84.83 178.2,85.52 172.47,85.52 171.39,86.6 167.17,86.6 164.15,89.62 164.15,90.12 163.38,90.88 162.6,90.88 161.86,91.62 161.86,94.25 161.15,94.96 159.28,94.96 158.37,95.87 v1(158.37,96.29) 158.37,97.29 158.21,97.45 R677.1
DP_UTIL: length 7.6
  BOTTOM w0.114: R546.2 128.06,136.51 v1(128.36,136.22) 128.37,136.21 R553.2 128.31,135.38 127.47,134.54
  BOTTOM w0.127: U35.B52 127.75,130.66 127.75,132.56 127.47,132.84 127.47,134.54
DPWROK_C: length 107.8
  IN2 w0.127: v1(176.87,78.63) 177.38,79.14 181.17,79.14 183.67,76.64 191.67,76.64 192.09,76.64 192.93,75.8 192.93,60.92 192.19,60.18 192.19,52.62 193.81,51 193.81,47.7 196.28,45.23 198.59,45.23 199.15,44.67 200.74,44.67 201.1,44.31 201.1,43.3 198.36,40.56 v1(198.36,37.44)
  BOTTOM w0.114: v1(198.36,37.44) 197.72,37.44 196.69,36.41 194.39,36.41 193.95,35.97 193.13,35.97 193.08,35.91 U45.76 ; R674.2 R675.1 151.73,96.38 v3(151.73,95.68) 151.73,94.18 158.2,87.71 162.99,87.71 166.28,84.42 168.26,84.42 168.37,84.3 170.65,84.3 171.79,83.17 174.35,83.17 176.87,80.64 v1(176.87,78.63)
DPWROK_R: length 13.8
  BOTTOM w0.076: U35.BB20 145.84,107.88 148.33,105.39 149.14,105.39 149.85,104.68 149.85,103.88
  BOTTOM w0.114: 149.85,103.88 149.85,103.22 151.57,101.5 v3(151.57,100.99) 151.85,100.71 151.85,100 152.04,99.81 R661.1 152.49,99.31 151.85,98.67 R674.1
EC_FB_CLAMP: length 131.2
  TOP w0.114: R129.2 177.36,135.73 177.26,135.63 177.26,134.87 R140.1 177.76,134.88 177.76,135.2 v1(178.07,135.5)
  IN1 w0.127: v1(178.07,135.5) 179.06,135.5 181.85,132.72 181.85,128.04 180.78,126.98 180.78,125.24 181.44,124.58 181.44,124.27 182.69,123.03 182.69,116.16 183.88,114.96 183.88,114.92 186.56,112.24 187.41,112.24 189.67,109.98 189.67,106.63 190.41,105.89 190.41,105 190.13,104.72 189.06,104.72 187.93,103.59 187.93,92.66 189.18,91.41 189.18,87.41 194.56,82.03 196.06,82.03 200.3,77.78 200.3,74.09 205.18,69.22 205.18,67.15 208.42,63.91 208.42,53.72 206.27,51.57 206.27,49.65 205.71,49.09 205.71,47.52 203.17,44.98 203.17,40.18 v1(203.27,40.08)
  BOTTOM w0.114: v1(203.27,40.08) 203.2,40 201.87,40 199.95,38.08 197.66,38.08 196.48,36.9 194.17,36.9 193.58,36.31 U45.77
EC_FPBACK#: length 234.7
  TOP w0.114: v1(140.35,174.75) 140.25,174.65 v1(139.71,174.65) 132.4,174.65 130.17,172.42 118.8,172.42 118.63,172.24 118.05,172.24 117.9,172.39 115.3,172.39 Q4.2
  IN1 w0.127: v1(204.62,40.42) 203.94,41.11 203.94,44.66 206.48,47.2 206.48,48.77 207.04,49.33 207.04,51.26 209.19,53.41 209.19,64.21 205.94,67.46 205.94,69.53 201.07,74.41 201.07,78.12 199.86,79.33 199.86,80.74 195.75,84.86 193.17,84.86 191.45,86.58 191.45,87.4 191.88,87.83 193.31,87.83 193.89,88.41 193.89,89.53 195.29,90.93 195.29,97.1 193.59,98.8 193.59,107.56 193.23,107.92 193.23,108 192.85,108.38 192.8,108.38 192.52,108.66 192.52,108.68 190.59,110.61 190.56,110.61 187.9,113.28 186.96,113.28 184.9,115.34 184.9,115.38 183.71,116.58 183.71,123.45 183.3,123.85 183.3,124.15 182.92,124.53 182.92,124.63 182.21,125.34 182.21,126.96 183.07,127.82 183.07,133.65 176.48,140.24 170.31,140.24 166.2,144.35 166.2,145.05 165.82,145.44 164.91,145.44 164.34,146.01 164.34,148.88 164.93,149.47 164.93,150.63 165.94,151.63 166.66,151.63 167.7,152.67 v1(167.7,159.89) ; v1(156.17,173.86) 155.66,174.37 155.66,175.64 155.21,176.09 143.39,176.09 142.7,175.4 141,175.4 v1(140.35,174.75)
  IN2 w0.127: v1(156.17,173.86) 156.93,173.86 158.05,172.74 160.52,172.74 160.77,173 162.98,173 165.44,170.53 165.44,162.68 167.7,160.42 v1(167.7,159.89)
  BOTTOM w0.114: v1(204.62,40.42) 204.47,40.42 204.34,40.55 202.1,40.55 200.79,39.24 195.67,39.24 195.03,38.6 194.53,38.6 193.38,39.75 193.18,39.75 193.01,39.91 U45.86
EC_GND: length 21.9
  TOP w0.254: R782.1 196.35,48.03 v1(196.3,47.98)
  TOP w0.508: L11.1 197.79,38.02 197.24,38.56 v1(197.24,39.98)
  BOTTOM w0.203: 207.1,44.29 207.1,44.02 207.2,43.91 U45.1 ; U45.49 199.91,30.85 ; U45.27 209.31,33.52 ; U45.91 191.25,41.91 ; U45.104 196.71,47.04
  BOTTOM w0.254: 199.91,30.85 198.62,32.15 v1(197.78,32.15) ; 196.71,47.04 196.71,47.29 196.3,47.7 v1(196.3,47.98) ; 207.1,44.29 207.25,44.45 207.25,45.18 207.86,45.79 R784.1 208.36,45.35 v1(207.85,44.84) ; R783.1 189.56,41.12 189.93,41.12 v1(190.08,41.27) 190.72,41.91 191.25,41.91 ; v1(211.16,32.84) 210.45,32.84 210.14,33.15 R785.1 210.12,33.52 209.31,33.52

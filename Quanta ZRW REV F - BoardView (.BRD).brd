# Allegro board Quanta ZRW REV F - BoardView (.BRD).brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
EC_ODD_EJ: length 4.9
  TOP w0.114: R746.1 R209.1 v3(229.93,110.99) 231.92,110.99 CN9.11
EC_ODD_EJ_R: length 124.1
  TOP w0.114: R746.2 C799.1 226.03,111.95 226.02,111.94 v1(226.02,111.25)
  IN1 w0.127: v1(226.02,111.25) 226.02,110.87 224.88,109.72 223.8,109.72 221.6,107.52 221.6,101.16 222.31,100.45 222.31,95.12 223.91,93.52 223.91,93.01 223.61,92.71 219.42,92.71 215.15,88.44 215.15,83.19 212.84,80.88 212.84,78.64 211.39,77.19 211.39,71.83 214.77,68.45 214.77,67.13 217.24,64.67 217.24,61.63 218.59,60.27 218.59,58.35 217.58,57.33 217.58,54.67 215.23,52.32 215.23,50.44 212.98,48.19 212.98,46.41 213.37,46.02 v1(213.37,42.82)
  BOTTOM w0.114: U45.94 190.83,43.11 190.41,43.53 190.41,47.01 v3(190.77,47.37) 191.1,47.37 192.24,46.22 192.24,45.21 192.87,44.58 193.85,44.58 194.93,43.5 198.98,43.5 199.8,42.67 202.27,42.67 202.68,43.08 205.43,43.08 206.92,44.57 206.92,46.12 207.68,46.88 209.16,46.88 209.72,46.33 209.72,43.89 210.07,43.53 211.42,43.53 211.7,43.25 212.94,43.25 v1(213.37,42.82)
EC_PECR_R: length 3.2
  BOTTOM w0.114: U45.117 201.91,47.27 v1(201.79,47.39) R738.1
EC_PWROK: length 177.2
  TOP w0.114: v1(178.4,124.96) 177.97,125.4 177.97,125.57 175.78,127.76 173.52,127.76 172.71,128.57 172.71,129.77 172.11,130.36 172.11,130.61 170.85,131.87 170.09,131.87 169.23,132.74 168.29,132.74 166.2,134.82 164.3,134.82 164.17,134.69 v1(163.79,134.69) 163.79,134.75 163.8,134.77 163.8,136.03 R131.2 R130.2 162.02,136.53 161.63,136.14 161.63,135.89 161.38,135.63 160.62,135.63 160.36,135.38 U8.2 ; v1(219.8,50.92) 219.54,51.18 215.86,51.18 210.91,56.13 209.89,56.13 209,57.02 209,58.03 207.48,59.56 207.48,62.61 206.21,63.88 206.21,64 204.38,65.83 v3(200.44,65.83) v1(199.22,67.05)
  IN1 w0.127: v1(199.22,67.05) 199.29,67.12 199.29,72.96 197.47,74.77 197.47,78.2 194.97,80.7 194.09,80.7 192.5,82.29 191.15,82.29 187.64,85.8 187.64,90.41 185.78,92.27 185.78,93.33 186.65,94.21 186.65,106.47 185.94,107.18 184.95,107.18 183.77,108.37 183.77,110.8 182.96,111.62 182.65,111.62 181.13,113.14 181.13,118.75 180.44,119.44 180.44,121.49 180.06,121.87 180.06,122.55 179.64,122.97 179.64,123.87 178.55,124.96 v1(178.4,124.96)
  IN2 w0.127: v1(219.8,50.92) 219.8,48.74 224.17,44.37 224.17,32.99 222.52,31.34 218.43,31.34 216.75,33.02 216.75,35.1 214.06,37.79 212.56,37.79 211.86,37.09 208.86,37.09 206.95,35.17 206.95,33.52 206.29,32.86 206.29,28.52 v1(206.15,28.38)
  BOTTOM w0.114: R560.2 163.37,134.77 163.72,134.77 v1(163.79,134.69) ; U45.33 206.31,28.55 v1(206.15,28.38)
EC_PWROK_R: length 10.3
  BOTTOM w0.076: R643.2 152.38,104.73 152.17,104.94 151.62,104.94 151.46,105.1 151.22,105.1 150.86,104.75 150.86,104.3 R647.1 150.14,104.46 150.14,104.64 149.22,105.56 148.4,105.56 146.11,107.85 146.11,108.6 145.84,108.87 U35.BA20
EC_RCIN#: length 14
  BOTTOM w0.076: R639.2 156.24,104.91 155.66,105.49 154.72,105.49 154.22,105.99 153.39,105.99 153.2,106.18 152.1,106.18 151.79,106.49 151.13,106.49 151.01,106.6 150.07,106.6 149.21,107.46 149.21,107.87 149.06,108.02 149.06,108.46 149.07,108.49 149.1,108.57 149.1,108.69 149.04,108.91 149.04,109.05 149.1,109.21 149.1,109.66 149.49,110.05 U35.AW13
  BOTTOM w0.114: R639.2 156.25,104.48 156.25,103.3 R652.2
EC_RTCRST: length 103.1
  TOP w0.114: R786.1 172.75,42.62 174.84,42.62 175.73,41.73 175.73,33.04 175.15,32.46 171.5,32.46 171.19,32.14 167.85,32.14 v1(167.73,32.26) ; R786.1 172.56,43.43 173.34,43.43 173.57,43.66 PQ6059.2 ; R786.1 172.09,43.28 PQ6060.2
  IN1 w0.127: v1(167.73,32.26) 172.71,27.28 172.71,26.01 173.29,25.42 190.18,25.42 192.44,23.16 192.44,21.99 194.31,20.13 205.11,20.13 205.85,20.87 v1(205.85,21.81)
  IN2 w0.127: v1(208.98,44.57) 207.81,43.4 207.81,42.92 207.07,42.19 205.55,42.19 205.09,41.73 204.33,41.73 203.85,41.25 203.85,39.67 204.51,39.01 204.51,39.01 204.53,39 204.83,39 205.04,38.78 205.04,38.25 204.61,37.82 203.87,37.82 203.47,37.41 203.47,36.8 203.72,36.55 204,36.55 204.56,35.99 204.56,34.57 205.98,33.14 205.98,28.85 205.7,28.57 205.7,24.18 205.5,23.97 205.5,22.17 v1(205.85,21.81)
  BOTTOM w0.114: U45.3 208.94,43.11 209.13,43.3 209.13,44.42 v1(208.98,44.57)
EC_SCI#: length 128
  IN1 w0.127: v1(171.32,130.07) 171.72,130.07 172.4,129.38 172.4,128.57 173.22,127.76 174.54,127.76 177.33,124.97 177.33,124.56 179.55,122.34 179.55,121.66 179.92,121.29 179.92,117.67 180.62,116.98 180.62,112.78 181.88,111.52 181.88,111.02 183.22,109.67 183.22,108 185.13,106.09 185.13,105.48 186.14,104.47 186.14,94.84 185.27,93.96 185.27,92.06 187.13,90.2 187.13,85.59 191.17,81.56 192.37,81.56 193.73,80.2 194.54,80.2 196.94,77.8 196.94,73.91 198.53,72.32 198.53,62.99 197.18,61.64 197.18,60.1 196.55,59.46 196.55,56.56 195.73,55.75 195.73,53.21 196.46,52.49 197.21,52.49 198.29,51.41 198.29,50.54 198.91,49.92 199.92,49.92 200.94,48.9 200.94,46.92 200.1,46.08 200.1,42.27 201.08,41.29 201.08,35.7 202.8,33.97 v1(202.8,33.68)
  BOTTOM w0.114: R571.1 168.36,129.4 168.36,130.74 R781.1 169.84,130.21 170.46,130.21 v1(170.65,130.02) 170.7,130.07 v1(171.32,130.07) ; v1(202.8,33.68) 203.36,34.24 205.63,34.24 206.15,34.76 206.79,34.76 207.14,35.11 U45.23
ECAGND: length 1.2
  BOTTOM w0.203: v1(193.5,35.52) U45.75
  vias: v1(194.07,31.77) v1(194.7,32.15) v1(194.86,37.72) v1(196.38,38.3)
EDP_AUX#_C: length 11
  BOTTOM w0.114: R449.2 R450.1 137.67,189.02 136.15,189.02 135.78,189.39 135.78,190.23 CN5.22 134.62,191.38 134.45,191.38 132.58,193.26 132.58,194.03 132.27,194.33 131.82,194.33 C2.2
EDP_AUX_C: length 11
  BOTTOM w0.114: C4.2 131.83,194.09 132.17,194.09 132.33,193.92 132.33,193.16 134.27,191.21 134.27,191.04 CN5.23 135.53,189.78 135.53,189.29 136.05,188.78 137.56,188.78 R447.1 R448.2
EDP_AUXN: length 91.8
  IN2 w0.127: v1(129.89,194.48) 129.54,194.13 129.02,194.13 128.23,193.34 128.23,186.56 127.01,185.34 120.35,185.34 117.89,182.88 117.43,182.88 115.79,181.23 115.79,165.96 115.19,165.37 115.19,154.72 116.93,152.98 116.93,151.27 119.29,148.91 119.29,146.75 122.34,143.71 127.77,143.71 129.76,141.73 132.32,141.73 133.21,140.84 133.21,131.39 132.5,130.68 132.06,130.68 131.03,129.64 131.03,128.67 v2(130.84,128.48)
  BOTTOM w0.114: C2.1 130.66,194.42 130.49,194.26 130.12,194.26 v1(129.89,194.48) ; U35.E45 131.29,128.32 131.14,128.48 v2(130.84,128.48)
EDP_AUXP: length 91.7
  IN2 w0.127: v1(129.89,193.8) 129.82,193.87 129.12,193.87 128.49,193.24 128.49,186.46 127.11,185.09 120.46,185.09 118,182.62 117.54,182.62 116.04,181.12 116.04,165.86 115.44,165.26 115.44,154.82 117.18,153.08 117.18,151.38 119.55,149.02 119.55,146.86 122.44,143.96 127.88,143.96 129.86,141.98 132.42,141.98 133.46,140.94 133.46,131.29 132.6,130.42 132.17,130.42 131.28,129.54 131.28,128.27 v2(130.83,127.82)
  BOTTOM w0.114: U35.F45 131.09,127.57 v2(130.83,127.82) ; v1(129.89,193.8) 130.1,194.01 130.37,194.01 130.66,193.72 C4.1
EDP_HPD: length 113
  IN1 w0.127: v1(160.85,129.13) 160.85,129 160.23,128.38 158.33,128.38 158.05,128.1 155.24,128.1 154.22,127.07 154.22,125.8 153.89,125.47 153.76,125.47 153.56,125.27 152.63,125.27 151.89,124.52 v2(151.89,124.5) ; v1(167.53,138.3) 167.53,139.44 166.44,140.53 166.44,140.69 162.59,144.55 162.59,146.93 163.22,147.57 163.22,149.29 163.86,149.93 163.86,151.34 165.7,153.18 165.7,157.5 164.81,158.39 164.81,169.48 163.79,170.49 163.79,176.05 164.65,176.91 164.65,180.55 159.85,185.34 159.85,186.94 155.74,191.05 150.71,191.05 149.3,192.46 147.28,192.46 146.53,191.71 143.54,191.71 139.25,187.42 137.1,187.42 v1(136.94,187.27)
  IN2 w0.127: v1(167.53,138.3) 167.53,138.22 168.11,137.64 168.11,136.77 168.36,136.52 168.36,135.42 167.65,134.7 167.65,133.12 166.46,131.92 165.16,131.92 162.37,129.13 v1(160.85,129.13)
  BOTTOM w0.114: v1(160.85,129.13) 161.12,129.13 R563.2 ; v1(136.94,187.27) 136.37,186.69 C804.2 R457.1 ; U35.L10 151.48,124.93 151.89,124.52 v2(151.89,124.5)
EDP_HPD_R: length 6.4
  BOTTOM w0.114: CN5.25 134.58,189.34 134.58,188.74 135.18,188.15 135.59,188.15 v1(135.75,187.98) 136.03,187.7 137.25,187.7 137.5,187.45 137.5,187.07 137.76,186.81 138.02,186.81 R457.2
EDP_RCOMP: length 7.8
  TOP w0.508: v1(133.57,127.83) 134.27,127.83 R154.1
  IN1 w0.508: v1(133.57,127.83) 132.68,127.83 131.41,129.1 128.18,129.1 v2(127.85,128.77)
  BOTTOM w0.305: U35.E52 127.63,128.55 v2(127.85,128.77)
EDP_TXN0: length 100.3
  IN2 w0.127: v1(135.68,200.39) 135.46,200.39 135.27,200.2 135.27,199.59 134.66,198.98 131.28,198.98 126.07,193.77 126.07,192.19 121.43,187.55 119.37,187.55 117.49,185.67 116.98,185.67 115.48,184.17 114.9,184.17 114.19,183.46 114.19,182.8 113.5,182.11 113.5,179.57 113.31,179.38 113.31,171.31 113.67,170.94 113.67,167.43 112.28,166.04 112.28,147.95 117.24,143 120.32,143 121.98,141.34 125.29,141.34 125.67,140.97 126.96,140.97 127.52,140.41 127.52,139.11 127.33,138.92 127.33,137.07 128.59,135.81 129.43,135.81 130.11,135.13 130.11,132.83 129.68,132.41 129.2,132.41 v1(129.12,132.33)
  BOTTOM w0.076: U35.C47 129.85,129.64 129.48,130 129.41,130.18 129.41,130.43 129.45,130.51 129.45,130.72 129.42,130.79 129.42,130.79 129.42,131.18 129.84,131.61 129.84,132.01 129.52,132.33 v1(129.12,132.33)
  BOTTOM w0.114: C12.1 135.33,199.79 135.33,200.19 135.54,200.39 v1(135.68,200.39)
EDP_TXN0_C: length 8.2
  BOTTOM w0.114: C12.2 135.41,198.2 135.41,197.75 136.08,197.07 136.08,195.09 135.88,194.89 135.88,193.26 136.11,193.03 136.23,193.03 136.36,193.16 137.02,193.16 CN5.16
EDP_TXN1: length 97
  IN2 w0.127: v5(131.69,133.12) 131,133.12 130.54,133.57 130.54,135.91 130.13,136.32 128.89,136.32 128.05,137.15 128.05,140.05 128.56,140.56 128.56,141.27 128.36,141.47 127.57,141.47 126.81,142.24 121.69,142.24 120.4,143.53 117.56,143.53 112.86,148.23 112.86,165.71 114.19,167.03 114.19,171.8 113.74,172.24 113.74,178.98 113.93,179.17 113.93,181.81 114.69,182.57 114.69,183.25 115.11,183.66 115.71,183.66 117.2,185.16 117.71,185.16 119.59,187.04 121.98,187.04 122.57,187.63 123.31,188.36 124.7,188.36 125.36,189.03 125.36,190.4 126.61,191.64 126.61,193.4 129.35,196.13 131.45,196.13 132.04,196.72 132.36,196.72 v1(132.59,196.95)
  BOTTOM w0.076: v5(131.69,133.12) 131.66,133.09 131.66,132.99 131.23,132.55 131.23,131.75 131.43,131.54 131.43,130.87 131.37,130.7 131.37,130.56 131.44,130.33 131.44,130.2 131.35,130.02 131.35,129.59 131.09,129.32 U35.D46
  BOTTOM w0.114: C8.1 133.24,196.83 132.71,196.83 v1(132.59,196.95)
EDP_TXN1_C: length 7
  BOTTOM w0.114: CN5.19 135.89,192.2 135.76,192.2 135.19,192.77 135.19,195.73 135.34,195.88 135.34,196.36 135.01,196.69 134.54,196.69 C8.2
EDP_TXP0: length 100.2
  IN2 w0.127: v1(134.86,200.39) 135.01,200.24 135.01,199.69 134.55,199.23 131.18,199.23 125.82,193.87 125.82,192.3 121.32,187.8 119.26,187.8 117.38,185.92 116.87,185.92 115.38,184.43 114.79,184.43 113.93,183.56 113.93,182.91 113.25,182.22 113.25,179.68 113.06,179.49 113.06,171.2 113.42,170.84 113.42,167.53 112.03,166.14 112.03,147.85 117.13,142.74 120.22,142.74 121.87,141.09 125.18,141.09 125.56,140.71 126.86,140.71 127.27,140.3 127.27,139.22 127.07,139.02 127.07,136.97 128.48,135.56 129.32,135.56 129.86,135.02 129.86,132.94 129.58,132.66 129.43,132.66 v5(129.12,132.96)
  BOTTOM w0.076: v5(129.12,132.96) 130.01,132.08 130.01,131.54 129.59,131.12 129.59,130.82 129.61,130.76 129.61,130.47 129.58,130.4 129.58,130.21 129.62,130.1 129.75,129.97 U35.C46
  BOTTOM w0.114: v1(134.86,200.39) 135.09,200.16 135.09,199.67 C13.1
EDP_TXP0_C: length 8.2
  BOTTOM w0.114: C13.2 135.17,198.16 135.17,197.65 135.84,196.97 135.84,195.19 135.64,194.99 135.64,193.16 136.01,192.79 136.23,192.79 136.36,192.65 136.83,192.65 CN5.17
EDP_TXP1: length 96.9
  IN2 w0.127: v1(132.59,196.08) 132.59,196.27 132.4,196.46 132.14,196.46 131.56,195.88 129.45,195.88 126.86,193.29 126.86,191.54 125.62,190.29 125.62,188.92 124.8,188.11 123.41,188.11 122.09,186.79 119.7,186.79 117.82,184.91 117.31,184.91 115.81,183.41 115.22,183.41 114.95,183.14 114.95,182.47 114.19,181.71 114.19,179.07 114,178.88 114,172.35 114.44,171.9 114.44,166.92 113.12,165.6 113.12,148.34 117.67,143.79 120.5,143.79 121.8,142.49 126.91,142.49 127.68,141.73 128.46,141.73 128.82,141.38 128.82,140.45 128.31,139.95 128.31,137.26 128.99,136.57 130.24,136.57 130.8,136.01 130.8,133.68 131.1,133.37 131.31,133.37 131.58,133.65 v1(131.58,133.8)
  BOTTOM w0.076: U35.C45 131.19,129.85 131.19,130.06 131.27,130.23 131.27,130.31 131.24,130.43 131.21,130.54 131.21,130.73 131.27,130.9 131.27,131.48 131.06,131.68 131.06,132.62 131.28,132.84 131.28,132.91 131.25,132.94 131.25,133.22
  BOTTOM w0.114: 131.25,133.22 131.25,133.3 131.28,133.32 131.28,133.5 v1(131.58,133.8) ; C10.1 133.43,196.39 133.23,196.59 132.83,196.59 132.59,196.35 v1(132.59,196.08)
EDP_TXP1_C: length 6.9
  BOTTOM w0.114: CN5.20 135.63,191.77 135.63,191.98 134.95,192.67 134.95,195.83 135.1,195.98 135.1,196.26 134.91,196.45 134.37,196.45 134.21,196.3 C10.2
EDP_VDD_EN: length 174.2
  TOP w0.114: v1(161.12,186.69) 161.12,186.7 152.23,195.59 152.23,198.37 149.78,200.83 138.89,200.83 138.59,200.53 137.63,200.53 136.11,199 131.87,199 129.65,196.78 127.53,196.78 122.08,191.33 121.06,191.33 119.6,189.86 119.47,189.86 116.55,186.94 115.91,186.94 114.01,185.03 R37.1 ; v1(173.27,120.57) 173.14,120.7 173.14,122.68 174.09,123.63 174.09,124.24 173.87,124.46 173.87,125.74 174.16,126.02 174.16,126.44 172.43,128.16 172.43,129.72 171.82,130.33 171.82,130.52 170.73,131.62 170.01,131.62 169.13,132.51 168.19,132.51 166.11,134.59 164.53,134.59 164.02,134.08 159.48,134.08 159.22,134.34 159.22,136.75 157.95,138.02 157.95,141.71 157.95,142.6 157.95,142.6 157.95,146.93 v1(158.71,147.7)
  IN1 w0.076: 154.77,120.46 154.23,120.46 153.87,120.81 150.55,120.81 150.2,121.15 150.2,121.46 149.11,122.55 v2(149.06,122.55)
  IN1 w0.127: v1(158.71,147.7) 158.71,151.18 161.12,153.59 161.12,162.39 161.98,163.24 161.98,163.84 160.01,165.81 160.01,172.79 v1(159.32,173.48) ; 154.77,120.46 156.25,120.46 156.43,120.63 161.72,120.63 163.35,122.27 163.64,122.27 164.52,121.38 164.53,121.38 164.64,121.27 165.7,121.27 166.62,120.35 169.29,120.35 169.51,120.57 v1(173.27,120.57)
  BOTTOM w0.114: v1(161.12,186.69) 160.11,185.67 v3(160.11,184.98) 160.11,182.75 156.89,179.53 156.89,176.54 159.32,174.11 v1(159.32,173.48)
  BOTTOM w0.127: U35.U13 149.53,122.08 v2(149.06,122.55)
EDP_VDD_EN_R: length 3.7
  TOP w0.114: R37.2 114.24,183.5 R38.2 115.41,184.28 116.39,185.25 U1.3
ESPI_RST#: length 3.8
  BOTTOM w0.114: U45.22 209.16,35.52 R748.2 210.16,34.51 R749.2
FANSIG: length 235.8
  TOP w0.114: v1(50.38,103.37) 50.38,111.76 51.14,112.52 62.57,112.52 63.08,112.01 v1(66.64,112.01) 68.03,112.01 C719.2 R609.2
  IN1 w0.127: v1(198.16,33.14) 198.16,32.43 198.39,32.2 198.39,30.83 196.85,29.29 193.51,29.29 192.66,28.44 190.84,28.44 190.35,28.94 186.72,28.94 186.27,28.49 182.87,28.49 182.38,28.98 179.97,28.98 178.75,30.2 171.66,30.2 170.95,30.9 170.95,31.55 167.36,35.15 100.8,35.15 87.67,48.28 83.64,48.28 83.26,48.66 83.26,49.11 71.2,61.17 69.88,61.17 61.84,69.21 61.84,71.17 60.64,72.36 60.64,74.57 60.08,75.13 60.08,75.41 59.35,76.15 59.08,76.15 58,77.22 58,77.24 56.63,78.61 55.42,78.61 49.73,84.3 48.93,84.3 47.46,85.77 47.46,88.13 48.48,89.15 48.48,90.04 51.59,93.15 51.59,95.63 51.27,95.94 51.27,102.48 v1(50.38,103.37)
  BOTTOM w0.114: U45.47 200.71,31.05 198.82,32.94 198.36,32.94 v1(198.16,33.14) ; v1(66.64,112.01) 66.8,111.85 CN8.2
FB_CAL_PD_VDDQ: length 17.1
  TOP w0.381: R84.2 194.4,149.85 194.4,150.62 193.51,151.51 v1(193.51,154.3) 193.51,158.19 193.31,158.39 193.31,159.71 191.25,161.77 191.25,162.4 v1(190.23,163.43)
  BOTTOM w0.381: U34.D22 190.63,163.82 v1(190.23,163.43)
FB_CAL_PU_GND: length 3.1
  TOP w0.102: R73.2 192.42,163.95 191.76,164.61 v1(191.76,164.79) 191.84,164.87 v1(191.84,165.9)
  BOTTOM w0.114: U34.C24 191.46,165.52 v1(191.84,165.9)
FB_CAL_TERM_GND: length 1.4
  TOP w0.102: R71.2 192.6,166.69 v1(192.63,166.73)
  BOTTOM w0.381: v1(192.63,166.73) 192.23,166.33 U34.B25
FB_CLAMP_MON: length 36.1
  TOP w0.114: R120.1 174.55,137.83 174.71,137.99 Q14.1 174.71,138.81 v1(175.6,139.7)
  BOTTOM w0.114: v1(175.6,139.7) 178.19,139.7 180.52,137.37 189.83,137.37 190.77,138.3 191.72,138.3 v1(191.98,138.55) 192.46,139.04 192.46,139.78 192.32,139.92 192.32,142.15 193.48,143.32 193.48,144.76 194.31,145.59 194.31,148.14 193.43,149.02 193.43,149.04 192.63,149.84 192.63,150.72 192.38,150.97 191.78,150.97 U34.C6
FB_CLAMP_REQ#: length 138.5
  TOP w0.114: v1(205.02,35.33) 205.32,35.63 R379.1 205.16,36.09 v1(203.72,36.09) ; R125.2 171.17,136.91 170.9,136.65 170.27,136.65 169.86,136.24 169.86,135.99 v1(169.68,135.81) 169.76,135.73 v1(169.76,135.12)
  IN1 w0.127: v1(203.72,36.09) 203.31,36.5 203.31,37.49 203.62,37.79 203.62,39.79 203.72,39.89 203.72,40.59 203.43,40.88 203.43,44.87 205.97,47.41 205.97,48.99 206.53,49.54 206.53,51.47 208.69,53.63 208.69,64 205.44,67.25 205.44,69.32 200.56,74.2 200.56,77.91 195.48,82.99 193.96,82.99 189.43,87.51 189.43,91.52 188.19,92.76 188.19,103.46 189.18,104.45 190.25,104.45 190.67,104.87 190.67,106 189.93,106.73 189.93,110.1 187.54,112.49 186.67,112.49 184.14,115.02 184.14,115.07 182.94,116.26 182.94,123.13 181.78,124.3 181.78,124.61 181.14,125.25 181.14,126.97 182.23,128.06 182.23,132.69 178.98,135.95 177.57,135.95 177.42,135.8 175.39,135.8 174.73,135.14 173.08,135.14 172.63,135.58 170.22,135.58 v1(169.76,135.12)
  BOTTOM w0.114: v1(205.02,35.33) 206.01,35.33 207,36.31 U45.20
FBA_CMD0: length 72.1
  TOP w0.114: U5.K1 218.94,168.02 218.94,168.13 218.81,168.26 215.76,168.26 215.38,167.89 v1(214.59,167.89) ; v1(204.63,168.94) 204.93,168.64 204.93,168.48 205.18,168.23 207.64,168.23 207.76,168.11 207.76,167.77 207.61,167.62 207.07,167.62 U4.K1
  TOP w0.127: v1(198.82,174.39) 200.89,176.47 200.89,176.71 201.21,177.03 R60.2
  IN1 w0.165: v1(198.82,174.39) 198.91,174.3 198.91,173.88 201.23,171.55 202.01,171.55 202.65,170.92 203.99,170.92 204.24,170.67 204.94,170.67 205.24,170.37 208.67,170.37 209.68,169.36 209.89,169.36 209.97,169.29 209.99,169.29 v1(210.35,168.93)
  IN2 w0.127: v1(204.63,168.94) 204.71,169.02 205.02,169.02 205.47,169.46 205.83,169.46 205.86,169.44 208.37,169.44 208.51,169.58 209.7,169.58 v1(210.35,168.93) 210.54,168.74 210.65,168.74 210.86,168.94 211.04,168.94 211.24,168.74 211.24,168.65 211.35,168.53 211.86,168.53 211.97,168.65 211.97,168.95 212.09,169.07 212.29,169.07 212.41,168.95 212.41,168.65 212.52,168.53 212.82,168.53 212.94,168.65 212.94,168.83 213.05,168.94 213.22,168.94 213.61,168.55 213.84,168.55 213.9,168.48 213.9,168.26 214.27,167.89 v1(214.59,167.89)
  IN2 w0.165: v1(191.82,167.53) 191,167.53 190.49,168.04 190.49,168.6 192.46,170.57 192.95,170.57 196.1,173.72 197.12,173.72 197.53,174.14 197.54,174.14 198.23,174.14 198.54,173.83 199.15,173.83 199.38,174.06 199.38,175.74 200.47,176.83 200.47,177.06 200.19,177.34 199.96,177.34 198.69,176.07 198.69,174.52 v1(198.82,174.39)
  BOTTOM w0.114: v1(204.63,168.94) 204.52,168.94 204.12,169.34 203.69,169.34 203.03,168.69 202.93,168.69 202.4,168.16 200.91,168.16 200.57,167.82 U31.K1 ; v1(191.82,167.53) 191.43,167.91 U34.C27 ; U32.K1 212.56,167.82 212.69,167.69 212.69,167.53 212.56,167.41 212,167.41 211.87,167.53 211.87,168.1 212,168.23 214.25,168.23 v1(214.59,167.89)
FBA_CMD1: length 67.1
  TOP w0.114: U5.L2 217.63,168.62 217.29,168.96 216.94,168.96 216.87,168.88 216.35,168.88 216.1,169.13 216.1,169.59 215.82,169.86 214.88,169.86 213.98,168.96 212,168.96 209.91,166.88 208.98,166.88 v1(208.94,166.92) 208.41,166.92 208.29,167.04 208.29,167.35 208.41,167.47 209.09,167.47 209.62,168 210.31,168 210.42,168.11 210.42,168.32 210.31,168.43 209.46,168.43 208.93,167.9 208.28,167.9 208.09,168.09 208.09,168.48 208.82,169.22 208.82,169.38 208.68,169.52 208.51,169.52 207.95,168.96 206.41,168.96 U4.L2
  IN2 w0.102: v1(191.05,166.72) 191.1,166.72 191.51,166.3 192.8,166.3 193.13,166.63
  IN2 w0.165: 193.13,166.63 193.74,167.24 194.13,167.24 194.68,167.79 194.68,168.09 194.32,168.45 192.81,168.45 192.7,168.56 192.7,169.6 192.87,169.77 193.34,169.77 193.51,169.6 193.51,169.15 193.68,168.98 193.98,168.98 194.14,169.15 194.14,170.46 194.45,170.76 194.83,170.76 195.92,169.67 195.92,169.38 195.76,169.21 195.45,169.21 195.16,169.51 194.92,169.51 194.68,169.26 194.68,169.03 195.26,168.45 195.26,167.85 195.43,167.69 196.21,167.69 196.38,167.85 196.38,170.1 195.1,171.38 195.1,171.61 195.32,171.83 195.55,171.83 196.08,171.3 196.31,171.3 197.05,172.04 197.28,172.04 197.52,171.81 197.52,171.57 196.78,170.84 196.78,170.6 197.04,170.34 197.04,167.85 197.21,167.69 197.54,167.69 197.7,167.85 197.7,168.44 197.87,168.6 198.2,168.6 198.36,168.44 198.36,167.85 198.53,167.69 200.48,167.69 200.68,167.89 201.7,167.89 202.37,167.21 203.57,167.21 204.04,166.74 207.08,166.74 207.31,166.97 207.93,166.97 207.97,166.92 v1(208.94,166.92)
  BOTTOM w0.114: v1(191.05,166.72) 191.43,167.11 U34.C26
FBA_CMD2: length 67
  IN2 w0.102: 192.27,167.25 192.13,167.12 191.65,167.12 191.64,167.13 190.88,167.13 190.63,166.88 190.63,166.37 v1(190.19,165.93)
  IN2 w0.165: 192.27,167.25 192.34,167.32 192.34,167.95 192.17,168.12 191.26,168.12 191.1,168.28 191.1,168.69 191.32,168.91 192.17,168.91 192.34,169.07 192.34,169.92 192.61,170.2 193.1,170.2 195.31,172.41 195.6,172.41 195.94,172.08 196.17,172.08 196.41,172.31 196.41,172.54 196.14,172.8 196.14,173.04 196.38,173.27 196.61,173.27 198.6,171.28 198.83,171.28 199.07,171.52 199.07,171.75 197.56,173.26 197.56,173.49 197.84,173.77 198.08,173.77 198.39,173.47 198.56,173.47 198.95,173.08 198.95,172.91 199.11,172.74 199.42,172.74 199.58,172.91 199.58,173.21 199.75,173.38 200.16,173.38 200.41,173.13 200.41,172.28 200.03,171.9 200.03,170.32 199.87,170.16 199.15,170.16 198.77,170.53 198.54,170.53 198.31,170.3 198.31,170.07 198.68,169.69 198.68,169.46 198.53,169.3 198.53,168.89 198.99,168.43 199.49,168.43 199.66,168.59 199.66,168.94 199.82,169.11 200.23,169.11 200.39,168.94 200.39,168.59 200.56,168.43 201.22,168.43 201.4,168.6 201.59,168.6 201.72,168.73 201.72,169.15 201.88,169.31 202.14,169.31 202.3,169.15 202.3,167.97 202.74,167.53 203.69,167.53 204.21,167.01 206.68,167.01 207.03,167.36 209.57,167.36 v1(209.62,167.3)
  BOTTOM w0.114: v1(190.19,165.93) U34.E24 ; U32.L2 213.14,168.9 213.03,169.02 212.09,169.02 211.97,168.9 211.97,168.72 211.87,168.62 211.61,168.62 211.49,168.73 211.49,169.03 211.38,169.14 211.16,169.14 211.05,169.03 211.05,168.44 210.81,168.2 210.58,168.2 210.45,168.33 209.73,168.33 209.61,168.22 209.61,167.99 209.73,167.87 210.13,167.87 210.25,167.76 210.25,166.83 209.37,165.96 209.21,165.96 209.03,166.15 209.03,166.31 209.62,166.91 v1(209.62,167.3) 209.37,167.3 208.92,167.75 208.28,167.75 207.02,169.02 206,169.02 205.65,169.36 205.65,169.52 205.39,169.78 205.23,169.78 204.76,170.24 203.79,170.24 203.06,169.51 202.63,169.51 202.17,169.04 201.99,169.04 201.57,168.62 U31.L2
FBA_CMD3: length 72.6
  TOP w0.114: v1(215.25,168.35) 215.2,168.31 214.39,168.31 214.37,168.28 212.84,168.28 212.75,168.19 212.75,167.63 212.63,167.51 212.46,167.51 212.34,167.63 U5.K9 ; U4.K9 200.83,168.18 202.32,168.18 202.82,168.68 203.64,168.68 203.84,168.88 v1(203.84,168.88)
  TOP w0.127: v1(197.57,175.56) 199.03,175.56 R59.1
  IN1 w0.165: v1(197.57,175.56) 198.31,174.82 198.31,173.95 199.12,173.14 199.12,172.15 199.43,171.84 199.48,171.84 200.11,171.21 200.82,171.21 200.94,171.08 201.86,171.08 202.14,170.81 202.14,170.2 202.41,169.92 203.39,169.92 203.77,170.3 204.79,170.3 205.09,170 206.49,170 207.22,169.26 209.26,169.26 209.62,168.9 v1(209.7,168.9)
  IN2 w0.127: v1(203.84,168.88) 203.84,168.66 204,168.51 204.45,168.51 204.53,168.43 204.95,168.43 205.08,168.56 205.99,168.56 206.11,168.67 206.11,168.99 206.22,169.11 208.51,169.11 208.65,169.25 209.35,169.25 v1(209.7,168.9) 210.19,168.41 210.41,168.41 210.61,168.2 213.49,168.2 214.3,167.39 214.79,167.39 215.25,167.84 v1(215.25,168.35)
  IN2 w0.165: v1(189.36,165.93) 189.36,167.66 189.48,167.79 189.48,169 194.82,174.34 195.66,174.34 195.82,174.51 195.82,174.91 195.66,175.08 194.92,175.08 194.75,175.24 194.75,175.57 194.92,175.74 195.48,175.74 195.64,175.9 195.64,176.44 195.81,176.6 196.09,176.6 196.25,176.44 196.25,175.89 196.62,175.52 196.85,175.52 197.09,175.76 197.09,175.99 196.94,176.14 196.94,176.4 198.1,177.56 198.34,177.56 198.63,177.28 198.63,177.04 197.95,176.37 197.95,175.73 197.79,175.56 v1(197.57,175.56)
  BOTTOM w0.114: v1(203.84,168.88) 203.74,168.78 203.74,168.61 203.89,168.46 204.05,168.46 204.13,168.53 204.46,168.53 204.76,168.23 206.46,168.23 U31.K9 ; v1(215.25,168.35) 215.27,168.38 216.9,168.38 217,168.28 217.01,168.28 217.11,168.18 218.5,168.18 218.74,167.94 U32.K9 ; v1(189.36,165.93) 189.34,165.93 U34.F24
FBA_CMD4: length 143.3
  TOP w0.114: U3.R7 185.01,187.02 186.3,188.32 186.3,188.64 186.18,188.77 185.56,188.77 185.43,188.9 185.43,189.18 185.56,189.3 v1(186.4,189.3) ; U2.R7 172.83,186.7 172.71,186.82 172.71,187.01 172.83,187.13 173.25,187.13 173.48,187.36 173.48,188.34 173.6,188.46 173.65,188.46 173.77,188.59 173.77,188.79 173.65,188.92 173.49,188.92 173.37,189.05 173.37,189.53 173.49,189.66 173.67,189.66 173.8,189.53 v1(173.8,189.48) ; U4.R7 202.07,172.14 202.47,172.55 202.47,174.86 203.03,175.41 v1(203.03,176.19) ; v1(215.53,175.62) 215.47,174.85 215.41,174.33 215.38,174.21 215.21,174.04 215.08,173.71 214.48,173.11 214.28,172.69 214.28,172.49 U5.R7
  IN1 w0.127: v1(173.8,189.48) 174,189.68 174.79,189.68 175.03,189.44 175.62,189.44 176.19,188.87 178.75,188.87 179.49,189.61 179.49,190.34 179.86,190.72 v1(180.65,190.72) 183.93,191.33 184.86,191.73 186.14,192.35 187.34,192.35 188.01,192.01 189.17,190.85 191.38,190.85 194.34,187.89 195.27,187.89 197.59,185.58 v1(198.46,185.16) 198.78,184.85 198.78,184.67 198.39,184.28 198.39,184.1 198.57,183.92 198.75,183.92 199.19,184.36 199.37,184.36 199.55,184.18 199.55,184 199.07,183.52 199.07,183.35 199.26,183.16 199.43,183.16 199.86,183.59 200.04,183.59 200.56,183.07 200.56,182.84 200.63,182.76 200.88,182.76 201,182.63 201,182.29 201.13,182.16 201.41,182.16 201.54,182.29 201.54,182.63 201.66,182.76 202.21,182.76 202.59,182.38 202.59,181.99 202.95,181.63 203.26,181.63 203.46,181.83 203.64,181.83 203.86,181.62 203.86,181.44 203.58,181.17 203.58,180.99 203.76,180.81 203.94,180.81 204.22,181.09 204.4,181.09 204.53,180.96 204.53,180.59 204.66,180.46 205.03,180.46 205.05,180.44 205.65,179.84 205.65,179.09 205.78,178.96 206.06,178.96 206.18,179.09 206.18,179.88 206.31,180.01 206.62,180.01 206.74,179.88 206.74,179.09 206.87,178.96 207.18,178.96 207.3,179.09 207.3,179.35 207.43,179.47 207.73,179.47 207.86,179.35 207.86,178.97 207.99,178.84 v1(208.21,178.84)
  IN2 w0.127: v1(180.65,190.72) 180.76,190.83 181.38,190.83 181.64,190.57 181.64,190.44 181.86,190.22 182.14,190.22 182.33,190.41 182.5,190.41 182.63,190.28 182.63,189.98 182.83,189.77 183.24,189.77 183.45,189.99 183.72,189.99 183.93,189.77 184.16,189.77 184.29,189.9 184.29,190.52 184.42,190.65 184.67,190.65 184.8,190.52 184.8,189.9 184.92,189.77 185.57,189.77 186.04,189.3 v1(186.4,189.3) ; v1(215.53,175.62) 215.36,175.89 212.29,178.96 210.63,178.96 210.26,179.34 209.41,179.34 208.85,179.25 208.65,179.17 v1(208.21,178.84) 208.15,178.9 207.61,178.9 207.58,178.88 207.4,178.71 207.4,178.53 207.64,178.29 207.64,178.11 207.44,177.91 207.26,177.91 207.04,178.14 206.86,178.14 206.68,177.96 206.68,177.78 206.8,177.66 206.8,177.48 206.56,177.25 206.16,177.25 205.25,176.33 204.92,176.33 204.75,176.5 204.49,176.5 204.3,176.31 204.3,176 204.04,175.74 203.21,175.74 203.03,175.92 v1(203.03,176.19)
  BOTTOM w0.114: v1(215.53,175.62) 215.53,174.93 215.19,174.2 215.05,173.72 214.65,173.32 214.28,172.74 214.28,172.48 U5.R7 ; v1(203.03,176.19) 203.03,175.22 202.41,174.6 202.41,172.48 202.07,172.14 U4.R7 ; U3.R7 185.29,186.98 185.29,187.3 185.37,187.38 185.37,187.89 185.7,188.22 185.7,189.78 185.83,189.91 186.35,189.91 186.47,189.78 186.47,189.38 v1(186.4,189.3) ; U2.R7 173.14,186.92 173.48,187.25 173.48,188.32 173.48,188.32 173.48,188.35 173.72,188.59 173.72,188.74 173.37,189.1 173.37,189.81 173.49,189.94 173.88,189.94 174,189.81 174,189.61 173.88,189.48 v1(173.8,189.48)
  BOTTOM w0.127: U34.D27 190.63,167.95 191.34,168.65 193.17,168.65 198.11,173.59 198.86,173.59 200.42,175.15 200.42,183.21 v1(198.46,185.16) 198.31,185.31 198.31,186 v3(199.25,186.94) R458.2 200.49,187.06 201,187.57 202.27,187.57 202.65,187.2 R459.1
FBA_CMD5: length 138.6
  TOP w0.114: U3.R2 189.23,186.7 189.37,186.84 189.47,186.84 189.63,186.99 189.63,187.17 189.48,187.31 189.3,187.31 189.15,187.16 188.98,187.16 188.7,186.88 188.52,186.88 188.38,187.01 188.38,187.19 188.67,187.48 188.67,187.86 188.73,187.92 v1(188.73,188.92) ; v1(206.5,175.86) 206.5,174.44 206.11,174.06 206.11,173.43 206.5,173.04 206.5,172.25 U4.R2 ; v1(217.92,173.61) 217.84,173.69 217.84,174.14 217.97,174.27 218.23,174.27 218.36,174.14 218.36,173.94 218.38,173.92 218.38,173.12 218.28,173.02 218.28,172.36 218.15,172.23 217.63,172.23 217.51,172.11 217.51,171.94 217.63,171.82 U5.R2 ; v1(175.37,190.83) 176.49,188.62 176.55,188.26 176.72,187.47 U2.R2
  IN1 w0.127: v1(181.6,191.61) 182.08,191.69 183.92,191.69 184.32,192.08 185.99,192.68 187.81,192.68 189.31,191.18 191.57,191.18 194.88,188.75 197.68,185.95 198.64,185.95 v1(198.84,185.75) 199.24,185.75 199.47,185.51 199.47,185.33 199.23,185.09 199.23,184.91 199.41,184.73 199.58,184.73 199.83,184.97 200.01,184.97 200.19,184.79 200.19,184.61 199.94,184.37 199.94,184.19 200.12,184.01 200.3,184.01 200.55,184.25 200.73,184.25 200.91,184.07 200.91,183.89 200.66,183.65 200.66,183.47 200.84,183.29 201.02,183.29 201.27,183.54 201.45,183.54 201.89,183.09 202.35,183.09 203.25,182.19 203.77,182.19 205.62,180.34 207.35,180.34 208.74,178.95 208.74,178.3 209.63,177.41 210.37,177.41 210.93,176.86 211.32,176.86 211.62,177.16 v1(211.62,177.63) 212.65,176.6 212.9,176.6 214.97,174.53 216.87,174.53 217.21,174.19 217.21,173.93 217.53,173.61 v1(217.92,173.61)
  IN2 w0.127: v1(206.5,175.86) 206.5,176.14 206.61,176.26 206.84,176.26 207,176.1 207.16,176.1 207.3,176.25 207.3,176.58 207.48,176.76 207.82,176.76 208.43,177.37 208.65,177.37 208.78,177.5 208.78,177.72 208.96,177.87 209.11,177.87 209.23,177.75 209.23,177.54 209.36,177.41 209.54,177.41 209.76,177.64 209.76,177.88 209.84,177.96 210.02,177.96 210.27,177.7 210.51,177.7 210.68,177.87 210.68,178.15 210.81,178.28 211.13,178.28 211.35,178.06 211.35,177.9 v1(211.62,177.63) ; v1(188.73,188.92) 188,189.66 187.44,189.81 186.17,189.81 185.38,190.6 185.02,190.88 184.47,191.07 182.36,191.07 v1(181.6,191.61) 181.55,191.56 179.72,191.56 179.07,192.21 179.07,192.38 178.76,192.69 177.04,192.69 176.72,192.38 176.72,191.54 176.01,190.83 v1(175.37,190.83)
  BOTTOM w0.114: v1(206.5,175.86) 206.41,175.78 206.41,174.04 206.79,173.66 206.79,173.33 206.41,172.94 206.41,172.47 206.07,172.13 U4.R2 ; U2.R2 176.76,187.45 176.72,187.7 176.65,188.36 176.56,188.59 175.83,189.6 175.63,190 v1(175.37,190.83) ; U3.R2 189.27,186.7 189.51,186.94 189.51,187.11 189.39,187.22 189.22,187.22 189.14,187.14 188.94,187.14 188.69,186.9 188.52,186.9 188.4,187.02 188.4,187.19 188.67,187.46 188.67,187.79 188.8,187.92 188.84,187.92 188.96,188.04 188.96,188.31 188.84,188.44 188.73,188.44 188.61,188.57 188.61,188.79 v1(188.73,188.92) ; v1(217.92,173.61) 217.92,173.83 218.04,173.96 218.22,173.96 218.48,173.7 218.71,173.7 218.83,173.57 218.83,173.3 218.68,173.15 218.45,173.15 218.33,173.02 218.33,172.36 218.2,172.23 217.61,172.23 217.49,172.11 217.49,171.94 217.61,171.82 U5.R2
  BOTTOM w0.127: R462.1 202.14,185.29 200.61,185.29 200.49,185.41 R461.2 198.89,185.8 v1(198.84,185.75) 200.75,183.84 200.75,175.02 198.99,173.26 198.25,173.26 193.28,168.29 191.3,168.29 190.99,167.98 190.99,167.48 U34.D26
FBA_CMD6: length 133.4
  TOP w0.102: v1(201.67,170.62) 201.18,170.62 201.05,170.75 200.88,170.75 200.75,170.62 200.75,170.46 200.87,170.34 200.87,169.98 201.08,169.78 201.6,169.78 201.71,169.89 201.71,170.11 201.6,170.22 U4.N8
  TOP w0.114: v1(215.55,172.36) 215.55,172.16 214.08,170.68 213.84,170.68 213.38,170.22 U5.N8 ; v1(185.59,185.69) 185.36,185.47 185.1,185.47 185.01,185.56 184.76,185.56 184.59,185.39 184.59,184.84 184.38,184.63 183.89,184.63 183.78,184.74 183.78,184.98 183.89,185.1 U3.N8 ; U2.N8 172.09,185.1 171.97,185.21 171.97,185.43 172.09,185.54 173.26,185.54 174.13,186.41 v1(174.13,186.6)
  TOP w0.127: v1(199.61,179.68) 199.61,180.6 R45.2 200.62,181.61 201.13,181.1 202.26,181.1 R46.1
  IN1 w0.127: v1(208.57,173.78) 208.46,173.66 206.6,173.66 205.19,175.07 205.19,175.63 205.01,175.82 204.83,175.82 204.42,175.41 204.17,175.41 204.03,175.56 204.03,175.74 204.47,176.18 204.47,176.36 204.19,176.63 202.99,176.63 202.99,176.63 202.62,176.63 202.5,176.75 202.18,176.75 201.94,176.51 201.72,176.29 201.72,176.11 202.45,175.38 202.45,175.2 202.24,174.99 202.01,174.99 201.51,175.48 201.26,175.48 200.88,175.87 200.88,176.2 201.42,176.74 201.42,176.97 201.24,177.15 201.07,177.15 200.42,176.5 200.24,176.5 200.06,176.69 200.06,176.86 200.74,177.54 200.74,177.72 200.56,177.9 200.38,177.9 199.69,177.21 199.54,177.21 199.12,177.62 199.12,177.92 199.45,178.25 200.01,178.25 200.29,178.53 200.29,178.99 v1(199.61,179.68) 198.62,180.01 198.42,180.09 197.25,180.9 196.44,181.72 195.98,182.54 195.68,183.07 190.97,187.78 188.14,187.78 187.74,188.18 186.35,188.18 185.67,188.03 182.69,187.49 181.22,187.49 180.6,187.39 v1(180.02,187.16)
  IN2 w0.127: v1(215.55,172.36) 215.11,172.36 214.87,172.12 214.47,172.12 211.62,174.96 210.15,174.96 209.69,174.5 209.3,174.5 v1(208.57,173.78) 208.46,173.66 205.94,173.66 205.15,172.87 204.26,172.87 203.97,172.59 203.02,172.59 202.19,171.76 202.19,170.85 201.97,170.62 v1(201.67,170.62) ; v1(174.13,186.6) 173.53,186.6 173.42,186.48 173.42,186.19 173.53,186.08 176.64,186.08 177.36,186.79 177.71,186.79 177.86,186.94 177.86,187.3 178.17,187.6 179.18,187.6 179.63,187.16 v1(180.02,187.16) 180.16,187.16 181.09,186.23 181.31,186.23 181.42,186.34 181.42,186.6 181.53,186.71 181.74,186.71 181.85,186.6 181.85,186.43 181.97,186.32 182.22,186.32 182.33,186.43 182.33,186.47 182.44,186.57 182.74,186.57 182.84,186.47 182.84,186.43 182.96,186.32 183.21,186.32 183.35,186.46 183.35,186.64 183.45,186.73 184.2,186.73 184.32,186.62 184.32,186.48 184.24,186.41 184.24,186.22 184.35,186.12 184.61,186.12 184.87,186.38 185.18,186.38 185.28,186.28 185.28,186.13 185.08,185.93 185.08,185.8 185.31,185.58 185.47,185.58 v1(185.59,185.69)
  BOTTOM w0.114: U3.N8 183.9,185.1 183.6,185.39 183.6,185.54 183.75,185.69 183.91,185.69 184.09,185.52 185.07,185.52 185.27,185.31 185.46,185.31 185.59,185.44 v1(185.59,185.69) ; U2.N8 172.07,185.1 171.96,185.21 171.96,185.45 172.07,185.56 173.28,185.56 174.13,186.41 v1(174.13,186.6) ; U4.N8 201.22,170.17 201.22,169.84 201.16,169.78 201.15,169.78 201.13,169.76 200.99,169.62 200.83,169.62 200.69,169.76 200.69,169.92 200.9,170.13 200.9,170.27 200.64,170.53 200.64,170.69 200.8,170.85 200.96,170.85 201.19,170.62 v1(201.67,170.62) ; v1(215.55,172.36) 215.55,172.16 214.08,170.68 213.92,170.68 213.46,170.22 U5.N8
  BOTTOM w0.127: v1(199.61,179.68) 200.09,179.19 200.09,175.61 199.45,174.98 198.59,174.98 198.36,174.75 198.36,174.32 193.03,168.98 191.12,168.98 189.33,167.2 189.33,166.72 U34.F25
FBA_CMD7: length 121.9
  TOP w0.114: U3.N7 185.6,185.1 185.66,185.16 186.55,185.16 186.73,185.33 186.73,185.6 186.55,185.77 v1(186.22,185.77) ; v1(174.83,186.52) 174.83,186.23 174.7,186.11 174.24,186.11 174.09,185.96 174.09,185.63 173.95,185.49 173.67,185.49 173.28,185.1 U2.N7 ; v1(215.99,171.9) 215.27,171.55 U5.N7 ; v1(203.01,171.38) 203.07,171.38 203.31,171.14 203.31,170.95 203.22,170.85 203.07,170.85 203.01,170.79 202.8,170.79 202.74,170.86 202.74,170.96 202.63,171.07 202.5,171.07 202.41,170.98 202.41,170.88 202.17,170.64 202.17,170.32 U4.N7
  TOP w0.127: v1(199.66,178.96) 200.11,179.42 200.11,179.71 R50.2 201.12,180.72 202.26,180.72 R51.1
  IN1 w0.127: v1(209.25,173.73) 209.54,173.44 209.54,173.15 209.4,173.01 208.9,173.01 208.58,173.33 208.46,173.33 207.05,173.33 206.84,173.12 206.67,173.12 206.3,173.49 206.13,173.49 205.75,173.12 205.6,173.12 205.39,173.33 205.4,173.48 205.77,173.85 205.77,174.03 205.59,174.21 205.41,174.21 204.75,173.55 204.56,173.55 204.25,173.86 204.25,174.06 204.38,174.19 204.66,174.19 205.05,174.57 205.05,174.75 204.72,175.08 203.7,175.08 203.57,175.21 203.57,175.64 203.44,175.76 203.19,175.76 203.06,175.64 203.06,175.19 202.93,175.07 202.78,175.07 202.37,174.66 202.22,174.66 202.1,174.53 202.1,174.37 202.31,174.15 202.31,173.97 202.07,173.73 201.89,173.73 201.55,174.07 201.55,174.98 201.38,175.15 201.12,175.15 198.72,177.56 198.72,178.5 198.9,178.69 199.38,178.69 v1(199.66,178.96) 198.32,179.69 197.3,180.39 196.17,181.52 195.35,182.93 190.84,187.45 188,187.45 187.6,187.85 186.55,187.85 183.49,187.08 182.98,186.57 182.62,186.57 181.56,186.92 v1(181.05,186.99)
  IN2 w0.127: v1(186.22,185.77) 186.22,185.86 186.03,186.05 185.81,186.05 185.63,186.24 185.63,186.45 185.29,186.79 185.15,186.79 185.07,186.71 184.85,186.71 184.76,186.8 184.76,186.97 184.86,187.08 184.86,187.21 184.73,187.35 184.56,187.35 184.44,187.23 184.44,187.18 184.33,187.07 184.18,187.07 184.06,187.18 184.06,187.33 183.95,187.45 183.76,187.45 183.63,187.32 183.63,187.19 183.5,187.07 183.32,187.07 183.2,187.19 183.2,187.34 183.07,187.46 182.21,187.46 182.08,187.34 182.08,187.17 181.95,187.04 181.7,187.04 181.57,187.17 181.57,187.34 181.44,187.46 181.18,187.46 181.05,187.33 v1(181.05,186.99) 180.8,186.99 180.56,187.23 180.56,187.32 180.34,187.54 180.26,187.54 180.1,187.7 179.92,187.7 179.82,187.6 179.65,187.6 179.32,187.93 178.01,187.93 177.85,187.78 177.53,187.78 177.41,187.65 177.41,187.55 177.51,187.45 177.51,187.24 177.38,187.12 177.22,187.12 176.74,186.64 176.54,186.64 176.47,186.71 176.34,186.71 176.21,186.58 176.21,186.53 176.09,186.41 175.86,186.41 175.73,186.53 175.73,186.61 175.6,186.74 175.43,186.74 175.3,186.61 175.3,186.53 175.17,186.41 174.95,186.41 v1(174.83,186.52) ; v1(215.99,171.9) 215.12,171.9 215.01,171.79 214.33,171.79 211.8,174.32 210.99,174.63 210.29,174.63 209.83,174.17 209.7,174.17 v1(209.25,173.73) 209.25,173.58 209,173.33 208.39,173.33 206.08,173.33 205.29,172.54 204.39,172.54 204.11,172.26 203.16,172.26 202.6,171.7 202.6,171.48 202.73,171.35 202.98,171.35 v1(203.01,171.38)
  BOTTOM w0.114: v1(203.01,171.38) 203.08,171.38 203.26,171.2 203.26,170.99 203.13,170.85 203.07,170.85 202.98,170.76 202.86,170.76 202.74,170.88 202.74,171 202.64,171.1 202.5,171.1 202.41,171 202.41,170.88 202.08,170.56 202.08,170.23 U4.N7 ; U3.N7 185.15,184.96 185.85,184.96 185.97,185.07 185.97,185.17 186.08,185.29 186.5,185.29 186.65,185.44 186.65,185.62 186.45,185.83 186.27,185.83 v1(186.22,185.77) ; v1(215.99,171.9) 215.21,171.49 U5.N7 ; v1(174.83,186.52) 174.93,186.42 174.93,186.24 174.75,186.06 174.57,186.06 174.49,186.15 174.2,186.15 U2.N7
  BOTTOM w0.127: v1(199.66,178.96) 199.76,178.86 199.76,175.75 199.32,175.31 198.45,175.31 198.03,174.88 198.03,174.45 192.89,169.31 191.12,169.31 U34.F26
FBA_CMD8: length 160.5
  TOP w0.114: U3.T8 184.21,188.89 186.02,190.7 186.02,191.99 186.3,192.28 186.77,192.28 v1(187.16,191.89) ; v1(202.81,177.07) 202.96,176.92 202.96,176.76 202.84,176.65 202.08,176.65 201.73,176.3 201.73,172.31 201.62,172.19 201.38,172.19 201.28,172.29 201.28,172.61 U4.T8 ; v1(215.7,176.65) 215.19,176.14 214.33,176.14 213.8,175.61 213.8,175.51 213.69,175.39 213.41,175.39 213.29,175.28 213.29,175 213.41,174.88 213.5,174.88 213.63,174.76 213.63,174.53 213.5,174.4 213.42,174.4 213.14,174.12 U5.T8 ; U2.T8 172.05,187.79 172.05,189.33 172.68,189.96 172.68,190.95 173.34,191.61 173.44,191.61 173.6,191.77 173.6,192.03 173.48,192.15 173.38,192.15 173.27,192.26 173.27,192.5 173.38,192.62 v1(173.86,192.62)
  IN1 w0.127: v1(210.57,180.26) 210.57,180.91 208.78,182.7 208.78,182.96 208.89,183.07 208.89,183.25 208.71,183.43 208.53,183.43 208.38,183.28 208.2,183.28 208.02,183.46 208.02,183.64 208.17,183.79 208.17,183.97 207.99,184.15 207.81,184.15 207.66,184 207.48,184 207.3,184.18 207.3,184.36 207.45,184.51 207.45,184.69 207.27,184.87 207.09,184.87 206.94,184.72 206.76,184.72 205.84,185.64 204.15,185.64 201.52,188.27 200.34,188.27 198.56,190.04 v1(198.26,190.04) 195.98,191.69 195.08,192.32 192.39,193.16 190.33,193.16 188.84,194.66 182.49,194.66 v1(181.14,194.41)
  IN2 w0.102: v1(189.36,165.11) 189.76,165.52 189.76,167.7 189.85,167.79 189.85,167.94
  IN2 w0.127: v1(173.86,192.62) 173.93,192.68 174.54,192.68 174.77,192.92 174.77,193.1 174.57,193.3 174.57,193.48 174.75,193.66 174.93,193.66 175.13,193.45 175.31,193.45 175.48,193.62 175.48,194.13 175.76,194.41 v1(181.14,194.41) 184.65,194.41 185.2,193.85 186.04,193.85 186.22,193.67 186.22,192.83 186.35,192.71 186.63,192.71 186.75,192.83 186.75,193.11 186.88,193.24 187.16,193.24 187.29,193.11 187.29,192.02 v1(187.16,191.89) ; v1(215.7,176.65) 215.7,176.81 215.53,176.98 215.21,176.98 214.97,177.22 214.97,177.54 214.75,177.77 214.42,177.77 214.26,177.93 214.26,178.25 214.03,178.49 213.71,178.49 213.55,178.64 213.55,178.96 213.24,179.27 212.92,179.27 212.76,179.43 212.76,179.62 212.64,179.75 212.36,179.75 212.26,179.65 212,179.65 211.87,179.78 211.87,180.11 211.75,180.23 211.54,180.23 211.42,180.11 211.42,179.75 211.29,179.62 211.06,179.62 210.93,179.75 210.93,180.13 210.81,180.26 v1(210.57,180.26) 210.53,180.29 210.05,180.29 209.92,180.29 209.59,180.29 208.92,180.18 208.56,180.08 207.11,179.39 204.95,177.85 203.84,176.81 203.66,176.63 203.26,176.63 v1(202.81,177.07)
  IN2 w0.165: 189.85,167.94 189.85,168.48 189.94,168.57 190.16,168.79 190.46,169.1 191.16,169.79 192.31,170.94 192.8,170.94 195.95,174.09 196.96,174.09 197.38,174.5 197.39,174.5 197.66,174.78 197.66,174.78 198.32,175.45 198.32,176.22 199.05,176.95 199.05,181.43 199.31,181.69 199.31,189.01 198.28,190.04 v1(198.26,190.04)
  BOTTOM w0.114: U29.T8 189.19,187.68 189.19,189.48 188.31,190.36 188.31,191.17 188.07,191.41 187.86,191.41 187.74,191.52 187.74,191.7 187.86,191.82 187.91,191.82 188.02,191.93 188.02,192.13 187.91,192.25 187.52,192.25 v1(187.16,191.89) ; U31.T8 205.85,172.84 205.48,173.99 205.48,175.11 205.11,175.79 204.61,176.5 204.5,176.63 203.64,177.49 203.37,177.49 203.26,177.46 203.12,177.38 v1(202.81,177.07) ; U32.T8 217.48,173.08 217.48,174.16 217.6,174.29 218.02,174.29 218.15,174.42 218.15,174.67 218.02,174.8 217.6,174.8 217.48,174.93 217.48,175.11 215.93,176.65 v1(215.7,176.65) ; U28.T8 177.14,188.56 176.88,188.82 176.88,189.09 175.98,189.99 175.98,190.8 174.17,192.62 v1(173.86,192.62) ; U34.F23 189.32,165.11 v1(189.36,165.11)
  BOTTOM w0.127: R446.1 201.12,190.24 199.99,190.24 199.48,190.75 R445.2 198.84,190.75 198.26,190.17 v1(198.26,190.04)
FBA_CMD9: length 128.2
  TOP w0.114: U2.N3 175.28,186.16 175.28,186.65 175,186.94 174.6,186.94 v1(174.33,187.21) ; U5.N3 216.99,170.22 216.54,170.67 215.9,170.67 215.68,170.45 215.31,170.45 215.2,170.57 215.2,171.05 215.31,171.16 v1(215.61,171.16) ; v1(188.62,185.51) 188.12,185.51 187.87,185.76 187.87,185.91 187.61,186.17 187.46,186.17 187.35,186.06 187.35,185.91 187.4,185.86 187.64,185.62 187.64,185.39 187.86,185.17 188.13,185.17 U3.N3 ; v1(203.64,171.4) 203.57,171.33 203.57,170.7 203.69,170.58 203.93,170.58 204.05,170.69 204.05,170.83 204.16,170.95 204.37,170.95 204.48,170.83 204.48,170.69 204.6,170.58 204.74,170.58 204.85,170.47 205.16,170.47 205.27,170.36 U4.N3
  TOP w0.127: v1(198.34,180.72) 200.29,182.67 R41.2 201.07,183.13 202.31,183.13 R42.1
  IN1 w0.127: v1(181.22,187.93) 181.65,187.82 182,187.82 184.73,188.25 186.03,188.51 187.87,188.51 188.27,188.11 191.09,188.11 191.19,188.03 196.01,183.21 196.8,181.82 197.4,181.22 v1(198.34,180.72) 198.69,180.37 199.1,180.37 199.22,180.5 199.22,180.69 199.35,180.82 199.65,180.82 200.05,180.41 200.05,179.71 200.86,178.9 200.86,178.72 200.66,178.52 200.66,178.34 200.84,178.16 201.02,178.16 201.29,178.42 201.47,178.42 201.69,178.2 201.69,178.02 201.38,177.72 201.38,177.54 201.84,177.09 202.02,177.09 202.22,177.29 202.22,177.69 202.35,177.82 202.6,177.82 202.73,177.69 202.73,177.64 202.86,177.52 203.24,177.52 203.37,177.64 203.37,177.72 203.49,177.85 203.91,177.85 204.04,177.72 204.04,177.47 203.95,177.38 203.95,177.21 204.14,177.02 204.62,177.02 204.81,176.84 204.81,176.49 204.99,176.3 205.34,176.3 205.52,176.12 205.52,175.77 205.71,175.58 206.06,175.58 206.31,175.33 206.31,175.15 206.03,174.88 206.03,174.7 206.21,174.52 206.39,174.52 206.67,174.79 206.89,174.79 207.02,174.66 207.02,174.24 207.15,174.11 207.73,174.11 207.86,174.24 209.56,174.24 209.93,173.88 v1(209.93,173.71)
  IN2 w0.102: 188.94,167.66 188.94,164.69 v1(188.53,164.28)
  IN2 w0.127: v1(203.64,171.4) 203.57,171.4 203.44,171.53 203.44,171.8 203.57,171.92 203.9,171.92 203.96,171.86 204.3,171.86 204.42,171.98 204.42,172.1 204.53,172.21 204.73,172.21 204.81,172.13 204.81,172.05 204.94,171.92 205.14,171.92 205.86,172.65 206.06,172.65 206.18,172.78 206.18,172.87 206.31,173 208.25,173 209.15,173 209.34,173.19 209.68,173.19 209.92,173.43 209.92,173.7 v1(209.93,173.71) 210.18,173.96 210.18,174.01 210.45,174.27 210.91,174.27 211.03,174.15 211.03,173.92 211.14,173.82 211.26,173.82 211.46,174.01 211.64,174.01 214.19,171.46 214.44,171.46 214.56,171.33 214.56,171.22 214.69,171.09 214.95,171.09 215.07,171.22 215.07,171.38 215.26,171.57 215.61,171.57 215.73,171.44 215.73,171.29 v1(215.61,171.16) ; v1(188.62,185.51) 187.93,186.2 186.34,186.2 184.75,187.79 181.4,187.79 181.26,187.93 v1(181.22,187.93) 181.14,187.93 180.84,187.63 180.72,187.63 180.48,187.87 180.4,187.87 180.21,188.06 179.76,188.06 179.56,188.26 177.87,188.26 177.72,188.11 177.53,188.11 177.38,188.26 177.2,188.26 177.05,188.11 177.05,187.72 177.05,187.44 176.73,187.12 175.89,187.12 175.84,187.07 175.23,187.07 175.16,187 174.54,187 v1(174.33,187.21)
  IN2 w0.165: 188.94,167.66 189.12,167.84 189.12,169.15 194.36,174.4 194.36,176.56 194.77,176.97 196.9,176.97 198.23,178.31 198.23,180.62 v1(198.34,180.72)
  BOTTOM w0.102: v1(188.53,164.28) 188.13,163.89 U34.G22
  BOTTOM w0.114: v1(203.64,171.4) 203.69,171.35 203.69,170.58 203.81,170.46 204.06,170.46 204.18,170.58 204.18,170.81 204.29,170.92 204.47,170.92 204.58,170.81 204.58,170.63 204.7,170.52 204.79,170.52 205.09,170.22 U4.N3 ; U2.N3 175.27,186.16 175.27,186.66 175,186.94 174.6,186.94 v1(174.33,187.21) ; v1(215.61,171.16) 215.53,171.08 215.53,170.79 215.64,170.67 216.56,170.67 216.68,170.55 216.68,169.89 216.79,169.78 217.03,169.78 217.14,169.89 U5.N3 ; U3.N3 188.47,185.1 188.58,184.98 188.58,184.75 188.47,184.63 188.14,184.63 187.84,184.94 187.76,184.94 187.64,185.05 187.64,185.39 187.76,185.51 v1(188.62,185.51)
FBA_CMD10: length 139.3
  TOP w0.114: v1(186.73,187.37) 186.65,187.29 186.65,187.04 186.52,186.91 186,186.91 185.86,186.78 185.86,186.55 185.99,186.42 186.7,186.42 186.92,186.2 187.11,186.2 187.33,186.42 187.68,186.42 187.97,186.13 188.04,186.13 188.21,185.97 U3.P3 ; U5.P3 216.89,171.02 216.71,171.2 216.71,171.47 216.59,171.59 216.59,171.6 216.47,171.71 216.47,171.85 216.59,171.97 216.59,172.09 216.36,172.31 216.09,172.31 215.96,172.44 215.96,172.91 v1(215.8,173.08) ; U2.P3 176.34,186 176.21,186.13 175.94,186.13 175.74,186.33 175.74,187.01 175.57,187.18 175.57,187.43 174.93,188.07 v1(174.78,188.07) ; U4.P3 204.72,171.57 204.64,171.81 204.24,173.09 204.14,173.33 203.87,173.75 v1(203,174.61)
  TOP w0.127: R23.1 202.15,187.7 201.64,188.21 201.12,188.21 R22.2 199.51,186.6 199.08,186.6 198.01,185.52 198.01,183.99 v1(197.65,183.64)
  IN1 w0.127: v1(180.71,189.48) 181.18,189.95 182.76,189.95 182.89,189.82 183.85,189.82 185.59,190.44 188.4,190.44 188.78,190.06 191.2,190.06 194.03,187.23 194.79,187.23 197.13,184.89 197.13,184.16 v1(197.65,183.64) 198.34,182.95 198.47,182.95 199.04,182.38 199.95,182.38 201.46,180.87 201.46,180.51 201.59,180.39 201.87,180.39 201.99,180.51 201.99,180.62 202.12,180.74 202.4,180.74 202.53,180.62 202.53,180.26 202.65,180.13 202.96,180.13 203.13,180.3 203.33,180.3 203.56,180.07 203.56,179.89 203.32,179.65 203.32,179.47 203.5,179.29 203.68,179.29 203.92,179.53 204.23,179.53 204.36,179.4 204.36,179.28 205.33,178.3 205.88,178.3 206.06,178.13 206.06,177.57 206.19,177.44 206.44,177.44 206.57,177.57 206.57,178.17 206.69,178.3 207,178.3 207.1,178.2 207.1,177.93 207.26,177.77 207.26,177.53 207.14,177.42 207.14,177.26 207.35,177.06 207.5,177.06 207.78,177.34 207.96,177.34 208.16,177.14 208.16,176.96 207.92,176.72 207.92,176.54 208.01,176.45 208.39,176.45 208.7,176.75 209.78,176.75 v1(210.11,176.42) 210.43,176.42 210.86,175.99 210.86,175.72 211.18,175.4 211.85,175.4 211.98,175.53 211.98,176.3 212.1,176.42 212.35,176.42 212.48,176.29 212.48,175.53 212.61,175.4 213.48,175.4 214.79,174.09 215.68,174.09 215.94,173.83 215.94,173.23 v1(215.8,173.08)
  IN2 w0.127: v1(210.11,176.42) 209.62,175.84 209.28,175.49 208.89,175.49 208.14,174.91 207.48,174.66 205.53,174.66 204.74,173.86 203.75,173.86 v1(203,174.61) ; v1(174.78,188.07) 174.78,188.23 174.97,188.41 175.27,188.41 175.38,188.52 175.38,188.58 175.54,188.74 175.79,188.74 175.96,188.58 175.96,188.3 176.07,188.18 176.28,188.18 176.39,188.3 176.39,188.87 176.59,189.07 176.59,189.44 176.71,189.56 176.96,189.56 177.08,189.44 177.08,189.04 177.19,188.92 177.5,188.92 177.61,189.04 177.61,189.18 177.72,189.29 178,189.29 178.12,189.18 178.12,189.04 178.23,188.92 178.49,188.92 178.6,189.04 178.6,189.18 178.71,189.29 178.94,189.29 179.06,189.18 179.06,189.04 179.17,188.92 179.35,188.92 179.46,189.04 179.46,189.22 179.59,189.35 180.58,189.35 v1(180.71,189.48) 180.82,189.48 181.24,189.06 182.14,189.06 182.42,188.78 185.16,188.78 186.17,187.78 186.4,187.78 186.84,188.22 187.1,188.22 187.24,188.08 187.24,187.87 187.21,187.85 187.2,187.85 186.94,187.59 186.94,187.58 v1(186.73,187.37)
  IN2 w0.165: v1(197.65,183.64) 198.11,183.17 198.11,181.43 197.36,180.68 197.36,179 197.12,178.76 197.12,177.75 196.71,177.34 194.51,177.34 193.99,176.82 193.99,174.55 188.75,169.31 188.75,167.99 188.53,167.78 188.53,167.78 v1(188.53,165.12)
  BOTTOM w0.114: v1(215.8,173.08) 215.8,172.73 215.99,172.53 215.99,172.41 216.09,172.31 216.36,172.31 216.59,172.09 216.59,171.94 216.47,171.83 216.47,171.71 216.59,171.59 216.59,171.59 216.69,171.49 216.69,171.22 216.89,171.02 U5.P3 ; v1(203,174.61) 203.84,173.74 203.89,173.66 204,173.37 204.02,173.2 204.19,172.5 204.33,172.16 204.72,171.62 204.72,171.57 U4.P3 ; U2.P3 176.34,186 176.21,186.13 175.94,186.13 175.7,186.36 175.7,187.03 175.39,187.35 175.39,187.61 174.93,188.07 v1(174.78,188.07) ; U34.G23 v1(188.53,165.12) ; v1(186.73,187.37) 186.83,187.37 186.96,187.25 186.96,186.99 186.83,186.86 186.14,186.86 186.02,186.74 186.02,186.53 186.14,186.41 186.68,186.41 186.79,186.29 186.79,186.14 187.03,185.9 187.21,185.9 U3.P3

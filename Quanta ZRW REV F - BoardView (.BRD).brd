# Allegro board Quanta ZRW REV F - BoardView (.BRD).brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
M_A_CKE1: length 68
  IN1 w0.216: v1(124.71,48.41) 124.71,47.91 124.55,47.75 124.02,47.75 123.79,47.98 123.79,49.28 123.6,49.47 123.3,49.47 123.09,49.26 122.66,49.26 122.48,49.44 122.48,49.87 122.69,50.08 122.69,50.38 122.31,50.76 122.31,54.31 121.78,54.84 121.78,71.71 120.65,72.84 120.65,98.6 v1(123.31,101.26)
  BOTTOM w0.076: 123.16,104.66 124.89,106.4 U35.BB56
  BOTTOM w0.102: 123.16,104.66 123.16,101.41 v1(123.31,101.26)
  BOTTOM w0.165: v1(124.71,48.41) 125.03,48.41 125.54,47.9 JDIM2.74
M_A_CLK0: length 69.7
  IN1 w0.127: v2(126.26,111.74) 126.23,111.74 125.77,111.27 125.77,109.77 126.2,109.34 126.78,109.34 129.91,106.22 129.91,82.9 131.36,81.45 131.36,76.45 133.52,74.29 133.52,73.7 133.39,73.58 133.02,73.58 132.74,73.3 132.74,72.71 133.02,72.43 133.39,72.43 133.52,72.31 133.52,71.92 133.39,71.8 133.04,71.8 132.77,71.52 132.77,70.93 133.04,70.65 133.39,70.65 133.52,70.53 133.52,70.15 133.39,70.02 133.04,70.02 132.77,69.74 132.77,69.15 133.04,68.88 133.39,68.88 133.52,68.75 133.52,60.77 133.63,60.66 133.63,55.96 134,55.59 134,52.74 v1(133.86,52.6)
  BOTTOM w0.114: v1(133.86,52.6) 134,52.75 134,53.79 133.64,54.15 JDIM2.101 ; U35.AT53 v2(126.26,111.74)
M_A_CLK0#: length 69.8
  IN1 w0.127: v1(134.72,52.37) 134.7,52.37 134.25,52.82 134.25,55.7 133.88,56.07 133.88,60.77 133.77,60.88 133.77,68.86 133.49,69.13 133.15,69.13 133.02,69.26 133.02,69.64 133.15,69.77 133.49,69.77 133.77,70.04 133.77,70.63 133.49,70.91 133.15,70.91 133.02,71.04 133.02,71.42 133.15,71.54 133.49,71.54 133.77,71.82 133.77,72.41 133.49,72.69 133.12,72.69 132.99,72.81 132.99,73.19 133.12,73.32 133.49,73.32 133.77,73.6 133.77,74.39 131.61,76.55 131.61,81.56 130.16,83 130.16,106.27 126.87,109.56 126.29,109.56 125.98,109.86 125.98,110.85 v1(126.25,111.11)
  BOTTOM w0.114: v1(126.25,111.11) 126.63,111.11 126.72,111.21 U35.AU53 ; JDIM2.103 134.24,52.82 134.7,52.37 v1(134.72,52.37)
M_A_CLK1: length 69.7
  IN1 w0.127: v5(125.31,111.76) 124.85,111.3 124.85,109.65 127.83,106.68 128.23,106.68 129.12,105.79 129.12,82.57 130.57,81.12 130.57,76.12 131.74,74.95 131.74,72.39 131.98,72.15 131.98,68.25 132.73,67.5 132.73,60.59 132.49,60.35 132.49,54.42 132.86,54.05 132.86,52.16 133.93,51.09 v1(133.93,49.81)
  BOTTOM w0.114: v1(133.93,49.81) 133.93,48.4 133.94,48.38 JDIM2.102 ; v5(125.31,111.76) 125.48,111.76 U35.AT55
M_A_CLK1#: length 69.8
  IN1 w0.127: v1(125.31,111.1) 125.07,110.86 125.07,109.74 127.92,106.89 128.32,106.89 129.37,105.84 129.37,82.67 130.82,81.23 130.82,76.22 131.99,75.05 131.99,72.5 132.23,72.26 132.23,68.36 132.98,67.61 132.98,60.48 132.74,60.24 132.74,54.53 133.11,54.16 133.11,52.27 134.18,51.19 134.18,50.2 134.61,49.78 v1(134.66,49.78)
  BOTTOM w0.114: v1(134.66,49.78) 134.58,49.78 134.17,49.37 134.17,48.67 134.54,48.29 JDIM2.104 ; v1(125.31,111.1) 125.36,111.05 125.67,111.05 125.8,111.18 U35.AU55
M_A_CS#0: length 72.1
  IN1 w0.076: v2(131.77,111.78) 131.33,111.33 131.33,110.82 134.42,107.73 134.42,106.51 133.97,106.07 133.97,97.96 134.46,97.47 134.46,97.02
  IN1 w0.216: 134.46,97.02 134.46,84.7 139.6,79.56 139.6,76.72 139.74,76.58 139.74,69.46 139.59,69.31 139.59,68.14 140.13,67.6 140.13,64.39 139.26,63.51 139.26,61.76 140.3,60.72 140.3,58.29 139.8,57.79 139.8,56.58 140.35,56.03 140.35,54.84 140.09,54.58 140.09,53.09 138.63,51.63 v1(138.63,50.37)
  BOTTOM w0.165: v1(138.63,50.37) 138.47,50.37 137.54,49.44 JDIM2.114 ; v2(131.77,111.78) U35.AU45
M_A_CS#1: length 74.5
  IN1 w0.076: v2(131.77,111.13) 134.58,108.31 134.58,106.3 134.15,105.86 134.15,98.01 134.93,97.23 134.93,97.02
  IN1 w0.216: v1(141.05,53.06) 140.78,53.06 140.56,53.27 140.56,54.35 140.84,54.63 140.84,69.59 140.32,70.12 140.32,76.7 140.07,76.95 140.07,79.76 134.93,84.89 134.93,97.02
  BOTTOM w0.165: v1(141.05,53.06) 141.69,52.41 141.69,51.35 141.52,51.18 141.13,51.18 140.96,51.34 140.96,52.15 140.8,52.32 140.47,52.32 140.3,52.15 140.3,50.83 140.14,50.67 139.89,50.67 139.66,50.9 139.66,52.45 140.17,52.95 140.17,53.59 139.64,54.11 JDIM2.121 ; v2(131.77,111.13) U35.AU43
M_A_DQ0: length 88.8
  IN1 w0.127: v1(112.06,115.85) 111.76,115.85 111.37,116.25 109.73,116.25 109.28,115.79 107.29,115.79 101.57,110.07 101.57,109.59 97.96,105.97 97.96,72.56 97.88,72.48 97.73,72.48 97.6,72.36 97.6,72.1 97.73,71.97 97.88,71.97 98.01,71.85 98.01,71.59 97.88,71.47 97.46,71.47 97.33,71.34 97.33,71.09 97.46,70.96 97.88,70.96 98.01,70.83 98.01,70.58 97.88,70.45 97.46,70.45 97.33,70.32 97.33,70.07 97.46,69.94 97.88,69.94 98.01,69.82 98.01,69.56 97.88,69.43 97.46,69.43 97.33,69.31 97.33,69.05 97.46,68.93 98.01,68.93 98.13,68.8 98.13,68.55 98.01,68.42 97.46,68.42 97.33,68.29 97.33,68.04 97.46,67.91 98.01,67.91 98.13,67.78 98.13,67.53 98.01,67.4 97.46,67.4 97.33,67.28 97.33,67.02 97.46,66.89 98.01,66.89 98.13,66.77 98.13,66.51 98.01,66.39 97.46,66.39 97.33,66.26 97.33,60.31 97.5,60.14 98.95,60.14 99.15,59.94 99.15,55.6 v1(101.82,52.93)
  BOTTOM w0.076: 113.88,115.31 114.13,115.31 114.33,115.11 115.89,115.11 115.92,115.14 U35.AL71
  BOTTOM w0.114: v1(112.06,115.85) 112.6,115.31 113.88,115.31 ; v1(101.82,52.93) 102.17,52.93 102.44,53.21 JDIM2.5
M_A_DQ1: length 89.8
  IN1 w0.127: v1(101.82,50.19) 101.18,50.82 101.18,51.77 98.18,54.78 98.18,58.04 96.67,59.55 96.67,76.7 97.05,77.08 97.05,101.1 97.29,101.34 97.29,106.24 100.91,109.86 100.91,110.34 107.04,116.47 108.78,116.47 109.22,116.91 112.17,116.91 112.48,116.6 112.93,116.6 v1(113.56,115.97)
  BOTTOM w0.076: U35.AL68 118.45,115.46 118.45,116.01 118.28,116.19 117.13,116.19 117.03,116.1 116.46,116.1 116.31,116.03 115.46,116.03 115.19,116.3 114.59,116.3 114.52,116.38 113.96,116.38 113.56,115.98 v1(113.56,115.97)
  BOTTOM w0.114: v1(101.82,50.19) 101.82,50.16 101.38,49.73 101.38,48.69 102.14,47.93 JDIM2.4
M_A_DQ2: length 90.7
  IN1 w0.127: v1(105.75,52.29) 105.03,52.29 104.63,52.69 104.63,52.98 104.99,53.35 104.99,53.55 101.58,56.96 101.58,81.21 101.46,81.33 100.77,81.33 100.65,81.46 100.65,81.71 100.77,81.84 101.46,81.84 101.58,81.97 101.58,82.22 101.46,82.35 100.77,82.35 100.64,82.48 100.64,82.73 100.77,82.86 101.46,82.86 101.58,82.98 101.58,83.24 101.46,83.37 100.77,83.37 100.64,83.49 100.64,83.75 100.77,83.87 101.46,83.87 101.58,84 101.58,84.25 101.46,84.38 100.77,84.38 100.64,84.51 100.64,84.76 100.77,84.89 101.46,84.89 101.58,85.02 101.58,85.27 101.46,85.4 100.77,85.4 100.64,85.52 100.64,105.59 103.85,108.79 103.85,109.16 108.25,113.56 111.38,113.56 v1(112.11,114.3)
  BOTTOM w0.076: U35.AN68 117.92,113.91 117.63,113.62 117.07,113.62 116.85,113.4 115.86,113.4 115.86,113.4 114.21,113.4 113.98,113.63
  BOTTOM w0.114: v1(105.75,52.29) 106.91,51.14 106.91,48.52 106.34,47.96 JDIM2.18 ; 113.98,113.63 112.78,113.63 v1(112.11,114.3)
M_A_DQ3: length 89.3
  IN1 w0.127: v1(114.76,114.3) 113.8,115.26 111.79,115.26 110.75,114.23 107.87,114.23 103.19,109.55 103.19,109.06 99.93,105.81 99.93,79.28 100.06,79.16 100.5,79.16 100.62,79.03 100.62,78.78 100.5,78.65 100.06,78.65 99.93,78.52 99.93,78.27 100.06,78.14 100.5,78.14 100.62,78.01 100.62,77.76 100.5,77.63 100.06,77.63 99.93,77.51 99.93,77.25 100.06,77.12 100.52,77.12 100.65,77 100.65,76.74 100.52,76.62 100.06,76.62 99.93,76.49 99.93,76.24 100.06,76.11 100.52,76.11 100.65,75.98 100.65,75.73 100.52,75.6 100.06,75.6 99.93,75.47 99.93,75.22 100.22,74.94 100.22,71.51 99.93,71.22 99.93,67.07 100.91,66.09 100.91,56.64 103.78,53.76 103.78,52.11 105.12,50.77 105.12,48.38 105.24,48.26 105.75,48.26 105.88,48.38 v1(105.88,48.51)
  BOTTOM w0.076: U35.AN69 117.18,113.91 116.95,114.14 116.54,114.14 116.32,114.25 115.91,114.25 115.58,113.92 115.14,113.92 v1(114.76,114.3)
  BOTTOM w0.114: JDIM2.16 105.74,48.37 v1(105.88,48.51)
M_A_DQ4: length 89.6
  IN1 w0.127: v1(101.82,51.56) 101.82,51.63 100.98,52.47 100.98,53.16 98.64,55.49 98.64,59.43 98.46,59.61 97.93,59.61 97.73,59.41 97.28,59.41 97,59.69 97,72.89 97.13,73.01 97.5,73.01 97.62,73.14 97.62,73.4 97.5,73.52 97.13,73.52 97,73.65 97,73.9 97.13,74.03 97.5,74.03 97.62,74.16 97.62,74.41 97.5,74.54 97.13,74.54 97,74.67 97,74.92 97.13,75.05 97.5,75.05 97.62,75.17 97.62,75.43 97.5,75.55 97.13,75.55 97,75.68 97,75.94 97.13,76.06 97.5,76.06 97.62,76.19 97.62,106.11 101.24,109.73 101.24,110.21 107.18,116.14 108.92,116.14 109.35,116.58 111.96,116.58 112.61,115.93 v1(112.8,115.93)
  BOTTOM w0.076: 114.39,115.44 114.54,115.29 115.73,115.29 115.79,115.34 115.93,115.34 116.09,115.41 116.27,115.41 116.39,115.36 116.61,115.36 U35.AL70
  BOTTOM w0.114: JDIM2.7 103.04,54.17 102.83,53.96 102.83,52.57 v1(101.82,51.56) ; 114.39,115.44 114.31,115.52 113.2,115.52 v1(112.8,115.93)
M_A_DQ5: length 89.9
  IN1 w0.127: v1(114.22,115.95) 113.24,116.93 112.62,116.93 112.31,117.24 108.82,117.24 108.42,116.84 106.94,116.84 100.58,110.48 100.58,110 96.96,106.38 96.96,101.48 96.34,100.85 96.34,57.77 96.47,57.64 97.07,57.64 97.19,57.51 97.19,57.26 97.07,57.13 96.47,57.13 96.34,57.01 96.34,56.15 100.79,51.7 100.79,49.96 v1(101.86,48.89)
  BOTTOM w0.076: U35.AL69 117.25,115.37 117.09,115.37 116.93,115.53 116.41,115.53 116.31,115.58 116.06,115.58 115.89,115.51 115.45,115.51 115.4,115.47 114.7,115.47 v1(114.22,115.95)
  BOTTOM w0.114: v1(101.86,48.89) 102.74,48 JDIM2.6
M_A_DQ6: length 88.9
  IN1 w0.127: v1(105.88,50.03) 105.88,50.72 106.3,51.14 106.3,51.32 106.12,51.5 105.94,51.5 105.52,51.08 105.34,51.08 104.11,52.31 104.11,53.96 101.24,56.83 101.24,66.23 100.26,67.21 100.26,71.09 101.18,72 101.18,79.48 100.98,79.68 100.39,79.68 100.26,79.81 100.26,80.06 100.39,80.19 101.05,80.19 101.18,80.31 101.18,80.57 101.05,80.7 100.39,80.7 100.26,80.82 100.26,105.67 103.52,108.93 103.52,109.3 108.12,113.9 110.89,113.9 111.9,114.91 113.52,114.91 v1(114.12,114.3)
  BOTTOM w0.076: v1(114.12,114.3) 114.7,113.73 115.63,113.73 115.98,114.08 116.28,114.08 116.53,113.97 116.68,113.97 U35.AN70
  BOTTOM w0.114: JDIM2.15 105.44,54.04 105.24,53.84 105.24,50.67 v1(105.88,50.03)
M_A_DQ7: length 87.4
  IN1 w0.127: v1(105.75,53.59) 105.42,53.59 101.91,57.09 101.91,85.73 101.79,85.85 101.1,85.85 100.97,85.98 100.97,86.24 101.1,86.36 101.89,86.36 102.01,86.49 102.01,86.74 101.89,86.87 101.1,86.87 100.97,87 100.97,87.25 101.1,87.38 101.89,87.38 102.01,87.51 102.01,87.76 101.89,87.89 101.1,87.89 100.97,88.01 100.97,88.27 101.1,88.39 101.89,88.39 102.01,88.52 102.01,88.78 101.89,88.9 101.1,88.9 100.97,89.03 100.97,89.28 101.1,89.41 101.89,89.41 102.01,89.54 102.01,89.79 101.89,89.92 101.1,89.92 100.97,90.05 100.97,90.3 101.1,90.43 101.89,90.43 102.01,90.55 102.01,90.81 101.89,90.93 101.1,90.93 100.97,91.06 100.97,91.32 101.1,91.44 101.89,91.44 102.01,91.57 102.01,91.82 101.89,91.95 101.1,91.95 100.97,92.08 100.97,92.33 101.1,92.46 101.79,92.46 101.98,92.65 101.98,92.85 101.32,93.51 101.32,105.79 104.18,108.65 104.18,109.02 108.39,113.23 111.71,113.23 v1(112.77,114.3)
  BOTTOM w0.076: 114.23,113.76 114.43,113.56 115.71,113.56 115.96,113.81 U35.AN71
  BOTTOM w0.114: v1(105.75,53.59) 105.75,53.84 106.04,54.14 JDIM2.17 ; 114.23,113.76 114.11,113.88 113.2,113.88 v1(112.77,114.3)
M_A_DQ8: length 80.2
  IN1 w0.127: v1(107.53,52.24) 107.06,52.71 107.06,53.84 103.58,57.32 103.58,66.79 103.44,66.93 103.44,78.88 103.56,79.01 103.86,79.01 103.99,79.13 103.99,79.39 103.86,79.51 103.56,79.51 103.44,79.64 103.44,79.9 103.56,80.02 103.86,80.02 103.99,80.15 103.99,80.4 103.86,80.53 103.56,80.53 103.44,80.66 103.44,80.91 103.56,81.04 103.86,81.04 103.99,81.17 103.99,81.42 103.86,81.55 103.56,81.55 103.44,81.67 103.44,81.93 103.56,82.05 103.86,82.05 103.99,82.18 103.99,82.44 103.86,82.56 103.56,82.56 103.44,82.69 103.44,82.94 103.56,83.07 103.86,83.07 103.99,83.2 103.99,83.45 103.86,83.58 103.56,83.58 103.44,83.71 103.44,83.96 103.72,84.24 103.72,93.05 102.61,94.15 102.61,105.26 105.6,108.25 105.6,108.3 109,111.7 110.9,111.7 v1(111.36,112.16)
  BOTTOM w0.076: U35.AR70 116.56,113.06 113.63,113.06
  BOTTOM w0.114: JDIM2.23 107.84,54.12 108.08,53.89 108.08,52.79 v1(107.53,52.24) ; 113.63,113.06 112.27,113.06 v1(111.36,112.16)
M_A_DQ9: length 81.1
  IN1 w0.127: v1(113.37,112.16) 112.93,112.6 108.65,112.6 104.81,108.76 104.81,108.39 101.95,105.53 101.95,93.77 102.78,92.95 102.78,66.66 102.9,66.54 102.9,57.07 106.38,53.6 106.38,52.2 108.08,50.5 v1(108.08,49.98)
  BOTTOM w0.076: U35.AR68 117.98,112.68 117.68,112.39 116.07,112.39 115.88,112.58 113.8,112.58 v1(113.37,112.16)
  BOTTOM w0.114: JDIM2.22 107.54,49.45 v1(108.08,49.98)
M_A_DQ10: length 78.3
  IN1 w0.127: v1(112.34,110.14) 112.06,109.85 109.79,109.85 107.43,107.49 107.43,107.32 104.48,104.38 104.48,98.17 106.54,96.11 106.54,89.59 106.41,89.46 105.98,89.46 105.85,89.33 105.85,89.08 105.98,88.95 106.41,88.95 106.54,88.83 106.54,88.57 106.41,88.44 105.98,88.44 105.85,88.32 105.85,88.06 105.98,87.94 106.41,87.94 106.54,87.81 106.54,87.56 106.41,87.43 105.98,87.43 105.85,87.3 105.85,87.05 105.98,86.92 106.41,86.92 106.54,86.79 106.54,86.54 106.41,86.41 105.98,86.41 105.85,86.29 105.85,86.03 105.98,85.9 106.41,85.9 106.54,85.78 106.54,85.52 106.41,85.4 105.98,85.4 105.85,85.27 105.85,85.02 105.98,84.89 106.41,84.89 106.54,84.76 106.54,84.51 106.41,84.38 105.98,84.38 105.85,84.25 105.85,84 105.98,83.87 106.41,83.87 106.54,83.75 106.54,83.49 106.41,83.36 105.98,83.36 105.85,83.24 105.85,82.98 105.98,82.86 106.41,82.86 106.54,82.73 106.54,82.48 106.41,82.35 105.98,82.35 105.83,82.2 105.83,63.5 106.02,63.3 106.02,60.09 106.82,59.29 106.82,57.66 107.38,57.1 107.38,56.15 109.77,53.77 v1(109.94,53.77)
  BOTTOM w0.076: U35.AU71 116.12,111.4 114.92,111.4 114.52,110.99 114.13,110.99
  BOTTOM w0.114: JDIM2.33 110.84,54.12 110.49,53.77 v1(109.94,53.77) ; 114.13,110.99 113.2,110.99 v1(112.34,110.14)
M_A_DQ11: length 79.8
  IN1 w0.127: v1(111.29,48.57) 111.84,49.12 111.84,51.06 111.06,51.84 111.06,54.5 109.93,55.62 109.56,55.62 108.42,56.76 108.42,60.18 107.01,61.59 107.01,63.36 107.27,63.62 107.27,64 106.87,64.4 106.87,66.9 107.54,67.57 107.54,71.64 107.67,71.77 108.02,71.77 108.15,71.89 108.15,72.15 108.02,72.28 107.67,72.28 107.54,72.4 107.54,72.66 107.67,72.78 108.02,72.78 108.15,72.91 108.15,73.16 108.02,73.29 107.67,73.29 107.54,73.42 107.54,73.67 107.67,73.8 108.02,73.8 108.15,73.93 108.15,74.18 108.02,74.31 108.02,74.31 107.9,74.43 107.9,74.68 108.15,74.93 108.15,96.78 105.47,99.46 105.47,103.97 108.42,106.91 108.42,107.08 110.05,108.71 113.46,108.71 v1(114.25,109.5)
  BOTTOM w0.076: U35.AU68 118.05,111.48 117.62,111.05 117.37,111.05 117.18,110.86 117.18,110.63 116.93,110.38 116.34,110.38 116.29,110.43
  BOTTOM w0.114: JDIM2.36 111.74,48.11 v1(111.29,48.57) ; 116.29,110.43 115.81,110.43 114.88,109.5 v1(114.25,109.5)
M_A_DQ12: length 78.6
  IN1 w0.127: v1(107.53,53.77) 107.53,53.86 104.93,56.46 104.93,58.16 104.8,58.29 104.04,58.29 103.91,58.42 103.91,58.67 104.04,58.8 104.67,58.8 104.8,58.92 104.8,59.18 104.67,59.3 104.1,59.3 103.91,59.49 103.91,69.34 103.77,69.48 103.77,72.11 103.89,72.24 104.19,72.24 104.32,72.36 104.32,72.62 104.19,72.74 103.89,72.74 103.77,72.87 103.77,73.12 103.89,73.25 104.19,73.25 104.32,73.38 104.32,73.63 104.19,73.76 103.89,73.76 103.77,73.89 103.77,74.14 103.89,74.27 104.19,74.27 104.32,74.39 104.32,74.65 104.19,74.78 103.89,74.78 103.77,74.9 103.77,75.16 103.89,75.28 104.19,75.28 104.32,75.41 104.32,75.66 104.19,75.79 103.89,75.79 103.77,75.92 103.77,76.17 103.89,76.3 104.19,76.3 104.32,76.43 104.32,76.68 104.19,76.81 103.89,76.81 103.77,76.93 103.77,77.19 103.89,77.32 104.19,77.32 104.32,77.44 104.32,77.7 104.19,77.82 103.89,77.82 103.77,77.95 103.77,78.2 103.89,78.33 104.19,78.33 104.32,78.46 104.32,92.92 102.94,94.29 102.94,104.98 105.93,107.97 105.93,108.16 109.14,111.36 111.21,111.36 111.53,111.68 112.26,111.68 v1(112.74,112.16)
  BOTTOM w0.076: v1(112.74,112.16) 113.36,112.78 U35.AR71
  BOTTOM w0.114: JDIM2.21 107.24,54.05 v1(107.53,53.77)
M_A_DQ13: length 80.1
  IN1 w0.127: v1(108.05,48.56) 108.67,49.18 108.67,50.39 106.71,52.36 106.71,53.73 103.23,57.21 103.23,66.67 103.11,66.8 103.11,93.09 102.28,93.91 102.28,105.39 105.27,108.38 105.27,108.44 108.98,112.14 v1(110.72,112.14)
  BOTTOM w0.076: U35.AR69 117.36,112.68 116.83,113.22 113.86,113.22 113.75,113.32
  BOTTOM w0.114: JDIM2.24 108.14,48.5 108.08,48.56 v1(108.05,48.56) ; v1(110.72,112.14) 111.9,113.32 113.75,113.32
M_A_DQ14: length 78.9
  IN1 w0.127: v1(112.61,109.5) 109.9,109.5 107.76,107.36 107.76,107.19 104.81,104.24 104.81,98.67 106.95,96.54 106.95,81.91 106.82,81.78 106.31,81.78 106.18,81.66 106.18,81.4 106.31,81.27 106.82,81.27 106.95,81.15 106.95,80.89 106.82,80.77 106.31,80.77 106.18,80.64 106.18,80.39 106.31,80.26 106.82,80.26 106.95,80.13 106.95,79.88 106.82,79.75 106.31,79.75 106.18,79.62 106.18,79.37 106.31,79.24 106.82,79.24 106.95,79.12 106.95,78.86 106.82,78.73 106.31,78.73 106.18,78.61 106.18,78.35 106.31,78.23 106.82,78.23 106.95,78.1 106.95,77.85 106.82,77.72 106.31,77.72 106.18,77.59 106.18,63.91 106.35,63.75 106.35,60.23 107.2,59.38 107.2,57.75 107.71,57.24 107.71,56.33 109.44,54.61 109.81,54.61 110.39,54.03 110.39,52.87 v1(109.97,52.45)
  BOTTOM w0.089: 114.3,110.77 114.56,110.77 114.98,111.18 116.56,111.18 U35.AU70
  BOTTOM w0.114: JDIM2.35 111.44,54.2 110.58,53.34 110.58,53.06 v1(109.97,52.45) ; v1(112.61,109.5) 113.03,109.5 114.3,110.77
M_A_DQ15: length 79.5
  IN1 w0.127: v1(113.61,109.5) 113.17,109.06 109.93,109.06 108.09,107.22 108.09,107.05 105.14,104.1 105.14,99.29 107.82,96.61 107.82,77.41 107.69,77.28 107.28,77.28 107.15,77.15 107.15,76.9 107.28,76.77 107.67,76.77 107.8,76.64 107.8,76.39 107.67,76.26 107.18,76.26 107.05,76.14 107.05,75.88 107.18,75.75 107.67,75.75 107.8,75.63 107.8,75.37 107.67,75.25 107.15,75.25 107.02,75.12 107.02,67.94 106.51,67.43 106.51,64.29 106.68,64.12 106.68,60.37 108.09,58.96 108.09,56.49 109.33,55.24 109.69,55.24 110.72,54.21 110.72,51.42 111.3,50.83 v1(111.3,49.86)
  BOTTOM w0.076: 114.52,110.49 115.04,111 116.64,111 116.71,111.08 117.1,111.08 U35.AU69
  BOTTOM w0.114: v1(113.61,109.5) 113.61,109.58 114.52,110.49 ; v1(111.3,49.86) 111.04,49.86 110.71,49.53 110.71,48.84 110.85,48.69 110.85,48.4 111.14,48.11 JDIM2.34
M_A_DQ16: length 74.3
  IN1 w0.127: v1(114.77,104.64) 114.34,105.07 109.11,105.07 107.1,103.06 107.1,100.21 109.79,97.52 109.79,61.39 110.79,60.39 110.79,57.18 112.81,55.17 112.81,50.13 v1(112.95,49.98)
  BOTTOM w0.076: U35.BB65 119.84,108.21 119.84,108.07 118.12,106.35 116.22,106.35 115.3,105.42 115.3,105.17 v1(114.77,104.64)
  BOTTOM w0.114: JDIM2.42 113.54,49.39 v1(112.95,49.98)
M_A_DQ17: length 75.8
  IN1 w0.127: v1(111.7,53.46) 111.7,54.76 110.2,56.26 109.82,56.26 109.05,57.03 109.05,60.45 108.23,61.28 108.23,66.87 108.52,67.16 108.52,67.36 108.23,67.65 108.23,67.98 108.35,68.11 108.66,68.11 108.79,68.24 108.79,68.49 108.66,68.62 108.32,68.62 108.19,68.75 108.19,69 108.32,69.13 108.66,69.13 108.79,69.25 108.79,69.51 108.66,69.64 108.3,69.64 108.17,69.76 108.17,70.02 108.3,70.14 108.66,70.14 108.79,70.27 108.79,70.52 108.66,70.65 108.3,70.65 108.17,70.78 108.17,71.03 108.3,71.16 108.66,71.16 108.79,71.29 108.79,97.05 106.11,99.73 106.11,103.7 108.47,106.06 114.16,106.06 115.28,107.18 v1(115.66,107.18)
  BOTTOM w0.076: v1(115.66,107.18) 116.42,107.95 118,107.95 118.3,108.25 118.3,108.45 118.48,108.63 118.76,108.63 119.09,108.96 119.37,108.96 119.49,109.08 119.54,109.19 119.54,109.62 119.65,109.72 119.65,109.9 119.94,110.19 U35.AW65
  BOTTOM w0.114: JDIM2.39 112.64,54.12 111.99,53.46 v1(111.7,53.46)
M_A_DQ18: length 77.3
  IN1 w0.127: v1(116.59,103.61) 116.4,103.42 116.4,101.32 115.84,100.76 115.84,77.53 114.87,76.56 114.87,72.44 114.74,72.31 114.01,72.31 113.88,72.18 113.88,71.93 114.01,71.8 114.74,71.8 114.87,71.67 114.87,71.42 114.74,71.29 114.01,71.29 113.88,71.17 113.88,70.91 114.01,70.78 114.74,70.78 114.87,70.66 114.87,70.4 114.74,70.28 114.22,70.28 114.1,70.15 114.1,69.9 114.22,69.77 114.74,69.77 114.87,69.64 114.87,69.39 114.74,69.26 114.01,69.26 113.76,69.52 113.53,69.52 113.37,69.36 113.37,68.88 113.5,68.75 114.74,68.75 114.87,68.63 114.87,68.37 114.74,68.24 113.27,68.24 113.14,68.12 113.14,67.86 113.27,67.74 114.16,67.74 114.26,67.63 114.26,67.43 114.07,67.24 114.07,61.26 114.64,60.7 114.64,57.78 116.12,56.3 116.12,52.4 v1(115.66,51.94)
  BOTTOM w0.076: U35.AW63 121.16,110.05 121.47,109.74 121.47,109.19 121.69,108.97 121.69,107.33 120.79,106.42 120.1,106.42 119.04,105.36 118.47,105.36 117.1,103.99 116.97,103.99 v1(116.59,103.61)
  BOTTOM w0.114: JDIM2.53 116.84,53.12 v1(115.66,51.94)
M_A_DQ19: length 76
  IN1 w0.127: v1(116.59,105.56) 116.35,105.56 115.41,104.62 115.41,102.11 114.85,101.55 114.85,99.17 113.86,98.17 113.86,80.88 113.78,80.8 113.58,80.8 113.45,80.68 113.45,80.42 113.58,80.3 113.78,80.3 113.91,80.17 113.91,79.92 113.78,79.79 112.14,79.79 112.01,79.66 112.01,79.41 112.14,79.28 113.75,79.28 113.88,79.15 113.88,78.9 113.75,78.77 112.14,78.77 112.01,78.65 112.01,78.39 112.14,78.26 112.48,78.26 112.61,78.14 112.61,77.88 112.48,77.76 112.14,77.76 112.01,77.63 112.01,61.31 113.59,59.73 113.59,57.42 114.77,56.24 114.77,49.78 v1(115.66,48.89)
  BOTTOM w0.076: v1(116.59,105.56) 117.9,105.56 118.2,105.86 118.52,105.86 119.85,107.18 120.85,107.18 121.18,107.51 121.18,107.98 121,108.16 121,108.42 121.05,108.54 121.05,108.68 120.99,108.91 120.99,109.04 121.06,109.26 121.06,109.51 U35.AY63
  BOTTOM w0.114: JDIM2.52 116.54,47.99 116.41,48.12 116.41,48.14 v1(115.66,48.89)
M_A_DQ20: length 75
  IN1 w0.127: v1(112.94,48.54) 112.61,48.54 112.47,48.68 112.47,55.03 110.46,57.03 110.46,60.25 109.45,61.27 109.45,97.4 106.77,100.08 106.77,103.37 108.8,105.4 114.67,105.4 v1(114.77,105.3)
  BOTTOM w0.076: U35.BA65 119.94,108.74 119.71,108.51 119.71,108.5 119.65,108.37 119.65,108.12 118.05,106.52 115.99,106.52 v1(114.77,105.3)
  BOTTOM w0.114: JDIM2.40 v1(112.94,48.54)
M_A_DQ21: length 75.7
  IN1 w0.127: v1(111.74,52.17) 112.14,52.57 112.14,54.87 110.13,56.88 110.13,60.07 108.56,61.65 108.56,65.71 108.68,65.84 108.99,65.84 109.12,65.97 109.12,66.22 108.99,66.35 108.68,66.35 108.56,66.47 108.56,66.73 108.68,66.86 108.99,66.86 109.12,66.98 109.12,97.19 106.44,99.86 106.44,103.55 108.62,105.73 114.47,105.73 v1(114.74,106)
  BOTTOM w0.076: v1(114.74,106) 115.42,106.68 117.99,106.68 119.49,108.18 119.49,108.42 119.54,108.53 119.54,108.58 119.65,108.69 119.65,109.02 119.71,109.15 119.71,109.39 U35.AY65
  BOTTOM w0.114: JDIM2.41 113.24,54.08 112.21,53.05 112.21,52.64 v1(111.74,52.17)
M_A_DQ22: length 75.4
  IN1 w0.127: v1(116.59,104.26) 116.07,103.74 116.07,101.63 115.51,101.07 115.51,77.95 114.52,76.96 114.52,75.89 114.39,75.76 113.93,75.76 113.8,75.63 113.8,75.38 113.93,75.25 114.36,75.25 114.49,75.13 114.49,74.87 114.36,74.75 112.8,74.75 112.67,74.62 112.67,74.36 112.8,74.24 114.36,74.24 114.49,74.11 114.49,73.86 114.36,73.73 112.8,73.73 112.67,73.6 112.67,73.35 112.8,73.22 114.36,73.22 114.49,73.09 114.49,72.84 114.36,72.71 112.8,72.71 112.67,72.59 112.67,72.33 112.8,72.21 113.37,72.21 113.5,72.08 113.5,71.82 113.37,71.7 112.8,71.7 112.67,71.57 112.67,71.32 112.8,71.19 113.37,71.19 113.5,71.06 113.5,70.81 113.37,70.68 112.8,70.68 112.67,70.55 112.67,61.59 113.57,60.69 113.57,60.68 114.25,60.01 114.25,57.7 115.66,56.29 v1(115.66,53.26)
  BOTTOM w0.076: v1(116.59,104.26) 117.09,104.26 118.36,105.53 118.88,105.53 120.03,106.68 120.81,106.68 121.53,107.4 121.53,108.49 121.26,108.75 U35.BA63
  BOTTOM w0.114: JDIM2.51 116.24,53.85 v1(115.66,53.26)
M_A_DQ23: length 74.5
  IN1 w0.127: v1(115.66,50.19) 115.1,50.75 115.1,56.38 113.92,57.56 113.92,59.87 112.34,61.44 112.34,75.1 112.47,75.23 113.25,75.23 113.37,75.36 113.37,75.61 113.25,75.74 112.47,75.74 112.34,75.86 112.34,76.12 112.47,76.25 113.75,76.25 113.88,76.37 113.88,76.63 113.75,76.75 112.47,76.75 112.34,76.88 112.34,77.13 112.47,77.26 113.75,77.26 113.88,77.39 113.88,77.64 113.75,77.77 113.58,77.77 113.45,77.9 113.45,78.15 113.58,78.28 114.44,78.28 114.77,78.61 114.77,98.42 115.18,98.83 115.18,101.25 115.74,101.81 115.74,104.06 v1(116.59,104.91)
  BOTTOM w0.076: U35.BB63 121.34,108.24 121.34,107.44 120.83,106.93 119.98,106.93 118.74,105.69 118.27,105.69 117.48,104.91 v1(116.59,104.91)
  BOTTOM w0.114: v1(115.66,50.19) 115.15,49.68 115.15,48.76 115.94,47.97 JDIM2.50
M_A_DQ24: length 67.1
  IN1 w0.127: v1(117.6,52.22) 117.22,52.22 117.12,52.32 117.12,54.01 117.11,54.02 117.11,56.71 115.86,57.96 115.86,60.91 115.68,61.08 115.68,67.43 115.86,67.61 115.86,74.2 115.98,74.33 116.68,74.33 116.81,74.45 116.81,74.71 116.68,74.84 115.98,74.84 115.86,74.96 115.86,75.22 115.98,75.34 116.68,75.34 116.81,75.47 116.81,75.72 116.68,75.85 116.49,75.85 116.34,75.99 116.34,76.25 116.81,76.71 116.81,100.2 117.37,100.75 117.37,102.97 v1(118.71,104.32)
  BOTTOM w0.076: v1(118.71,104.32) 120.31,105.91 120.75,105.91 122.03,107.19 122.03,108.48 122.29,108.74 U35.BA61
  BOTTOM w0.114: JDIM2.59 118.64,52.6 118.26,52.22 v1(117.6,52.22)
M_A_DQ25: length 68.2
  IN1 w0.127: v1(118.71,104.97) 118.2,104.45 118.2,104.29 117.04,103.13 117.04,100.89 116.48,100.33 116.48,77.27 115.53,76.32 115.53,67.78 114.71,66.96 114.71,61.53 115.53,60.71 115.53,57.79 116.77,56.54 116.77,49.43 v1(117.69,48.51)
  BOTTOM w0.076: U35.AW61 122.39,110.08 122.07,109.75 122.07,109.21 121.86,109 121.86,107.26 120.77,106.17 120.18,106.17 119.11,105.1 118.84,105.1 v1(118.71,104.97)
  BOTTOM w0.114: v1(117.69,48.51) 117.74,48.46 JDIM2.56
M_A_DQ26: length 66.8
  IN1 w0.127: v1(121.41,49.96) 120.94,49.96 120.62,50.28 120.62,50.95 119.96,51.61 119.96,58.48 119.61,58.84 119.61,61.23 119.96,61.58 119.96,66.99 119.84,67.12 119.6,67.12 119.47,67.25 119.47,67.5 119.6,67.63 119.84,67.63 119.96,67.76 119.96,68.01 119.84,68.14 119.6,68.14 119.47,68.26 119.47,68.52 119.6,68.65 119.84,68.65 119.96,68.77 119.96,69.03 119.84,69.15 119.6,69.15 119.47,69.28 119.47,69.53 119.6,69.66 119.84,69.66 119.96,69.79 119.96,71.51 119.31,72.16 119.31,99.15 119.87,99.71 119.87,101.76 120.64,102.54 v1(120.64,102.56)
  BOTTOM w0.076: 121.71,104.94 123.28,106.51 123.28,107.07 123.66,107.45 123.66,108.27 U35.BB59
  BOTTOM w0.102: 121.71,104.94 121.71,103.63 v1(120.64,102.56)
  BOTTOM w0.114: v1(121.41,49.96) 121.94,49.43 JDIM2.70
M_A_DQ27: length 69
  IN1 w0.127: v1(121.41,48.51) 120.29,49.63 120.29,50.82 119.63,51.47 119.63,58.35 119.28,58.7 119.28,61.37 119.63,61.72 119.63,64.3 119.51,64.43 119.04,64.43 118.91,64.56 118.91,64.81 119.04,64.94 119.51,64.94 119.63,65.07 119.63,66.42 119.01,67.05 119.01,69.76 119.63,70.38 119.63,71.2 118.98,71.86 118.98,99.29 119.54,99.85 119.54,101.9 120.15,102.52 120.15,102.72 v1(120.64,103.21)
  BOTTOM w0.076: U35.AW59 122.97,110.27 122.76,110.06 122.76,109.55 122.69,109.45 122.69,109.2 122.73,109.07 122.73,108.84 122.73,108.83 122.72,108.83 122.72,108.83 122.69,108.74 122.69,108.54 122.72,108.45 122.72,108.09 122.52,107.89 122.52,106.98 120.1,104.56 120.1,103.75 v1(120.64,103.21)
  BOTTOM w0.114: v1(121.41,48.51) 121.34,48.44 JDIM2.68
M_A_DQ28: length 66.4
  IN1 w0.127: v1(118.71,103.67) 118.53,103.67 117.7,102.83 117.7,100.62 117.14,100.06 117.14,73.75 117.01,73.63 116.52,73.63 116.4,73.5 116.4,73.24 116.52,73.12 117.01,73.12 117.14,72.99 117.14,72.74 117.01,72.61 116.31,72.61 116.19,72.48 116.19,72.23 116.31,72.1 117.01,72.1 117.14,71.97 117.14,71.72 117.01,71.59 116.31,71.59 116.19,71.47 116.19,71.21 116.31,71.09 117.01,71.09 117.14,70.96 117.14,70.7 117.01,70.58 116.31,70.58 116.19,70.45 116.19,70.2 116.31,70.07 117.01,70.07 117.14,69.94 117.14,69.69 117.01,69.56 116.31,69.56 116.19,69.43 116.19,67.43 116.04,67.28 116.04,65.15 116.93,64.26 116.93,57.53 117.44,57.02 117.44,56.15 117.6,55.99 v1(117.6,53.62)
  BOTTOM w0.076: U35.BB61 122.19,108.21 122.19,107.12 120.73,105.66 120.49,105.66 119.21,104.38 119.21,104.17 v1(118.71,103.67)
  BOTTOM w0.114: JDIM2.57 118.04,54.06 v1(117.6,53.62)
M_A_DQ29: length 68
  IN1 w0.127: v1(117.69,50.03) 118.11,50.45 118.11,55.95 117.77,56.29 117.77,57.7 117.34,58.14 117.34,67.4 117.18,67.55 116.85,67.55 116.73,67.68 116.73,67.93 116.85,68.06 117.34,68.06 117.47,68.19 117.47,68.44 117.34,68.57 116.85,68.57 116.73,68.69 116.73,68.95 116.85,69.08 117.34,69.08 117.47,69.2 117.47,99.92 118.03,100.48 118.03,102.69 118.32,102.99 v1(118.71,102.99)
  BOTTOM w0.076: v1(118.71,102.99) 119.16,103.44 119.16,103.59 119.46,103.88 119.46,104.16 122.36,107.05 122.36,107.96 122.56,108.16 122.56,108.42 122.52,108.51 122.52,108.52 122.52,108.77 122.56,108.86 122.56,109.07 122.53,109.15 122.53,109.15 122.49,109.25 122.49,109.51 U35.AY61
  BOTTOM w0.114: JDIM2.58 118.34,48.13 118.2,48.27 118.2,49.53 v1(117.69,50.03)
M_A_DQ30: length 67.9
  IN1 w0.127: v1(121.63,52.19) 121.63,51.24 121.5,51.11 121.25,51.11 121.12,51.24 121.12,51.58 120.99,51.71 120.42,51.71 120.3,51.84 120.3,52.09 120.42,52.22 120.99,52.22 121.12,52.34 121.12,52.57 120.99,52.7 120.42,52.7 120.3,52.83 120.3,58.62 120.15,58.76 120.15,58.97 120.3,59.12 120.3,59.32 120.17,59.45 120.07,59.45 119.94,59.57 119.94,59.83 120.07,59.96 120.17,59.96 120.3,60.08 120.3,60.34 120.17,60.46 120.07,60.46 119.94,60.59 119.94,60.84 120.07,60.97 120.17,60.97 120.3,61.1 120.3,71.76 119.64,72.42 119.64,99.02 120.2,99.58 120.2,101.47 v1(120.64,101.91)
  BOTTOM w0.076: 122.03,104.92 123.44,106.33 123.44,107 123.88,107.44 123.88,108.41 123.82,108.56 123.73,108.74 U35.BA59
  BOTTOM w0.102: 122.03,104.92 122.03,103.29 v1(120.64,101.91)
  BOTTOM w0.114: v1(121.63,52.19) 120.74,53.08 120.74,53.97 121.04,54.28 JDIM2.67
M_A_DQ31: length 68.6
  IN1 w0.127: v1(121.63,53.59) 121.25,53.21 120.85,53.21 120.63,53.44 120.63,54.49 120.75,54.62 120.97,54.62 121.1,54.74 121.1,55 120.97,55.13 120.75,55.13 120.63,55.25 120.63,55.51 120.75,55.63 120.97,55.63 121.1,55.76 121.1,56.01 120.97,56.14 120.75,56.14 120.63,56.27 120.63,56.52 120.75,56.65 120.97,56.65 121.1,56.78 121.1,57.03 120.97,57.16 120.75,57.16 120.63,57.28 120.63,57.54 120.75,57.67 120.97,57.67 121.1,57.79 121.1,58.05 120.97,58.17 120.75,58.17 120.63,58.3 120.63,58.55 120.84,58.77 120.84,59.1 120.63,59.32 120.63,59.57 120.75,59.7 120.97,59.7 121.1,59.82 121.1,60.08 120.97,60.21 120.75,60.21 120.63,60.33 120.63,60.59 120.75,60.71 120.97,60.71 121.1,60.84 121.1,61.09 120.97,61.22 120.75,61.22 120.63,61.35 120.63,64 120.75,64.13 120.97,64.13 121.1,64.25 121.1,64.51 120.97,64.63 120.75,64.63 120.63,64.76 120.63,67.5 120.75,67.63 120.97,67.63 121.1,67.75 121.1,68.01 120.97,68.13 120.75,68.13 120.63,68.26 120.63,68.52 120.75,68.64 120.97,68.64 121.1,68.77 121.1,69.02 120.97,69.15 120.75,69.15 120.63,69.28 120.63,69.53 120.75,69.66 120.97,69.66 121.1,69.79 121.1,70.04 120.97,70.17 120.75,70.17 120.63,70.29 120.63,70.55 120.75,70.67 120.97,70.67 121.1,70.8 121.1,71.06 120.97,71.18 120.75,71.18 120.63,71.31 120.63,71.9 119.97,72.56 119.97,98.88 120.64,99.55 v1(120.64,101.26)
  BOTTOM w0.076: U35.AY59 123.62,109.41 123.88,109.15 123.88,108.95 124.02,108.52 124.05,108.45 124.05,107.37 123.66,106.98 123.66,106.17 122.39,104.9 ; v1(121.75,102.36) 121.75,102.37
  BOTTOM w0.102: 122.39,104.9 122.39,103.01 v1(120.64,101.26)
  BOTTOM w0.114: JDIM2.69 121.64,53.61 v1(121.63,53.59)
M_A_DQ32: length 68.8
  IN1 w0.076: 137.38,97.02 137.38,97.06 135.37,99.07 v1(135.37,100.52)
  IN1 w0.127: 137.38,97.02 137.38,85.67 142.49,80.56 142.49,79.68 143.31,78.86 143.31,67.9 143.67,67.54 143.67,53.89 143.46,53.67 143.46,52.04 143.33,51.91 142.89,51.91 142.77,51.79 142.77,51.53 142.89,51.41 143.33,51.41 143.46,51.28 143.46,50.57 v1(143.26,50.37)
  BOTTOM w0.076: v1(135.37,100.52) 134.17,101.73 134.17,106.13 134.44,106.41 134.44,107.04 134.23,107.25 134.23,108.46 134.29,108.59 134.29,108.61 134.39,108.86 134.39,109.15 134.66,109.41 U35.AY39
  BOTTOM w0.114: JDIM2.130 142.34,49.92 142.79,50.37 v1(143.26,50.37)
M_A_DQ33: length 66.2
  IN1 w0.076: 136.61,97.02 134.71,98.93 134.71,105.06 v1(135.37,105.72)
  IN1 w0.127: v1(142.62,53.77) 143.01,54.16 143.01,54.56 142.89,54.68 142.63,54.68 142.46,54.85 142.46,56.13 143.01,56.68 143.01,57.06 142.89,57.18 142.7,57.18 142.53,57.36 142.53,57.54 142.68,57.69 142.89,57.69 143.01,57.82 143.01,58.31 142.46,58.86 142.46,60.96 143.01,61.51 143.01,63.44 142.89,63.56 142.61,63.56 142.48,63.69 142.48,63.94 142.61,64.07 142.89,64.07 143.01,64.19 143.01,64.45 142.89,64.58 142.61,64.58 142.48,64.7 142.48,64.96 142.61,65.08 142.86,65.08 143.01,65.24 143.01,67.13 142.56,67.58 142.56,69.19 142.65,69.28 142.65,77.21 141.83,78.03 141.83,80.29 136.61,85.5 136.61,97.02
  BOTTOM w0.076: U35.AW39 135.31,110.27 135.52,110.06 135.52,109.55 135.59,109.39 135.59,109.21 135.54,109.05 135.54,108.91 135.6,108.69 135.6,108.57 135.56,108.46 135.56,108.08 135.76,107.88 135.76,106.11 v1(135.37,105.72)
  BOTTOM w0.114: v1(142.62,53.77) 142.64,53.79 JDIM2.131
M_A_DQ34: length 68.4
  IN1 w0.076: v1(135.37,105.07) 136.43,104.02 136.43,99.24 137.93,97.74 138.53,97.74 139.24,97.02
  IN1 w0.127: v1(145.38,49.02) 144.92,49.47 144.92,50.21 145.7,50.99 145.7,56.19 145.86,56.36 145.86,57.55 145.63,57.78 145.63,60.82 145.79,60.98 145.79,67.02 145.52,67.29 145.52,68.29 145.15,68.66 145.15,80.5 139.24,86.41 139.24,97.02
  BOTTOM w0.076: v1(135.37,105.07) 135.92,105.62 135.92,107.95 135.72,108.15 135.72,108.42 135.78,108.54 135.78,108.68 135.71,108.91 135.71,109.04 135.79,109.26 135.79,109.51 U35.AY37
  BOTTOM w0.114: v1(145.38,49.02) 145.34,48.99 JDIM2.140
M_A_DQ35: length 69.3
  IN1 w0.076: 139.57,97.02 138.68,97.91 137.99,97.91 136.59,99.31 136.59,101.91 v1(137.15,102.47)
  IN1 w0.127: 139.57,97.02 139.57,86.55 145.48,80.64 145.48,68.8 145.85,68.43 145.85,67.97 146.9,66.92 146.9,58.15 146.19,57.44 146.19,56.23 146.03,56.06 146.03,50.27 v1(146.39,49.91)
  BOTTOM w0.076: U35.AW37 135.89,110.05 136.2,109.74 136.2,109.19 136.42,108.97 136.42,107.95 136.42,103.2 v1(137.15,102.47)
  BOTTOM w0.114: JDIM2.142 145.94,49.46 v1(146.39,49.91)
M_A_DQ36: length 67.1
  IN1 w0.076: v1(135.37,101.82) 134.96,101.41 134.96,99.08 137.02,97.02
  IN1 w0.127: v1(142.62,52.47) 142.98,52.47 143.13,52.63 143.13,53.81 143.34,54.02 143.34,55.25 143.22,55.38 142.92,55.38 142.79,55.5 142.79,55.76 142.92,55.88 143.22,55.88 143.34,56.01 143.34,59.24 143.22,59.37 142.92,59.37 142.79,59.49 142.79,59.75 142.92,59.87 143.22,59.87 143.34,60 143.34,60.25 143.22,60.38 142.92,60.38 142.79,60.51 142.79,60.76 142.92,60.89 143.22,60.89 143.34,61.02 143.34,67.4 142.98,67.76 142.98,77.88 142.76,78.1 142.28,78.1 142.16,78.23 142.16,78.48 142.28,78.61 142.68,78.61 142.81,78.74 142.81,78.89 142.16,79.54 142.16,80.42 137.05,85.54 137.05,97 137.02,97.02
  BOTTOM w0.076: U35.BB39 134.56,108.21 134.56,107.39 134.77,107.18 134.77,106.27 134.52,106.02 134.52,102.67 v1(135.37,101.82)
  BOTTOM w0.114: JDIM2.129 142.04,53.05 v1(142.62,52.47)
M_A_DQ37: length 67.6
  IN1 w0.076: 137.71,97.02 135.76,98.97 135.76,100.79 135.39,101.17 v1(135.37,101.17)
  IN1 w0.127: v1(143.26,49.1) 143.79,49.63 143.79,50.28 143.92,50.41 144.16,50.41 144.28,50.54 144.28,50.79 144.16,50.92 143.92,50.92 143.79,51.04 143.79,53.54 144,53.75 144,67.67 143.64,68.04 143.64,79.46 142.82,80.28 142.82,80.7 137.73,85.79 137.73,97 137.71,97.02
  BOTTOM w0.076: U35.BA39 134.66,108.82 134.52,108.68 134.52,108.67 134.51,108.67 134.39,108.42 134.39,107.32 134.6,107.11 134.6,106.34 134.33,106.06 134.33,102.21 v1(135.37,101.17)
  BOTTOM w0.114: JDIM2.132 142.94,48 142.71,48.24 142.71,48.55 v1(143.26,49.1)
M_A_DQ38: length 68.2
  IN1 w0.076: v1(137.15,101.82) 136.76,101.43 136.76,99.55 138.18,98.12 138.81,98.12 139.9,97.02
  IN1 w0.127: 139.9,97.02 139.9,86.69 145.81,80.78 145.81,68.95 146.18,68.58 146.18,68.15 147.23,67.1 147.23,58.01 146.52,57.31 146.52,56.09 146.36,55.92 146.36,52.83 146.43,52.76 146.43,51.48 146.56,51.35 146.79,51.35 146.94,51.5 v1(146.94,52.45)
  BOTTOM w0.076: U35.BA37 135.99,108.75 136.25,108.49 136.25,108.02 136.25,108.02 136.25,102.72 v1(137.15,101.82)
  BOTTOM w0.114: v1(146.94,52.45) 146.84,52.45 145.64,53.64 JDIM2.141
M_A_DQ39: length 67.1
  IN1 w0.076: 140.23,97.02 138.84,98.42 138.12,98.42 137.15,99.39 v1(137.15,101.17)
  IN1 w0.127: v1(146.81,53.74) 146.81,55.91 147.56,56.66 147.56,56.86 147.43,56.99 147.18,56.99 147.06,57.12 147.06,57.37 147.18,57.5 147.43,57.5 147.56,57.63 147.56,67.24 147.05,67.75 147.05,68.73 146.9,68.88 146.35,68.88 146.14,69.08 146.14,69.26 146.27,69.39 146.82,69.39 146.94,69.5 146.94,69.64 146.68,69.89 146.27,69.89 146.14,70.02 146.14,70.28 146.27,70.4 146.39,70.4 146.52,70.53 146.52,70.78 146.39,70.91 146.27,70.91 146.14,71.04 146.14,71.29 146.27,71.42 146.93,71.42 147.05,71.55 147.05,71.8 146.93,71.93 146.27,71.93 146.14,72.05 146.14,72.31 146.27,72.43 146.67,72.43 146.8,72.56 146.8,72.82 146.67,72.94 146.35,72.94 146.14,73.15 146.14,80.91 140.23,86.82 140.23,97.02
  BOTTOM w0.076: v1(137.15,101.17) 136.09,102.23 136.09,108.02 135.99,108.12 U35.BB37
  BOTTOM w0.114: JDIM2.143 146.24,54.18 146.69,53.74 v1(146.81,53.74)
M_A_DQ40: length 72.9
  IN1 w0.076: v1(137.15,104.42) 137.75,103.82 137.75,99.27 138.15,98.87 139.36,98.87 141.2,97.02
  IN1 w0.127: 141.2,97.02 141.2,87.22 147.11,81.31 147.11,74.83 147.26,74.68 147.89,74.68 148.02,74.55 148.02,74.3 147.89,74.17 147.37,74.17 147.24,74.04 147.24,73.84 147.42,73.66 147.89,73.66 148.02,73.54 148.02,68.18 149.07,67.13 149.07,64.18 148.82,63.93 148.82,56.55 147.9,55.64 147.9,50.85 148.03,50.72 148.68,50.72 148.81,50.59 148.81,50.34 148.68,50.21 v1(147.83,50.21)
  BOTTOM w0.076: v1(137.15,104.42) 137.71,104.98 137.71,105.97 137.08,106.6 137.08,107.64 137.28,107.85 137.28,108.42 137.25,108.51 137.25,108.52 137.25,108.77 137.28,108.86 137.28,109.07 137.25,109.15 137.25,109.15 137.22,109.25 137.22,109.51 U35.AY35
  BOTTOM w0.114: JDIM2.146 147.14,49.53 v1(147.83,50.21)
M_A_DQ41: length 73.5
  IN1 w0.076: 140.87,97.02 139.26,98.64 138.14,98.64 137.54,99.23 137.54,103.38 v1(137.15,103.77)
  IN1 w0.127: v1(147.83,48.92) 147.83,48.26 147.7,48.13 147.45,48.13 147.32,48.26 147.32,49.06 147.19,49.18 147.08,49.18 146.95,49.31 146.95,49.57 147.08,49.69 147.19,49.69 147.32,49.82 147.32,50.07 147.19,50.2 147,50.2 146.87,50.33 146.87,50.58 147,50.71 147.19,50.71 147.32,50.84 147.32,50.99 147.57,51.24 147.57,55.77 148.49,56.69 148.49,58.8 148.2,59.1 148.2,59.34 148.49,59.64 148.49,59.85 148.2,60.14 148.2,60.37 148.49,60.66 148.49,60.87 148.2,61.16 148.2,61.36 148.49,61.66 148.49,64.07 148.74,64.32 148.74,66.99 147.69,68.04 147.69,72.82 146.78,73.74 146.78,81.18 140.87,87.09 140.87,97.02
  BOTTOM w0.076: U35.AW35 137.12,110.08 136.79,109.75 136.79,109.21 136.58,109 136.58,107.88 136.58,107.88 136.58,104.34 v1(137.15,103.77)
  BOTTOM w0.114: JDIM2.148 147.74,48.83 v1(147.83,48.92)
M_A_DQ42: length 73.3
  IN1 w0.076: 143.41,97.02 143.38,97.05 143.17,97.05 141.6,98.62 140.99,98.62 139.66,99.94 v1(138.9,99.94)
  IN1 w0.127: v1(151.28,49.81) 151.28,50.66 150.7,51.25 150.7,52.08 150.57,52.2 150.48,52.2 150.36,52.33 150.36,52.59 150.48,52.71 150.57,52.71 150.7,52.84 150.7,53.09 150.57,53.22 150.48,53.22 150.36,53.35 150.36,53.62 150.7,53.96 150.7,54.33 150.36,54.67 150.36,55 151.28,55.93 151.28,61.13 151.78,61.62 151.78,67.89 151.59,68.08 151.59,71.6 150.63,72.55 150.63,73 150.51,73.12 150.32,73.12 150.19,73.25 150.19,73.5 150.32,73.63 150.51,73.63 150.63,73.76 150.63,74.01 150.51,74.14 150.32,74.14 150.19,74.27 150.19,74.52 150.32,74.65 150.51,74.65 150.63,74.77 150.63,75.03 150.51,75.16 150.32,75.16 150.19,75.28 150.19,75.54 150.32,75.66 150.51,75.66 150.63,75.79 150.63,76.49 149.3,77.82 149.3,82.28 143.47,88.12 143.47,96.96 143.41,97.02
  BOTTOM w0.076: U35.AY33 138.34,109.41 138.61,109.14 138.61,108.8 138.66,108.69 138.73,108.55 138.77,108.46 138.77,108.09 138.65,107.97 138.65,107.97 138.6,107.91 138.6,107.59 138.76,107.42 138.76,105.29 139.44,104.61 139.44,100.48 v1(138.9,99.94)
  BOTTOM w0.114: v1(151.28,49.81) 150.74,49.27 JDIM2.158
M_A_DQ43: length 72.1
  IN1 w0.076: 143.8,97.02 143.8,97.12 143.71,97.21 143.24,97.21 141.62,98.83 141,98.83 139.69,100.14 139.34,100.14 v1(138.9,100.58)
  IN1 w0.127: 143.8,97.02 143.8,88.25 149.63,82.42 149.63,77.95 150.96,76.62 150.96,72.69 151.92,71.74 151.92,68.22 152.11,68.03 152.11,61.44 151.63,60.96 151.63,55.81 151.03,55.21 151.03,51.39 151.73,50.69 151.73,48.89 v1(151.29,48.46)
  BOTTOM w0.076: U35.AW33 137.69,110.27 137.49,110.06 137.49,109.55 137.41,109.45 137.41,109.2 137.46,109.07 137.46,108.84 137.45,108.83 137.45,108.83 137.45,108.83 137.41,108.74 137.41,108.54 137.45,108.45 137.45,107.78 137.24,107.58 137.24,106.67 137.87,106.04 137.87,104.82 137.84,104.78 137.84,101.64 v1(138.9,100.58)
  BOTTOM w0.114: v1(151.29,48.46) 151.34,48.41 JDIM2.160
M_A_DQ44: length 71.4
  IN1 w0.076: v1(137.15,105.07) 137.95,104.27 137.95,99.37 138.29,99.03 139.58,99.03 141.53,97.08 141.53,97.02
  IN1 w0.127: v1(148.84,51.84) 148.84,51.18 148.72,51.05 148.46,51.05 148.34,51.18 148.34,55.6 149.15,56.41 149.15,63.71 149.4,63.96 149.4,67.27 148.35,68.32 148.35,70.52 148.48,70.65 148.81,70.65 148.93,70.78 148.93,71.03 148.81,71.16 148.48,71.16 148.35,71.28 148.35,75.01 148.22,75.14 147.82,75.14 147.69,75.26 147.69,75.52 147.82,75.65 148.22,75.65 148.35,75.77 148.35,76.03 148.22,76.15 147.81,76.15 147.44,76.52 147.44,81.45 141.53,87.36 141.53,97.02
  BOTTOM w0.076: U35.BB35 136.91,108.21 136.91,107.75 136.91,107.75 136.91,106.53 137.54,105.9 137.54,105.47 v1(137.15,105.07)
  BOTTOM w0.114: v1(148.84,51.84) 148.59,51.84 147.44,52.98 JDIM2.147
M_A_DQ45: length 71.7
  IN1 w0.076: v1(137.15,105.72) 138.15,104.72 138.15,99.47 138.42,99.21 139.67,99.21 141.86,97.02
  IN1 w0.127: 141.86,97.02 141.9,96.98 141.9,87.55 147.77,81.68 147.77,76.66 147.94,76.48 148.5,76.48 148.68,76.31 148.68,72.38 148.81,72.25 148.81,72 148.68,71.88 148.68,71.61 148.81,71.49 149.19,71.49 149.31,71.36 149.31,70.35 149.39,70.28 149.39,70.11 149.29,70.01 148.81,70.01 148.68,69.88 148.68,69.63 148.81,69.5 149.9,69.5 150.03,69.37 150.03,69.12 149.9,68.99 148.81,68.99 148.68,68.87 148.68,68.61 148.97,68.32 149.16,68.32 149.33,68.49 149.9,68.49 150.03,68.36 150.03,68.1 149.9,67.98 149.54,67.98 149.44,67.87 149.44,67.69 149.73,67.4 149.73,67.05 150,66.78 150,66.43 149.73,66.16 149.73,65.88 149.86,65.75 149.89,65.75 150.01,65.62 150.01,65.37 149.89,65.24 149.86,65.24 149.73,65.12 149.73,64.86 149.86,64.73 150.14,64.73 150.27,64.61 150.27,64.35 150.14,64.23 149.86,64.23 149.73,64.1 149.73,63.75 149.48,63.5 149.48,56.28 148.67,55.46 148.67,55.13 148.83,54.96 148.83,54.34 148.67,54.17 148.67,53.54 v1(148.84,53.36)
  BOTTOM w0.076: U35.BA35 137.02,108.74 136.75,108.48 136.75,107.82 136.75,107.81 136.75,106.12 v1(137.15,105.72)
  BOTTOM w0.114: JDIM2.149 148.04,53.59 148.27,53.36 v1(148.84,53.36)
M_A_DQ46: length 72
  IN1 w0.076: 144.46,97.02 144.46,97.18 144.09,97.54 143.37,97.54 141.76,99.16 141.14,99.16 139.79,100.51 139.79,103.16 v1(138.93,104.03)
  IN1 w0.127: v1(151.5,52.45) 151.83,52.12 151.83,51.13 151.98,50.98 152.19,50.98 152.34,51.13 152.34,53.39 152.21,53.52 152.11,53.52 151.98,53.64 151.98,53.9 152.11,54.02 152.21,54.02 152.34,54.15 152.34,54.41 152.21,54.53 152.11,54.53 151.98,54.66 151.98,54.91 152.11,55.04 152.21,55.04 152.34,55.17 152.34,60.46 152.77,60.89 152.77,68.36 152.58,68.55 152.58,76.87 151.16,78.28 150.98,78.28 150.72,78.02 150.51,78.02 150.36,78.17 150.36,78.38 150.62,78.64 150.62,78.82 150.3,79.15 150.3,82.7 144.46,88.53 144.46,97.02
  BOTTOM w0.076: v1(138.93,104.03) 138.6,104.36 138.6,107.35 138.43,107.52 138.43,107.98 138.61,108.16 138.61,108.42 138.49,108.67 138.49,108.67 138.48,108.68 138.34,108.82 U35.BA33
  BOTTOM w0.114: JDIM2.157 150.44,53.5 v1(151.5,52.45)
M_A_DQ47: length 71
  IN1 w0.076: 144.13,97.02 144.13,97.02 143.78,97.38 143.31,97.38 141.69,99 141.07,99 139.53,100.53 139.53,102.77 v1(138.93,103.38)
  IN1 w0.127: 144.13,97.02 144.13,88.39 149.97,82.56 149.97,78.09 150.57,77.49 150.8,77.49 151.04,77.73 151.25,77.73 151.4,77.58 151.4,77.37 151.15,77.12 151.15,76.9 151.3,76.75 151.52,76.75 151.72,76.96 151.98,76.96 152.25,76.69 152.25,76.33 152.12,76.2 151.42,76.2 151.3,76.08 151.3,75.82 151.42,75.7 152.12,75.7 152.25,75.57 152.25,75.32 152.12,75.19 151.42,75.19 151.3,75.06 151.3,74.81 151.42,74.68 152.12,74.68 152.25,74.55 152.25,74.3 152.12,74.17 151.42,74.17 151.3,74.05 151.3,73.79 151.42,73.66 152.12,73.66 152.25,73.54 152.25,73.28 152.12,73.16 151.47,73.16 151.35,73.03 151.35,72.78 151.47,72.65 152.12,72.65 152.25,72.52 152.25,68.41 152.44,68.22 152.44,61.29 151.98,60.83 151.98,55.69 151.47,55.19 v1(151.47,53.82)
  BOTTOM w0.076: v1(138.93,103.38) 138.43,103.87 138.43,107.29 138.27,107.45 138.27,108.11 138.34,108.18 U35.BB33
  BOTTOM w0.114: JDIM2.159 151.04,54.25 v1(151.47,53.82)
M_A_DQ48: length 73.2
  IN1 w0.076: 145.76,97.02 145.76,97.13 144.85,98.04 143.58,98.04 141.1,100.52 v1(140.81,100.52)
  IN1 w0.127: v1(153.42,52.45) 153.89,52.92 153.89,53.55 154.14,53.8 154.14,56.13 153.89,56.38 153.89,59.79 155.42,61.33 155.42,64.28 155,64.71 155,67.11 154.67,67.43 154.67,76.32 154.23,76.77 154.23,77.05 152.23,79.04 152.23,81.33 152.11,81.46 151.72,81.46 151.59,81.59 151.59,81.84 151.72,81.97 152.11,81.97 152.23,82.09 152.23,82.35 152.11,82.47 151.72,82.47 151.59,82.6 151.59,83.23 145.78,89.04 145.78,93.13 145.88,93.23 146.27,93.23 146.39,93.36 146.39,93.62 146.27,93.74 145.88,93.74 145.76,93.87 145.76,94.12 145.88,94.25 146.27,94.25 146.39,94.38 146.39,94.63 146.27,94.76 145.88,94.76 145.76,94.89 145.76,95.14 145.88,95.27 146.27,95.27 146.39,95.39 146.39,95.72 145.76,96.36 145.76,97.02
  BOTTOM w0.076: U35.AY31 139.64,109.41 139.38,109.15 139.38,108.86 139.21,108.45 139.21,108.09 139.38,107.92 139.38,107.04 139.7,106.72 139.7,101.63 v1(140.81,100.52)
  BOTTOM w0.114: JDIM2.163 152.24,53.62 v1(153.42,52.45)
M_A_DQ49: length 73.2
  IN1 w0.076: 145.1,97.02 144.41,97.71 143.44,97.71 141.83,99.33 141.21,99.33 140.04,100.49 140.04,105.02 140.74,105.72 v1(140.81,105.72)
  IN1 w0.127: v1(152.78,49.81) 152.97,50 152.97,50.92 153.1,51.04 153.56,51.04 153.68,51.17 153.68,51.42 153.56,51.55 153.1,51.55 152.97,51.68 152.97,60.19 154.14,61.36 154.14,64.4 153.66,64.88 153.66,71.55 153.21,72 153.21,77.13 150.93,79.41 150.93,82.96 145.1,88.79 145.1,97.02
  BOTTOM w0.076: U35.AW31 140.29,110.27 140.5,110.06 140.5,109.55 140.57,109.39 140.57,109.21 140.52,109.05 140.52,108.91 140.58,108.69 140.58,108.57 140.55,108.49 140.54,108.46 140.54,107.94 140.83,107.64 140.83,105.75 v1(140.81,105.72)
  BOTTOM w0.114: v1(152.78,49.81) 153.29,49.3 153.29,48.3 153.14,48.16 JDIM2.166
M_A_DQ50: length 72.7
  IN1 w0.076: v1(140.81,105.07) 140.88,105.07 141.82,104.14 141.82,100.73 143.85,98.7 146.02,98.7 147.7,97.02
  IN1 w0.127: 147.7,97.02 148.6,96.12 148.6,89.51 154.08,84.03 154.08,80.01 156.69,77.39 156.69,69.01 156.93,68.77 156.93,67.22 157.97,66.19 157.97,60.89 156.26,59.18 156.26,54.02 156.32,53.95 156.32,50.63 v1(155.58,49.88)
  BOTTOM w0.076: U35.AY29 140.77,109.51 140.77,109.26 140.69,109.04 140.69,108.91 140.76,108.68 140.76,108.54 140.7,108.42 140.7,108.01 141,107.72 141,106.14 141.2,105.94 141.2,105.46 v1(140.81,105.07)
  BOTTOM w0.114: v1(155.58,49.88) 156.14,49.31 JDIM2.176
M_A_DQ51: length 73.4
  IN1 w0.076: 148.16,97.02 146.32,98.87 143.92,98.87 142,100.79 142,102.06 v1(142.41,102.47)
  IN1 w0.127: 148.16,97.02 148.93,96.26 148.93,89.64 154.41,84.17 154.41,81.01 155.02,80.4 155.02,79.58 157.02,77.58 157.02,74.8 157.39,74.43 157.39,67.24 158.33,66.29 158.33,60.76 156.59,59.02 156.59,54.19 156.65,54.12 156.65,49.58 v1(155.54,48.46)
  BOTTOM w0.076: U35.AW29 140.87,110.05 141.18,109.74 141.18,109.19 141.4,108.97 141.4,108.02 141.49,107.93 141.49,106.5 141.7,106.29 141.7,103.18 v1(142.41,102.47)
  BOTTOM w0.114: v1(155.54,48.46) 155.54,48.45 JDIM2.174
M_A_DQ52: length 71.3
  IN1 w0.076: v1(140.81,101.82) 140.52,101.82 140.3,101.6 140.3,100.47 141.28,99.49 141.89,99.49 143.51,97.87 144.58,97.87 145.43,97.02
  IN1 w0.127: 145.43,97.02 145.43,88.93 151.26,83.1 151.26,81.01 151.39,80.89 151.78,80.89 151.9,80.76 151.9,80.51 151.78,80.38 151.39,80.38 151.26,80.25 151.26,79.55 153.54,77.27 153.54,76.28 153.67,76.15 154.22,76.15 154.34,76.02 154.34,75.77 154.22,75.64 153.67,75.64 153.54,75.52 153.54,75.26 153.67,75.13 154.22,75.13 154.34,75.01 154.34,74.75 154.22,74.63 153.67,74.63 153.54,74.5 153.54,74.25 153.67,74.12 154.22,74.12 154.34,73.99 154.34,73.74 154.22,73.61 153.67,73.61 153.54,73.48 153.54,73.23 153.67,73.1 154.22,73.1 154.34,72.98 154.34,72.72 154.22,72.59 153.67,72.59 153.54,72.47 153.54,72.14 154.06,71.62 154.06,65.1 154.5,64.66 154.5,62.16 154.77,61.88 154.77,61.14 154.55,60.92 154.17,60.92 153.44,60.2 v1(153.44,53.74)
  BOTTOM w0.076: v1(140.81,101.82) 140.03,102.6 140.03,106.86 139.71,107.17 139.71,108.24 U35.BB31
  BOTTOM w0.114: v1(153.44,53.74) 153.16,53.74 152.84,54.06 JDIM2.165
M_A_DQ53: length 71.9
  IN1 w0.076: v1(140.81,101.17) 141.21,100.77 141.21,100.64 143.65,98.21 145.03,98.21 146.09,97.15 146.09,97.02
  IN1 w0.127: 146.09,97.02 146.09,96.5 146.72,95.86 146.72,93.19 146.11,92.58 146.11,89.18 152.57,82.73 152.57,79.18 154.65,77.1 154.65,76.83 155,76.48 155,68.09 155.33,67.77 155.33,64.84 155.77,64.4 155.77,61.18 154.24,59.65 154.24,56.54 154.53,56.24 154.53,53.73 154.24,53.43 154.24,52.78 154.18,52.72 154.18,49.56 153.15,48.54 v1(152.78,48.54)
  BOTTOM w0.076: v1(140.81,101.17) 139.86,102.11 139.86,106.79 139.55,107.1 139.55,107.99 139.38,108.16 139.38,108.42 139.49,108.67 139.5,108.67 139.5,108.68 139.64,108.82 U35.BA31
  BOTTOM w0.114: v1(152.78,48.54) 152.54,48.3 JDIM2.164
M_A_DQ54: length 71.8
  IN1 w0.076: 148.68,97.44 146.95,99.17 146.8,99.17 146.78,99.2 144.06,99.2 142.96,100.29 142.96,101.26 v1(142.41,101.82)
  IN1 w0.127: v1(157.7,53.23) 157.44,53.49 157.44,54.27 157.25,54.46 157.25,58.7 159.09,60.54 159.09,64.51 159.84,65.26 159.84,67.79 158.75,68.88 158.75,70.82 158.1,71.47 158.1,75.15 157.7,75.56 157.7,78.02 155.68,80.04 155.68,80.67 155.07,81.29 155.07,81.44 155.19,81.57 155.52,81.57 155.65,81.7 155.65,81.95 155.52,82.08 155.19,82.08 155.07,82.2 155.07,82.46 155.19,82.58 155.52,82.58 155.65,82.71 155.65,83.02 155.58,83.09 155.19,83.09 155.07,83.22 155.07,83.47 155.17,83.57 155.47,83.57 155.6,83.7 155.6,83.9 155.4,84.11 155.19,84.11 155.07,84.24 155.07,84.44 149.84,89.67 149.84,96.28 148.68,97.44
  BOTTOM w0.076: v1(142.41,101.82) 141.53,102.7 141.53,106.09 141.33,106.29 141.33,107.85 141.24,107.95 141.24,108.47 140.97,108.74 U35.BA29
  BOTTOM w0.114: v1(157.7,53.23) 157.29,53.23 156.44,54.08 JDIM2.177
M_A_DQ55: length 71.1
  IN1 w0.076: 148.63,97.02 148.61,97.04 148.61,97.09 146.67,99.03 143.99,99.03 142.41,100.61 v1(142.41,101.17)
  IN1 w0.127: v1(157.72,51.93) 157.08,52.57 157.08,54.16 156.92,54.32 156.92,58.86 158.74,60.68 158.74,64.66 159.5,65.42 159.5,67.66 157.72,69.44 157.72,75.05 157.35,75.42 157.35,77.77 155.35,79.77 155.35,80.53 154.74,81.15 154.74,84.31 149.31,89.73 149.31,96.34 148.63,97.02
  BOTTOM w0.076: v1(142.41,101.17) v1(141.65,101.93) 141.37,102.21 141.37,106.02 141.16,106.22 141.16,107.79 140.97,107.98 U35.BB29
  BOTTOM w0.114: JDIM2.175 155.84,53.81 v1(157.72,51.93)

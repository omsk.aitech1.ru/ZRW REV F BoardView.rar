# Allegro board Quanta ZRW REV F - BoardView (.BRD).brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PVDD: length 24.2
  TOP w1.016: L13.1 46.82,36.06 46.95,36.19 46.95,40 45.07,41.88 45.07,48.31 43.57,49.81 v3(43.55,49.81) 43.55,49.83 42.99,50.39 37.5,50.39 37.33,50.57 R338.1 36.18,50.57 Q28.1
V0P85A_VID0: length 24.6
  TOP w0.114: TP31.1 162.66,96.88 159.77,96.88 153.98,102.67 153.98,107.48 151.73,109.74 151.73,111.25 151.36,111.61 151.36,113.3 v2(150.95,113.71)
  BOTTOM w0.127: v2(150.95,113.71) U35.AN11
V0P85A_VID1: length 1.6
  TOP w0.114: TP16.1 149.88,113.81 v2(150.03,113.81)
  BOTTOM w0.114: v2(150.03,113.81) 149.81,114.03 U35.AN13
V18: length 2.2
  TOP w0.254: U26.24 60.44,24.23 60.82,24.61 60.82,24.63 v1(60.95,24.76) 61.05,24.86 61.79,24.86 C544.2
VCC_XD: length 29.2
  TOP w0.508: v4(53.17,25.78) v1(53.17,26.79) 53.17,27.29 R396.1 C533.2 55.08,27.78 56.6,26.26 ; v1(39.2,24.76) 38.85,25.12 C542.2 37.46,25.55 C543.1 37.44,25.15 37.17,24.89 33.87,24.89 33.26,24.28 CN4.4
  IN2 w0.508: v4(53.17,25.78) 46.82,25.78 45.68,24.63 40.86,24.63 40.12,25.37 39.56,25.37 39.2,25.01 v1(39.2,24.76)
VCCGT_SENSE: length 108.1
  TOP w0.114: R155.2 110.96,130.43 v1(110.96,130.04)
  IN1 w0.127: v1(110.96,130.04) 114.49,133.57 119.97,133.57 121.09,132.45 121.09,131.87 121.46,131.5 122.28,131.5 123.77,133 123.77,134.73 125.3,136.25 125.3,139.43 125.41,139.54 125.41,141.2 125.31,141.3 125.31,141.6 126.07,142.36 127.46,142.36 129.25,144.15 129.25,150.62 129.06,150.81 129.06,151.82 129.37,152.14 131.28,152.14 132.3,153.16 132.3,157.73 131.53,158.49 131.53,166.37 132.04,166.87 132.04,168.4 127.85,172.59 127.85,173.83 129.16,175.14 129.16,178.36 130.75,179.95 136.05,179.95 138.52,182.42 138.52,183.89 v1(139.03,184.4)
  BOTTOM w0.076: 115.09,125.85 115.8,125.85 115.85,125.79 116.28,125.79 116.44,125.86 116.63,125.86 U35.J70
  BOTTOM w0.114: 115.09,125.85 112.36,128.58 112.36,128.8 111.11,130.04 v1(110.96,130.04)
  BOTTOM w0.203: PR191.1 151.59,188.24 151.78,188.05 151.78,186.58 149.63,184.44 140.46,184.44 v3(140.23,184.2) 139.92,183.89 139.41,183.89 139.03,184.27 v1(139.03,184.4)
VCCOPC_VID0: length 2.3
  BOTTOM w0.114: PR287.2 R707.2 R708.1
VCCOPC_VID0_C: length 2.1
  BOTTOM w0.114: PU14.4 57.37,85.18 v1(57.24,85.31) 57.24,85.89 PR287.1
VCCOPC_VID1: length 3.5
  BOTTOM w0.114: R705.1 R706.2 55.84,87.93 55.66,87.75 55.33,87.75 v1(55,87.42) 55.4,87.03 55.4,87 PR286.2
VCCOPC_VID1_C: length 3.1
  BOTTOM w0.114: PU14.3 56.87,85.07 55.84,86.1 PR286.1 55.08,86.22 v1(55,86.15)
VCCRTC_2: length 11.2
  TOP w0.635: R308.1 84.28,69.5 v3(84.37,69.41) 84.57,69.21 v1(85.05,69.21)
  BOTTOM w0.635: BT1.1 90.16,65.66 86.6,69.21 v1(85.05,69.21)
VCCST_PWRGD: length 147.2
  TOP w0.114: R89.1 159.6,148.08 159.22,148.46 C136.2 158.58,149.47 158.58,150.36 158.97,150.74 159.97,150.74 160.49,151.26 160.49,151.54 163.41,154.46 163.41,156.16 164.55,157.3 v1(164.55,157.6)
  IN1 w0.127: v1(111.66,135) 115.1,135 118.12,138.02 118.12,141.1 120.33,143.31 120.33,147.65 120.26,147.72 120.26,152.27 121.32,153.34 121.32,166.7 125.03,170.4 125.03,173.15 127.42,175.54 127.42,180.06 131.05,183.69 134,183.69 136,185.7 138.42,185.7 142.96,190.24 149.31,190.24 150.48,189.07 151.3,189.07 155.74,184.63 157.67,184.63 158.56,183.74 158.56,180.49 157.95,179.88 157.95,177.04 162.04,172.95 162.04,170.73 164.07,168.7 164.07,158.09 v1(164.55,157.6)
  BOTTOM w0.076: U35.B65 119.67,130.57 119.67,131.85 119.37,132.15 118.99,132.15
  BOTTOM w0.114: 118.99,132.15 118.73,132.41 117.26,132.41 117.18,132.33 114.29,132.33 113.09,133.52 112.08,133.52 111.43,134.17 110.96,134.64 v3(110.96,135) v1(111.66,135)
VCCST_PWRGD_EN: length 5.6
  TOP w0.114: R103.1 R102.1 196.17,86.76 U47.1 196.17,85.53 196.33,85.37 196.63,85.37 R777.2
VCCST_PWRGD_EN_L: length 6.8
  TOP w0.114: U47.4 194.87,84.66 195.28,85.08 197.12,85.08 R777.1 197.9,85.86 197.9,86.61 197.57,86.94 197.32,86.94 196.8,87.46 U6.2
VCCST_PWRGD_R: length 97.8
  TOP w0.114: U6.4 197.45,89.12 v3(198.49,88.08) 198.49,84.73 196.76,83 195.01,83 194.6,83.41 193.71,83.41 192.9,84.22 190.64,84.22 v1(190.59,84.27) ; R85.1 158.47,148.46 158.58,148.46 159.17,147.87 159.17,147.08 R89.2 159.6,144.22 161.38,142.44 161.38,140.04 164.26,137.16 164.52,137.16 168.4,133.28 169.35,133.28 170.28,132.36 171.05,132.36 172.58,130.82 172.58,130.54 173.56,129.56 174.69,129.56 178.02,126.23 v1(178.4,126.23)
  IN1 w0.127: v1(190.59,84.27) 190.26,84.27 188.4,86.13 188.4,91.11 187.16,92.36 187.16,104.67 188.63,106.14 188.63,109.52 186.96,111.2 186.14,111.2 182.87,114.47 181.83,114.47 181.65,114.65 181.65,120.49 180.97,121.17 180.97,121.67 180.57,122.08 180.57,122.76 180.15,123.18 180.15,124.08 179.36,124.87 179.36,125.54 178.67,126.23 v1(178.4,126.23)
VDD10: length 4.2
  TOP w0.203: 34.51,90.75 34.94,90.75 35.3,90.38 U15.30 ; v1(32.66,87.74) 32.69,87.72 U15.3
  TOP w0.457: 33.82,91.26 34.33,90.75 34.51,90.75
  vias: v1(32.85,91.31) v1(33.29,85.16) v1(33.49,91.31) v1(39.18,87.42) v1(40.09,96.01) v1(40.09,95.35) v3(40.04,93.39)
VIN: length 166.4
  TOP w0.508: v1(48.97,47.76) 52.92,47.76 54.24,49.08 54.24,51.33 v1(53.48,52.09) 50.3,55.27 50.3,62.78 51.4,63.88 51.4,63.9 52.01,64.51 55.77,64.51 57.24,65.99 PR151.1 ; PR75.1 218.27,116.45 v1(217.51,115.69) ; PD4.2 v1(80.61,69.46) ; v1(186.91,80.89) 192.14,80.89 193.21,79.83 197.78,79.83 199.61,78.01 PR141.1 PR142.1 ; PR6130.1 70,51.94 73.06,51.94 73.44,51.56 v3(75.1,51.56) 76.21,50.44 v1(76.39,50.44) ; v1(80.99,16.89) PR159.1
  IN2 w0.254: v1(197.32,109.22) 197.32,106.8 200.62,103.5 v1(200.62,100.71)
  IN2 w0.508: v1(80.61,69.46) 80.1,68.96 75.65,68.96 74.76,68.07 65.11,68.07 v1(63.72,66.67)
  BOTTOM w0.178: PR209.2 219.67,177.54 222.3,177.54 222.47,177.37 PR213.2
  BOTTOM w0.254: PR272.1 200.85,100.48 v1(200.62,100.71)
  BOTTOM w0.508: 53.1,32.1 52.01,31.01 52.01,27.76 53.15,26.62 54.09,26.62 54.72,25.98 54.72,25.37 55.46,24.63 58.56,24.63 58.69,24.51 59.37,24.51 60.16,23.72 64.3,23.72 67.88,20.14 67.88,15.59 68.64,14.83 74.99,14.83 77.05,16.89 v1(80.99,16.89) ; 53.1,32.1 PR336.1 ; 53.1,32.1 52.69,32.1 52.03,32.76 52.03,33.63 52.41,34.01 52.46,34.01 PR335.1 50.51,37.23 50.51,46.22 v1(48.97,47.76) ; 161.63,170.17 159.48,170.17 157.95,171.7 157.57,171.7 156.81,172.46 156.81,174.74 155.16,176.39 PR212.1
  vias: v1(59.02,74.11) v1(59.04,53.56) v1(59.04,52.93) v1(59.04,52.29) v1(59.73,74.11) v1(124.7,192.54) v1(124.76,191.89) v1(125.36,192.53) v3(57.8,48.94) v3(138.7,170.86) v3(144.97,167.89) v3(156.73,167.86) v3(176.54,63.8) v3(204.81,109.77) v3(212.74,106.7) v3(217.87,113.91) v4(72.05,55.01) v4(72.78,55.01) v4(73.62,55.01) v4(74.87,117.63) v4(75.3,116.89) v4(75.7,117.65) v4(76.14,116.91) v4(76.57,117.65) v4(77.03,116.91) v4(110.76,168.88) v4(110.76,168.14) v4(112.13,168.25) v4(112.15,168.98) v4(112.92,168.98) v4(112.92,168.25) v4(124.93,168.02) v4(125.31,167.25) v4(125.82,168.02) v4(126.33,167.25) v4(126.71,168.02) v4(127.22,167.25) v4(129.63,168.96) v4(130.39,168.96) v4(132.76,177.61) v4(132.76,176.6) v4(133.77,177.61) v4(133.77,176.6) v4(134.2,166.75) v4(134.58,165.98) v4(134.79,177.61) v4(134.79,176.6) v4(135.22,166.75) v4(135.6,165.98) v4(135.8,177.61) v4(135.8,176.6) v4(136.23,166.75) v4(136.49,165.98) v4(139.03,167.64) v4(139.79,167.64) v4(145.2,166.57) v4(145.48,165.82) v4(146.12,166.57) v4(146.43,165.81) v4(146.96,166.56) v4(147.36,165.81) v4(148.83,169.15) v4(149.57,169.16) v4(150.33,169.16) v4(151.07,169.16) v4(151.47,166.62) v4(151.47,165.86) v4(151.8,169.16) v4(155.98,166.6) v4(156.35,165.85) v4(156.95,166.57) v4(157.24,165.85) v4(157.92,166.54) v4(158.14,165.8) v4(162.14,168.96) v4(162.9,168.96) v4(168.49,200.53) v4(168.49,199.77) v4(168.49,199) v4(169.25,200.53) v4(169.25,199.77) v4(169.25,199) v4(170.01,200.53) v4(170.01,199.77) v4(170.01,199) v4(175.5,61.89) v4(175.5,61.13) v4(175.5,60.32) v4(176.24,60.7) v4(176.24,59.89) v4(176.25,61.46) v4(177.06,60.95) v4(177.06,60.19) v4(177.05,59.38) v4(186.4,115.87) v4(186.63,115.06) v4(187.15,115.87) v4(187.19,114.55) v4(187.64,115.13) v4(187.89,115.89) v4(187.9,114.32) v4(188.38,114.96) v4(188.61,115.67) v4(195.36,201.04) v4(196.12,201.04) v4(196.91,201.07) v4(197.67,201.07) v4(198.46,201.09) v4(205.2,113.35) v4(205.21,112.42) v4(205.22,111.38) v4(205.96,113.35) v4(205.97,112.41) v4(205.98,111.37) v4(206.72,113.35) v4(206.74,112.41) v4(206.74,111.37) v4(210.05,114.68) v4(210.05,113.91) v4(210.81,114.65) v4(210.81,113.91) v4(211.52,113.56) v4(211.52,112.8) v4(220.87,114.32) v4(220.94,113.28) v4(220.94,112.26) v4(220.94,111.12) v4(223.13,175.92) v4(223.13,175.13) v4(223.13,174.37) v4(223.13,173.6) v4(223.13,172.84) v4(223.91,175.92) v4(223.91,175.18) v4(223.91,174.44) v4(223.91,173.71) v4(223.91,172.94)
VSSGT_SENSE: length 111.6
  TOP w0.114: R161.1 110.07,130.68 v1(110.32,130.42)
  IN1 w0.127: v1(110.32,130.42) 113.73,133.83 120.08,133.83 121.36,132.54 121.36,132.02 121.62,131.76 122.17,131.76 123.52,133.11 123.52,134.86 125.04,136.38 125.04,139.89 125.16,140 125.16,141.1 125.06,141.2 125.06,141.73 125.95,142.62 127.36,142.62 128.99,144.25 128.99,150.51 128.8,150.7 128.8,151.93 129.27,152.4 131.17,152.4 132.04,153.26 132.04,157.62 131.28,158.39 131.28,166.47 131.79,166.98 131.79,168.29 127.6,172.48 127.6,173.94 128.84,175.18 128.84,178.41 130.7,180.26 135.91,180.26 138.14,182.49 v1(138.14,184.4)
  BOTTOM w0.076: U35.J69 117.28,125.86 117.08,125.86 116.93,125.8 116.8,125.8 116.7,125.69 116.47,125.69 116.32,125.63 115.7,125.63 115.69,125.64 115.02,125.64
  BOTTOM w0.114: v1(110.32,130.42) 110.5,130.25 110.5,129.9 110.79,129.61 111.19,129.61 112.1,128.7 112.1,128.45 114.91,125.64 115.02,125.64
  BOTTOM w0.203: v1(138.14,184.4) 138.77,185.03 140.3,185.03 v3(141.35,186.09) 142.01,186.75 142.86,186.75 143.05,186.56 143.73,186.56 144.01,186.84 144.01,187.98 144.11,188.08 144.11,190.78 144.35,191.02 144.87,191.02 145.17,191.32 147.76,191.32 148.06,191.61 149.92,191.61 150.58,190.96 PR181.1
2ND_MBCLK: length 206
  TOP w0.114: v1(164.97,123.5) 165.65,122.83 R171.1 ; v1(211.82,145.13) 211.67,145.28 210.99,145.28 210.02,146.25 206.57,146.25 v3(206.06,145.74) 205.55,146.25 205.32,146.25 203.04,143.97 203.04,142.74 v1(203.29,142.49) 203.69,142.09 Q13.6
  IN1 w0.127: v1(164.97,123.5) 165.4,123.08 167.1,123.08 167.67,122.51 168.03,122.51 168.72,123.2 168.9,123.2 169.99,124.29 170.92,124.29 171.54,124.91 171.54,126.84 170.01,128.37 170.01,131.05 170.41,131.44 175.76,131.44 177.25,129.94 179.3,129.94 180.35,131 180.35,131.52 v1(180.17,131.69)
  IN2 w0.127: v1(201.03,50.78) 201.03,50.08 200.71,49.77 199.48,49.77 198.74,50.51 198.74,52.04 198.21,52.57 198.21,55.46 197.52,56.15 197.52,60.91 199.9,63.29 209.64,63.29 210.55,64.21 212.05,64.21 217.5,69.66 217.5,87.44 222.61,92.55 224.92,92.55 228.29,95.92 228.29,99.39 214.52,113.17 214.52,115.82 214.06,116.28 212.93,116.28 211.82,117.38 211.82,121 210.78,122.04 210.78,131.82 212.41,133.45 212.41,135.54 209.79,138.16 209.79,139.92 210.78,140.92 210.78,144.85 211.21,145.28 211.67,145.28 v1(211.82,145.13)
  BOTTOM w0.114: R733.1 200.88,50.93 v1(201.03,50.78) 201.04,50.77 201.04,46.86 201.11,46.79 U45.115 ; v1(180.17,131.69) 180.37,131.89 180.8,131.89 181.46,132.55 181.46,133.23 183.15,134.93 193.8,134.93 193.93,135.06 196.89,135.06 199.22,137.4 199.22,137.71 202.79,141.27 202.79,141.99 v1(203.29,142.49)
2ND_MBDATA: length 213.2
  TOP w0.114: Q13.3 202.4,140.61 202.53,140.73 v1(202.53,142.49) 202.77,142.74 202.77,144.08 205.21,146.52 205.56,146.52 v3(206.06,147.01) 206.55,146.52 210.13,146.52 211.1,145.55 211.61,145.55 v1(211.83,145.77) ; v1(167.91,121.99) 166.75,121.99 R175.1
  IN1 w0.127: v1(167.91,121.99) 168.83,122.92 169.01,122.92 170.1,124.01 171.03,124.01 171.82,124.8 171.82,126.96 170.29,128.48 170.29,130.93 170.52,131.16 175.64,131.16 177.14,129.66 179.41,129.66 180.63,130.88 180.63,131.87 v1(180.17,132.33)
  IN2 w0.127: v1(201.73,50.8) 201.31,50.38 201.31,49.97 200.83,49.49 199.36,49.49 198.46,50.39 198.46,51.93 197.93,52.46 197.93,55.35 197.24,56.03 197.24,61.03 199.79,63.57 209.52,63.57 210.44,64.49 211.93,64.49 217.22,69.78 217.22,87.56 222.5,92.83 224.81,92.83 228.01,96.04 228.01,99.27 214.24,113.05 214.24,115.7 213.94,116 212.81,116 211.54,117.27 211.54,120.89 210.5,121.93 210.5,131.94 212.13,133.56 212.13,135.43 209.51,138.04 209.51,140.04 210.5,141.03 210.5,141.49 210.23,141.76 209.53,141.76 209.38,141.91 209.38,142.12 209.53,142.27 210.3,142.27 210.45,142.42 210.45,142.63 210.3,142.78 209.53,142.78 209.38,142.92 209.38,143.13 209.53,143.28 210.3,143.28 210.45,143.43 210.45,143.64 210.3,143.79 209.53,143.79 209.38,143.94 209.38,144.15 209.53,144.3 210.3,144.3 210.45,144.45 210.45,144.92 211.1,145.56 211.62,145.56 v1(211.83,145.77)
  BOTTOM w0.114: R734.1 201.89,50.96 v1(201.73,50.8) 201.31,50.38 201.31,47.03 201.51,46.83 U45.116 ; v1(202.53,142.49) 202.53,141.39 198.96,137.82 198.96,137.51 196.78,135.33 193.82,135.33 193.69,135.19 183.04,135.19 181.19,133.34 181.19,132.66 180.69,132.15 180.35,132.15 180.3,132.2 180.3,132.2 v1(180.17,132.33)
27M_XTAL_IN_R: length 11.7
  BOTTOM w0.114: Y3.3 199.36,148.54 C639.2 197.55,149.01 197.55,149.61 195.94,151.21 195.94,151.69 195.15,152.48 195.15,152.97 194.86,153.25 194.49,153.25 193.27,154.47 192.47,154.47 192.4,154.39 191.78,154.39 U34.C11
27M_XTAL_OUT: length 15
  BOTTOM w0.114: Y3.1 200.9,146.17 198.79,146.17 198.66,146.3 198.66,146.7 198.08,147.28 C644.2 197.26,148.04 197.26,149.55 195.73,151.09 195.73,151.6 194.93,152.39 194.93,152.88 194.77,153.04 194.4,153.04 193.18,154.25 192.58,154.25 U34.B10
554EN_0.95V: length 3.3
  BOTTOM w0.114: PU16.5 191.97,65.89 192.11,66.04 192.49,66.04 193.26,65.27 PC240.2 PR307.1
554FB_0.95V: length 4.6
  BOTTOM w0.254: PR310.2 193.49,62.34 PR309.1 193.26,61.84 193.37,61.72 PC244.1 192.49,61.21 191.97,61.73 PU16.6
554FB_0.95V_S: length 3.3
  BOTTOM w0.114: PC244.2 195.14,61.21 v3(195.21,61.29)
  BOTTOM w0.254: PR311.1 PR310.1 194.15,62.23 PC244.2
554NC_0.95V: length 3.1
  BOTTOM w0.254: PC247.2 193,60.07 v1(192.39,60.67) 191.47,61.6 PU16.7
554PG_0.95V: length 3.8
  BOTTOM w0.114: PU16.4 191.47,66.03 191.73,66.29 PR302.2 193.37,66.8 193.36,66.81 v3(193.36,67.36)
554SVIN_0.95V: length 6.3
  BOTTOM w0.254: 191.35,60.83 v1(191.15,61.03) 190.97,61.21 PU16.8
  BOTTOM w0.508: 191.35,60.83 192.49,59.69 192.61,59.69 PC252.2 193.02,58.57 192.06,58.57 PR312.2
681_AGND: length 57
  IN1 w0.127: v1(88.73,103.37) 87.02,101.66 87.02,98.94 78.83,90.75 68.34,90.75 66,88.41 66,81.15 64.05,79.19 63.03,79.19 v1(62.57,78.74)
  BOTTOM w0.114: PU14.11 57.87,80.65 PC230.1 57.23,79.87 56.52,79.16 56.52,78.86 56.31,78.65 56.02,78.65 55.76,78.39 55.76,77.08 55.88,76.96 57.14,76.96 PR294.1 58.23,76.83 59.86,76.83 v3(60.46,77.44) 61.28,77.44 v1(62.57,78.74) ; R636.1 v1(88.73,103.37) R632.1
1658R-BOOT1:
  vias: v1(199.66,104.69)
1658R-BOOT2:
  vias: v1(205.07,104.62)
1658R-COMP: length 4.5
  TOP w0.203: PC89.1 v1(205.27,102.33) 204.68,102.92 PU3.12
  BOTTOM w0.254: PC214.1 206.07,101.46 v3(206.03,101.42) 205.27,102.18 v1(205.27,102.33)
1658R-EN: length 7
  TOP w0.203: PR111.2 198.89,103.3 199.25,102.94 v1(199.33,102.94) 199.53,102.94 199.91,103.32 PU3.3
  TOP w0.254: PR343.2 196.8,103.81 197.8,103.81 198.19,103.42 PR111.2 198.19,103.13 v1(198.7,102.62)
  BOTTOM w0.254: v1(198.7,102.62) 198.23,102.15 PR267.2
1658R-FB: length 5.8
  TOP w0.203: PC94.1 PR129.1 206.16,99.44 206.16,99.51 v3(205.47,100.2) 204.56,101.11 204.56,102.32 204.36,102.52 PU3.11
1658R-FBRTN: length 3.7
  TOP w0.203: PU3.10 203.15,101.23 203.39,100.99 203.8,100.99 v3(204.03,100.76) 205.37,99.41 PR128.1
1658R-LGATE1: length 15.5
  IN2 w0.762: v4(190.72,116.73) 191.12,116.73 194.81,113.05 194.81,112.89 v4(201.67,106.03)
  vias: v1(200.95,106.04)
1658R-LGATE2: length 11.3
  IN2 w0.762: v4(197.04,114.84) 203.04,108.84 v4(203.04,106.05)
  vias: v1(203.75,106.22)
1658R-OCS/CB: length 5.1
  TOP w0.203: v1(202.91,100.71) 202.75,100.87 PU3.9
  BOTTOM w0.114: PR274.1 203.97,99.73 v3(204,99.69)
  BOTTOM w0.203: PR269.2 202.92,100.72 v1(202.91,100.71) 203.03,100.58 PR274.1 PR273.2
1658R-PG: length 4.4
  TOP w0.203: PR110.1 205.59,102.99 v1(205.32,102.99) 205.07,102.99 204.74,103.32 PU3.13
  BOTTOM w0.114: v3(206.11,104.47) 206.11,103.54 PR266.1
  BOTTOM w0.254: PR266.1 205.57,102.99 v1(205.32,102.99)
1658R-PHASE1: length 24.9
  TOP w0.508: PR65.1 191.48,121.76 v4(190.82,122.42)
  IN1 w0.762: v4(200.37,105.31) 197.74,105.31 189.55,113.5 189.55,120.67 190.82,121.94 v4(190.82,122.42)
  vias: v3(186.35,124.41)
1658R-PHASE2: length 18.1
  TOP w0.508: PR67.1 202.07,120.83 v4(202.9,121.66)
  IN2 w0.762: v4(202.9,121.66) 204.3,120.26 v4(204.3,105.47)
  vias: v3(204.99,105.94)
1658R-PSI: length 2.9
  TOP w0.203: PR116.2 199.2,102.08 200.04,102.92 PU3.4
1658R-PVCC: length 4.4
  TOP w0.178: PU3.18 202.35,106.92 PC79.1
  TOP w0.508: PC79.1 202.36,107.47 v3(202.76,107.87) 203.44,107.18 PR99.2
1658R-REFADJ: length 3.3
  TOP w0.114: v3(199.91,100.02) 200.18,99.75 PR126.1
  TOP w0.203: PU3.6 201.55,101.25 201.13,100.83 201.13,100.03 PR126.1
1658R-REFIN: length 10.1
  TOP w0.178: PC92.2 201.64,100.03 v1(201.64,100.58) 201.64,100.83 201.95,101.15 PU3.7
  TOP w0.254: PR131.2 200.49,96.64 v1(200.37,96.77) 200.23,96.91 PR132.1
  BOTTOM w0.254: v1(201.64,100.58) 201,101.21 200.24,101.21 200.11,101.09 200.11,97.76 v1(200.09,97.74) 200.09,97.3 200.37,97.02 v1(200.37,96.77)
1658R-UGATE1: length 23.2
  IN2 w0.762: v4(189.83,122.58) 189.47,122.22 189.47,116.71 190.16,116.02 190.16,112.89 v4(199.4,103.65)
1658R-UGATE2: length 19.7
  IN2 w0.762: v4(205.19,103.75) 205.19,107.44 207.86,110.1 207.86,113.79 207.23,114.42 v4(207.23,122.04)
1658R-VID: length 3.2
  TOP w0.203: PR123.2 198.69,101.06 v1(199.17,101.55) 200.15,102.52 PU3.5
1658R-VREF: length 4.4
  TOP w0.203: PU3.8 202.35,100.78 v1(202.27,100.71) 202.27,100.49 PC93.2 PR127.1
  BOTTOM w0.203: v1(202.27,100.71) 202.14,100.84 PR269.1
8002LX1.05V:
  vias: v3(77.74,23.29)
24780_ACDET: length 5.3
  TOP w0.254: PR3.2 207.01,197.87 v1(206.34,198.55)
  BOTTOM w0.178: PR168.2 208.5,199.44 v1(208.09,199.03) 207.61,198.55 v1(206.34,198.55) 206.34,198.5 206.25,198.41 PU5.6
24780_ACDRV: length 2.8
  BOTTOM w0.178: PU5.4 205.45,198.98 v1(205.5,199.03) 205.5,199.69 205.78,199.97 206.12,199.97 PR165.2
24780_ACN: length 30.9
  TOP w0.203: v1(203.92,198.88) 203.92,198.47 PC5.2
  TOP w0.254: PC2.1 203.7,199.11 v1(203.92,198.88)
  IN2 w0.203: v1(203.92,198.88) 203.92,198.62 204.95,197.6 206.35,197.6 207.45,196.5 207.45,192.05 210.12,189.38 210.12,186.84 215.99,180.97 218.15,180.97 218.78,180.34 218.78,180.21 v1(218.66,180.08)
  BOTTOM w0.178: PU5.1 204.25,198.17 203.92,198.5 v1(203.92,198.88)
  BOTTOM w0.203: v1(218.66,180.08) 218.78,179.96 218.78,179.71 PR209.1
24780_ACP: length 31.8
  TOP w0.203: PC5.1 204.57,198.59 v1(204.57,198.88)
  IN2 w0.203: v1(219.29,180.08) 219.16,180.21 219.16,180.46 218.27,181.35 216.12,181.35 210.45,187.02 210.45,189.55 207.78,192.23 207.78,196.67 206.53,197.93 205.51,197.93 204.57,198.87 v1(204.57,198.88)
  BOTTOM w0.178: v1(204.57,198.88) 204.57,198.57 204.65,198.5 PU5.2
  BOTTOM w0.203: PR210.1 219.29,179.71 v1(219.29,180.08)
  BOTTOM w0.254: PC115.2 v1(203.9,199.84) 203.9,199.67 204.57,198.99 v1(204.57,198.88)
24780_BATDRV: length 4.1
  BOTTOM w0.178: PR185.2 207.33,191.11 206.79,191.64 206.79,191.69 v1(206.49,191.99) 206.35,192.13 205.66,192.13 205.24,192.55 205.24,193.06 205.45,193.26 PU5.18
24780_BATSRC: length 4.9
  BOTTOM w0.178: PU5.17 205.85,193.28 207.36,191.77 208.29,191.77 v1(208.47,191.59) 208.9,191.59 PR186.2
24780_BM#: length 4.3
  TOP w0.254: v1(208.37,192.91) 209.13,192.91 209.51,192.53 PR16.1
  BOTTOM w0.178: v1(208.37,192.91) v1(207.58,192.91) 206.64,192.91 206.25,193.3 PU5.16
24780_BST: length 2.9
  BOTTOM w0.178: 201.89,195.78 201.99,195.68 202.83,195.68 202.89,195.74 PU5.25
  BOTTOM w0.254: PR173.2 201.03,196.64 201.89,195.78
24780_CMPIN: length 1.6
  TOP w0.254: v1(208.28,194.77) 208.25,194.8 PR11.2
  BOTTOM w0.178: PU5.13 208.11,194.94 v1(208.28,194.77)
24780_CMPOUT: length 82.3
  TOP w0.114: v1(212.69,145.54) 212.69,145.87 210.6,147.95 204.43,147.95 204.15,147.67 204.15,146.58 202.48,144.9 200.8,144.9 200.19,144.29 199.22,144.29 198.72,143.79 PQ40.2
  IN1 w0.127: v1(222.69,152.12) 220.28,152.12 213.7,145.54 v1(212.69,145.54)
  BOTTOM w0.114: v1(222.69,152.12) v3(222.69,153.31) 222.69,153.36 222.24,153.82 222.24,167.41 221.02,168.63 221.02,174.49 218.15,177.36 217.06,177.36 212.15,182.27 212.15,185.37 210.65,186.86 210.65,190.95 210.99,191.28 210.99,192.76 210.71,193.04 210.27,193.04 PR179.1
  BOTTOM w0.178: PU5.14 207.86,194.54 208.15,194.26 208.67,194.26 209.26,193.67 209.26,193.03 PR179.1
24780_CMSRC: length 2.3
  BOTTOM w0.178: PU5.3 205.05,198.82 205.04,198.83 205.04,199.23 205.07,199.26 PR166.2
24780_DH: length 16.3
  TOP w0.762: v4(202.3,196.22) 202.65,196.58 202.65,198.83 201.54,199.94 v3(198.36,199.94) 192.16,199.94 190.82,201.29 v4(190.82,201.95)
24780_DL: length 7.2
  BOTTOM w0.762: 195.41,194.76 195.58,194.6 197.36,194.6 v3(197.37,194.59) 197.38,194.6 200.91,194.6 201.38,194.13 202.23,194.13 202.32,194.22
24780_ILIM: length 5.1
  TOP w0.254: PR14.1 205.76,193.54 205.25,193.03 PR15.2 204.82,193.03 204.43,193.42 v1(203.72,193.42)
  BOTTOM w0.178: PU5.21 204.04,193.74 v1(203.72,193.42)
  BOTTOM w0.254: PC123.2 204.19,192.52 203.72,192.99 v1(203.72,193.42)
24780_LX: length 14.3
  TOP w0.508: PR2.1 v3(191,197.46) 191,196.64 v4(190.69,196.34)
  IN2 w0.762: v4(201.84,197) 200.29,197 198.87,195.58 195.36,195.58 194.6,196.34 v4(190.69,196.34)
24780_SRN: length 35.8
  IN2 w0.203: v1(206.72,187.83) 206.72,187.96 203.85,190.83 201.74,190.83 199.02,193.54 199,193.54 198.84,193.7 194.21,193.7 193.49,194.41 189.18,194.41 188.54,195.04 188.07,195.04 187.49,195.63 v1(187.49,195.78)
  BOTTOM w0.203: v1(187.49,195.78) 187.34,195.63 187.34,194.62 186.71,193.99 184.59,193.99 v1(184.14,193.53) 183.68,193.99 182.25,193.99 181.24,194.99 181,194.99 PR175.1 ; v1(206.72,187.83) 206.84,187.96 207.66,187.96 207.85,188.15 PC132.2 PC131.1 206.6,188.58 205.96,189.23 PR184.1
24780_SRP: length 35
  IN2 w0.203: v1(206.08,187.83) 206.08,188.12 203.71,190.5 201.56,190.5 198.69,193.37 194.07,193.37 193.36,194.08 189.04,194.08 188.4,194.71 187.87,194.71 v1(186.8,195.78)
  BOTTOM w0.203: PR176.1 182.74,194.31 183.64,194.31 v1(184.14,194.8) 184.63,194.31 186.58,194.31 187.01,194.74 187.01,195.58 v1(186.8,195.78) ; PR183.1 205.35,188.97 205.57,188.97 205.82,188.73 PC131.2 PC130.2 204.57,188.15 204.76,187.96 205.96,187.96 v1(206.08,187.83)
24780_VCC: length 4.3
  BOTTOM w0.178: PU5.28 203.19,196.94 203.03,197.1 203.03,198.04 v3(202.7,198.37) PC116.2
  BOTTOM w0.508: PC116.2 201.74,198.55 v1(201.89,198.4)
51216_DRVH: length 11.6
  IN2 w0.762: v4(178.19,65.05) 178.19,56.6 v4(175.95,54.35)
  vias: v3(175.53,53.72)
51216_DRVL: length 9
  IN2 w0.762: v4(180.71,66.17) 180.71,63.7 182.53,61.88 182.53,58.87 v4(183.22,58.18)
  vias: v1(180.94,65.53)
51216_MODE: length 2.5
  BOTTOM w0.203: PR296.2 176.36,68.11 177.02,68.11 177.09,68.04 PU15.19
51216_REF: length 3.6
  BOTTOM w0.203: PU15.6 181.44,68.44 181.61,68.6 182.11,68.6 182.96,69.46 ; 182.96,69.46 PR297.1 ; 182.96,69.46 PC238.1
51216_REFIN: length 4.5
  BOTTOM w0.203: PR297.2 183.74,67.93 183.86,67.81 PR300.1 PC239.1 182.39,67.64 PU15.8
51216_S3: length 6.6
  BOTTOM w0.114: PR298.2 172.5,67.93 v3(172.48,67.92)
  BOTTOM w0.203: PR298.2 174.42,66.96 PR301.2 174.54,66.43 PR303.2 176.42,66.43 177.23,67.24 PU15.17
51216_S5: length 4.1
  BOTTOM w0.203: PR305.2 174.61,65.65 PR303.1 176.36,65.65 v1(176.9,66.19) 177.2,66.49 177.2,66.62 177.42,66.84 PU15.16
51216_SW: length 10.3
  IN2 w0.762: v4(179.56,54.75) 179.39,54.92 v4(179.39,64.99)
  vias: v3(176.77,52.75)
51216_TRIP: length 2.2
  BOTTOM w0.203: PU15.18 v1(176.82,67.64) 175.74,67.64 PR299.2
51216_VBST:
  vias: v1(177.43,64.99)
51225_CS1: length 2.1
  TOP w0.305: PR6124.1 64.19,56.81 64.58,56.42 v1(64.58,56.43)
  BOTTOM w0.203: v1(64.58,56.43) 64.67,56.35 64.67,56.09 64.97,55.78 PU6010.1
51225_CS2: length 2.2
  TOP w0.305: v1(66.92,56.43) 66.92,56.43 67.48,56.99 PR6122.2
  BOTTOM w0.203: PU6010.5 66.57,55.77 66.84,56.04 66.84,56.36 v1(66.92,56.43)
51225_DH1: length 13.7
  IN1 w0.762: v4(58.92,42.81) 62.22,42.71 62.83,43.32 62.83,51.67 63.64,52.48 v4(63.64,52.43)
  vias: v1(63.23,51.79)
51225_DH2: length 10.9
  IN1 w0.762: v4(76.4,47.18) 75.68,47.18 72.55,50.31 69.97,50.31 v4(67.75,52.52)
  vias: v1(68.01,51.86)
51225_DL1: length 6.1
  IN1 w0.762: v4(64.4,51.96) 64.4,50.19 65.26,49.33 65.26,47.18 v4(65.95,46.49)
  vias: v1(64.4,51.28)
51225_DL2: length 5.3
  IN1 w0.762: v4(71.42,49.39) 69.61,49.39 v4(67.16,51.84)
51225_EN1: length 5.4
  BOTTOM w0.203: PU6010.20 63.82,54.72 63.02,55.52 v3(63.02,56.84) 63.02,58.3 PR6278.1
51225_FB1: length 4
  TOP w0.305: v1(65.17,56.91) 65.32,57.06 PR6120.1
  BOTTOM w0.203: PU6010.2 65.37,55.87 65.17,56.08 v1(65.17,56.91) 65.17,57.33 PR6281.1
51225_FB2: length 4.1
  TOP w0.305: PR6121.1 66.33,57.59 66.33,57.02 v1(66.44,56.91)
  BOTTOM w0.203: PR6279.2 66.42,57.47 v1(66.44,56.91) 66.38,56.87 66.38,56.11 66.17,55.91 PU6010.4
51225_SW1: length 11.2
  IN1 w0.762: v4(62.55,53.56) 60.34,51.35 60.34,45.1 v4(61.61,43.83)
  vias: v3(68.16,43.28)
51225_SW2: length 7.4
  IN1 w0.762: v4(69.01,53.65) 69.01,53.09 70.07,52.04 72.54,52.04 v4(74.57,50.01)
  vias: v3(70.62,42.41)
51225_VBST1:
  vias: v1(63.16,53.16)
51225_VBST2:
  vias: v3(68.47,53.11)
51225_VCLK: length 2.7
  BOTTOM w0.203: PU6010.19 v1(62.55,54.32) 62.43,54.44 PR6285.1
51225_VIN: length 1.4
  BOTTOM w0.203: v1(66.67,51.25) 66.17,51.75 PU6010.12
+AZA_VDD: length 7.5
  IN2 w0.508: v1(35.9,31.11) 35.01,31.11 34.51,31.62 34.51,33.14 35.29,33.93 35.29,36.85 v1(35.52,37.08)
  vias: v1(35.67,30.37)
+FB_PLLAVDD: length 19.3
  TOP w0.508: v1(169.35,162.48) 169.08,162.2 C79.1 L1.1 ; C89.2 188.34,159.52 v1(188.57,159.3) ; v1(187.73,163.44) 187.99,163.18 C76.2 187.97,162.82 C77.1
  IN2 w0.508: 181.34,162.56 175.73,162.56 174.97,163.32 173.75,163.32 173.11,162.68 169.61,162.68 169.43,162.51 169.38,162.51 v1(169.35,162.48)
  BOTTOM w0.305: v1(181.92,163.49) 181.94,163.49 U34.P22
  BOTTOM w0.381: v1(188.57,159.3) 188.57,159.29 U34.F16 ; U34.H22 187.29,163.87 v1(187.73,163.44)
+G_SEN_PW: length 36.8
  TOP w0.254: U19.14 203.56,61.98 C412.1 ; U19.1 198.23,58.3 C428.1 ; v1(204.3,52.45) 204.3,52.57 203.56,53.32 U19.8
  TOP w0.508: C428.1 198.22,58.86 v1(198.64,59.28) 198.72,59.36 198.72,61.44 v3(199.75,62.48) 203.06,62.48 C412.1 R318.2 ; R333.2 v1(197.44,53.97) 197.69,53.97 R334.2
  IN1 w0.508: v1(204.3,52.45) 203.8,52.95 198.84,52.95 197.83,53.97 v1(197.44,53.97) 197.44,54.36 198.01,54.93 198.01,57.2 198.64,57.83 v1(198.64,59.28)
+SMDDR_VREF_DIMM: length 4.8
  BOTTOM w0.305: 141.14,58.69 JDIM1.126 ; v1(141.14,48.66) JDIM2.126
  BOTTOM w0.508: v1(142.57,58.13) 141.7,58.13 141.14,58.69
  vias: v3(142.66,55.29)
+SMDDR_VREF_DQ0: length 1.6
  BOTTOM w0.356: JDIM2.1 101.24,56.07 100.93,56.38 v1(100.55,56.38)
  vias: v3(98.18,55.01)
+SMDDR_VREF_DQ1: length 1.7
  BOTTOM w0.305: v1(100.72,69.93) 101.24,69.41 JDIM1.1
  vias: v3(96.86,68.86)
+TPVDD: length 10.7
  TOP w0.508: v1(201.33,18.49) 201.33,17.93 202.88,16.38 205.83,16.38 207.07,17.62 R409.2 207.61,19.75 207.63,19.72 R410.2
  vias: v3(203.06,21.59)
+VGPU_CORE: length 14.4
  TOP w0.508: v1(186.4,134.39) 186.27,134.51 PR64.1 185.87,135.01 185.37,135.51 R123.1
  BOTTOM w0.254: v1(180.43,151.89) 180.43,152.52 v1(180.45,152.55)
  BOTTOM w0.381: U34.N15 U34.P14 U34.N13 ; U34.N15 183.33,158.25 ; U34.N15 U34.M14 184.34,157.22 ; U34.M10 184.35,153.22 v1(185.03,152.55) ; 185.33,156.23 U34.L13 U34.K12 186.34,155.22 ; U34.K18 186.93,160.63 v1(186.93,160.27) 186.93,159.82 U34.K16 ; U34.R15 U34.T16
  vias: v1(177.76,155.82) v1(177.89,159.63) v1(177.86,157.7) v1(177.89,153.79) v1(178.88,160.57) v1(178.85,156.87) v1(178.85,141.5) v1(179.44,152.19) v1(179.51,141.47) v1(179.84,155.72) v1(179.82,153.69) v1(179.77,151.63) v1(180.12,145.61) v1(180.07,144.32) v1(180.07,143.4) v1(180.86,160.57) v1(181.78,159.66) v1(181.78,157.63) v1(181.8,155.67) v1(181.85,153.72) v1(182.71,152.14) v1(182.84,158.75) v1(182.84,154.55) v1(182.89,160.8) v1(183.22,152.55) v1(183.84,155.73) v1(183.96,159.76) v1(184.82,156.74) v1(184.85,158.54) v1(185.86,159.74) v1(185.94,157.73) v1(185.92,153.74) v1(186.78,158.67) v1(186.78,154.78) v1(187.01,156.56) v3(200.57,132.48) v4(185,130.42) v4(185,129.54) v4(185.76,131.19) v4(185.76,130.42) v4(185.76,129.54) v4(186.65,132.08) v4(186.65,131.19) v4(186.65,130.3) v4(186.65,129.41) v4(186.65,128.65) v4(187.56,131.27) v4(187.56,130.13) v4(187.56,128.98) v4(188.18,130.68) v4(188.18,129.54) v4(188.7,131.27) v4(188.7,130.13) v4(188.7,128.98) v4(189.19,129.54) v4(189.32,130.68) v4(189.84,131.27) v4(189.84,130.13) v4(189.84,128.98) v4(190.72,128.9) v4(191.48,128.9) v4(191.48,128.14) v4(191.48,127.38) v4(192.24,128.9) v4(192.24,128.14) v4(192.24,127.38) v4(193,128.52) v4(193.69,131.3) v4(193.69,130.16) v4(193.69,129.02) v4(193.69,127.87) v4(194.83,131.3) v4(194.83,130.16) v4(194.83,129.02) v4(194.83,127.87) v4(195.97,131.3) v4(195.97,130.16) v4(195.97,129.02) v4(195.97,127.87) v4(196.3,132.08) v4(197.12,131.3) v4(197.12,130.16) v4(197.12,129.02) v4(197.12,127.87) v4(197.19,132.08) v4(197.27,133.09) v4(198.08,132.08) v4(198.26,131.3) v4(198.26,130.16) v4(198.26,129.02) v4(198.26,127.87) v4(199.4,127.87) v4(200.55,127.87) v4(201.69,127.87) v4(201.89,131.19) v4(201.89,130.42) v4(201.89,129.66) v4(201.89,128.77) v4(202.83,131.3) v4(202.83,130.16) v4(202.83,129.02) v4(202.83,127.87) v4(203.97,131.3) v4(203.97,130.16) v4(203.97,129.02) v4(203.97,127.87) v4(204.81,128.52) v4(204.81,127.76) v4(205.57,128.52) v4(205.57,127.76)
+VREF_CA_CPU: length 129.6
  TOP w0.508: R362.2 135.98,42.97 134.33,44.62 v1(134.33,45.21)
  IN1 w0.381: 111.98,106.75 111.98,107.18 112.74,107.95 113.71,107.95 115.87,110.1 118.57,110.1 v2(118.95,110.49)
  IN1 w0.508: v1(134.33,45.21) 134.33,45.46 133.08,46.71 101.84,46.71 95.47,53.09 95.47,53.97 92.42,57.02 92.42,61.21 93.05,61.84 93.05,73.91 92.7,74.27 v1(92.49,74.27) ; v1(111.87,106.65) 111.98,106.75
  BOTTOM w0.254: v2(118.95,110.49) 118.95,110.16 118.59,109.81 U35.AY67
  BOTTOM w0.508: v1(92.49,74.27) 91.88,74.88 91.88,75.84 88.4,79.32 88.4,87.18 89.94,88.72 92.72,88.72 93.43,89.43 98.04,89.43 104.23,95.62 104.23,102.23 108.33,106.34 111.56,106.34 v1(111.87,106.65)
+VREFDQ_SA_M3: length 82.3
  TOP w0.508: v1(94.07,74.98) 94.7,74.98 95.03,75.31 98.39,75.31 101.69,72 101.69,69.34 92.16,59.81 R327.2
  IN1 w0.381: v1(112.69,106.6) 112.74,106.65 112.74,107.06 113.16,107.48 113.91,107.48 115.85,109.42 v2(117.3,109.42)
  BOTTOM w0.254: U35.AY68 117.41,109.36 117.32,109.45 v2(117.3,109.42)
  BOTTOM w0.508: v1(112.69,106.6) 112.69,106.29 112.09,105.7 108.6,105.7 104.99,102.09 104.99,95.48 98.3,88.79 94.36,88.79 93.65,88.08 90.21,88.08 89.26,87.13 89.26,80.4 v3(89.75,79.9) 91.4,78.25 91.4,78.23 92.56,77.07 92.56,75.83 93.41,74.98 v1(94.07,74.98)
+VREFDQ_SB_M3: length 52.8
  TOP w0.508: v1(95.72,90.06) 95.72,90.04 95.22,89.54 95.22,77.5 94.42,76.7 94.42,76.25 93.31,75.13 93.31,74.52 93.56,74.27 R302.2
  IN1 w0.381: v1(113.42,106.55) 113.8,106.93 114.06,106.93 115.02,107.9 115.91,107.9 116.86,108.85 v2(117.99,108.85)
  BOTTOM w0.305: U35.BA67 118.11,108.97 v2(117.99,108.85)
  BOTTOM w0.508: v1(113.42,106.55) 113.42,106.85 113,107.27 111.42,107.27 111.11,106.97 107.95,106.97 103.47,102.48 103.47,95.75 97.78,90.06 v1(96.89,90.06) v1(95.72,90.06)
+WL_VDD: length 15.4
  TOP w0.508: v1(183.35,94.61) R242.2
  IN2 w0.508: v1(183.35,94.61) 187.41,90.55 v1(190.97,90.55)
  BOTTOM w0.508: R714.2 193.5,85.85 191.86,85.85 191.48,86.23 191.48,89.01 C755.1
  vias: v1(189.45,103.68) v1(190.08,103.68) v1(190.97,89.53) v3(190.13,104.67)
ACCEL_INT2: length 25.5
  TOP w0.254: v1(210.65,53.74) 209.16,53.74 208.54,53.13 D35.1 ; R326.1 222.01,59.46 218.99,62.48 v1(214.24,62.48)
  BOTTOM w0.254: v1(210.65,53.74) v3(209.97,54.43) 209.72,54.68 209.72,60.02 212.18,62.48 v1(214.24,62.48)
ACCEL_INT2_R: length 6.3
  TOP w0.114: v3(209.54,54.33) 208.98,54.33 208.24,55.06 D35.2
  TOP w0.254: U19.9 207.69,56.3 D35.2
ACCEL_INTA: length 100.3
  TOP w0.114: D8.1 209.11,59.97 209.13,59.95 C425.2 209.77,61.08 203.91,66.94 v3(203.91,67.47) 202.55,68.83 v1(194.17,68.83)
  IN1 w0.127: v1(157.44,119.05) 157.9,118.59 158.58,118.59 158.81,118.36 163.39,118.36 163.69,118.66 164.2,118.66 164.76,118.11 170.35,118.11 170.95,117.5 170.95,115.95 171.3,115.6 171.31,115.6 171.58,115.34 173.06,115.34 173.33,115.6 174.45,115.6 175.08,114.97 175.08,112.91 174.69,112.52 174.69,108.86 175.6,107.95 175.6,106.42 179.43,102.6 179.43,102.02 179.39,101.98 179.39,98.57 178.68,97.86 178.68,91.66 179.36,90.98 179.36,88.47 182.37,85.46 182.37,82.97 184.44,80.9 184.44,80.01 187.14,77.31 190.61,77.31 193.65,74.27 193.65,69.35 v1(194.17,68.83)
  BOTTOM w0.076: U35.AB1 157.01,119.48 v1(157.44,119.05)
ACCEL_INTA_R: length 6.5
  TOP w0.114: D8.2 208.24,56.76 208.42,56.59 208.85,56.59 v3(209.87,55.57)
  TOP w0.254: D8.2 208.19,57.3 U19.11
ACIN: length 222.7
  TOP w0.254: v1(207.53,199.39) 207.27,199.12 PR1.2 206.87,198.95 207.28,198.55 207.73,198.55 v1(208.04,198.85) 208.39,198.5 PR4.1
  IN1 w0.254: v1(207.35,64.26) 207.35,61.35 208.1,60.6 208.1,53.89 205.96,51.74 205.96,49.91 205.19,49.14 205.19,47.46 202.77,45.03 202.77,39.16 v1(203.17,38.76)
  IN2 w0.254: v1(207.35,64.26) 207.35,64.61 208.15,65.41 211.87,65.41 216.52,70.07 216.52,87.85 222.47,93.8 224.79,93.8 227.32,96.33 227.32,98.89 219.84,106.37 215.43,106.37 213.07,108.73 213.07,114.63 210.64,117.05 210.64,120.75 209.79,121.6 209.79,132.05 208.75,133.09 208.75,140.58 208.43,140.91 208.43,144.48 210.29,146.34 214.78,146.34 222.87,154.43 222.87,165.69 221.36,167.21 221.36,179.67 213.58,187.45 213.58,190.07 210.38,193.27 210.38,200.3 209.77,200.91 209.26,200.91 v1(208.75,201.42)
  BOTTOM w0.203: U45.72 193.06,34.31 193.13,34.39 193.84,34.39
  BOTTOM w0.254: 193.84,34.39 194.25,34.39 195.41,35.56 197.58,35.56 197.84,35.3 198.25,35.3 201.71,38.76 v1(203.17,38.76) ; v1(208.75,201.42) 207.68,201.42 207.48,201.21 PR167.1 207.83,200.79 207.99,200.63 207.99,199.64 207.73,199.39 v1(207.53,199.39)
ACPRESENT: length 100.9
  IN2 w0.127: v1(180.56,81.91) 185.31,77.16 192.29,77.16 193.43,76.02 193.43,60.7 192.7,59.97 192.7,52.85 194.32,51.23 194.32,50.08 194.75,49.65 194.75,48.99 194.46,48.7 194.46,47.94 196.62,45.79 198.75,45.79 199.36,45.18 200.96,45.18 201.31,44.83 201.33,44.83 201.61,44.55 201.61,43.07 198.97,40.43 198.97,38.73 v1(199.15,38.55)
  BOTTOM w0.114: U45.84 193,39.11 193.25,39.37 193.43,39.37 194.45,38.35 195.29,38.35 195.67,38.73 198.97,38.73 v1(199.15,38.55) ; R676.1 156.55,95.88 158.2,94.24 160.85,94.24 161.14,93.95 161.14,91.32 163.24,89.22 163.53,89.22 166.87,85.88 171.09,85.88 172.17,84.8 176.78,84.8 178.4,83.18 179.29,83.18 v3(179.67,82.8) v1(180.56,81.91)
ACZ_SDIN: length 12.1
  TOP w0.114: U23.8 32,38.19 31.61,38.58 31.61,40.28 32.85,41.52 33.87,41.52 34.94,42.59 v3(35.83,42.59) 36.46,42.59 36.66,42.79 37.81,42.79 38.43,43.42 R359.1
ADOGND: length 28.5
  TOP w0.203: v1(29.76,30.8) 29.76,30.54 29.89,30.4 30.34,30.4 30.4,30.46 U23.25 ; U23.38 36.26,32.1 36.39,31.97 37.1,31.97 v1(37.68,31.39)
  TOP w0.457: v1(29.81,26.79) 29.81,27.55 R397.1 ; v1(30.44,26.79) 30.44,27.05 30.95,27.55 C535.1 ; v1(28.92,26.79) C534.2 ; C520.2 v1(40.86,32.25)
  TOP w0.508: C553.2 14.08,12.67 v1(14.31,12.44) 14.74,12.02 C554.2 ; R375.1 v1(27.77,37.33) ; R400.1 16.09,26.01 v1(15.74,25.65) ; C523.1 40.98,32.13 v1(40.86,32.25) ; C526.2 41.25,30.98 v1(40.98,31.25) ; v1(41.19,28.32) 41.19,28.06 41.43,27.82 C537.1 ; R423.2 v1(16.12,14.73) ; R399.1 15.1,26.25 15.1,25.24 v1(15.2,25.14) ; v1(26,29.33) 26.01,29.33 26.24,29.1 C532.2 C536.2 ; R401.2 35.78,26.85 v1(36.16,27.23) ; C529.1 39.33,28.98 v1(39.08,28.72) ; C538.1 42.64,28.19 v1(42.38,28.19) ; C519.2 26.39,31.36 v1(26.38,31.36) ; v1(40.73,30.48) 40.73,30.6 40.23,31.1 C524.2 ; v1(40.73,29.71) 40.98,29.71 41.24,29.97 R390.1 ; R393.1 21.58,28.61 R394.1 23.93,28.61 v1(24.52,29.21)
  BOTTOM w0.508: R750.1 v3(32.73,29.66) 32.73,29.21 32.22,28.7 31.71,28.7 v1(31.58,28.57)
  vias: v1(3.85,10.15) v1(8.16,10.18) v1(11.49,19.4) v1(11.72,16.12) v1(11.75,12.67) v1(11.98,10.77) v1(14.31,18.66) v1(14.31,18.03) v3(14.72,14.65)
ALERT: length 14.5
  BOTTOM w0.114: U34.F8 188.99,152.19 189.4,151.79 189.4,148.81 189.12,148.54 188.76,148.54 188.53,148.31 188.53,147.93 188.33,147.72 187.95,147.72 187.74,147.52 187.74,145.93 186.19,144.37 185.51,144.37 182.75,141.61 R511.1
AMP_MUTE#: length 167.2
  TOP w0.114: D16.1 44.92,37.71 44.41,37.21 v1(44.41,37.08)
  IN2 w0.127: v1(44.41,37.08) 50.58,30.91 53.51,30.91 55.11,29.31 56.4,29.31 56.88,28.82 68.19,28.82 68.95,29.59 88.25,29.59 89.47,30.81 94.65,30.81 95.24,30.22 171.58,30.22 172.52,31.16 172.52,31.76 181.42,40.66 188.79,40.66 191.71,43.58 194.81,43.58 195.03,43.81 197.78,43.81 v1(198.13,44.17)
  BOTTOM w0.114: v1(198.13,44.17) 198.31,44.35 U45.108
APS1: length 3.6
  TOP w0.114: CN2.1 176.81,79.21 175.85,78.25 R289.2 R291.2
APS3: length 13.4
  TOP w0.114: R272.2 171.79,81.76 R278.1 ; R278.1 172.31,80.55 v3(172.31,79.75) 172.31,79.4 172.89,78.82 172.89,77.77 173.11,77.54 173.65,77.54 174.23,78.13 R289.1 ; R278.1 172.94,80.62 172.94,80.04 173.6,79.37 174.03,79.37 174.87,80.21 CN2.3
APS7: length 8.8
  TOP w0.114: CN2.7 176.93,82.21 176.21,82.93 176.11,82.93 175.48,83.56 v1(173.7,83.56) 173.36,83.56 172.94,83.98 172.94,84.34 172.69,84.58 172.34,84.58 171.79,84.04 R272.1 R271.1
APW8824_1.8V:
  vias: v3(100.93,139.19)
BAT-V: length 5.8
  BOTTOM w0.178: PR175.2 180.99,196.14 180.99,196.26 179.64,197.61 179.03,197.61 178.71,197.93 178.71,199.58 178.4,199.89 PR169.2
  vias: v3(172.3,193.01)
BATLED0#: length 186.6
  TOP w0.508: v1(66.79,10.46) 66.79,10.55 R428.1 67.53,11.04 67.53,10.04 R430.1
  IN1 w0.127: v1(211.06,31.31) 211.24,31.14 211.24,24.66 211.63,24.27 211.63,20.15 207.2,15.72 197.96,15.72 197.66,16.02 194.55,16.02 193.26,14.73 193.26,11.26 192.29,10.29 175.9,10.29 166.94,19.25 165.47,19.25 165.42,19.3 129.04,19.3 119.23,29.12 99.6,29.12 97.14,26.66 90.12,26.66 85.13,21.66 84.27,21.66 83.86,21.25 v1(83.86,20.67)
  IN2 w0.127: v1(83.86,20.67) 83.3,20.11 83.3,17.29 78.37,12.37 71.69,12.37 69.79,10.46 v1(66.79,10.46)
  BOTTOM w0.114: U45.29 209.36,32.71 209.92,32.15 v3(209.92,31.36) 209.97,31.31 v1(211.06,31.31)
BATLED1#: length 177.8
  TOP w0.508: R431.1 R429.1 69.06,11.16 69.2,11.02 v3(70.37,11.02) 71.18,11.02 v1(71.34,10.87)
  IN1 w0.127: v1(71.34,10.87) 72.64,12.18 75.29,12.18 80.11,17 80.11,20.2 83.53,23.62 86.37,23.62 89.91,27.16 96.93,27.16 99.43,29.66 119.98,29.66 129.65,19.99 191.06,19.99 194.52,16.53 197.99,16.53 198.26,16.25 206.94,16.25 211.12,20.43 211.12,23.94 209.51,25.55 209.51,26.64 207.65,28.5 207.65,29.37 207,30.02 207,33.19 v1(206.49,33.7)
  BOTTOM w0.114: U45.25 207.15,34.31 206.54,33.7 v1(206.49,33.7)
BEEP_1: length 4.4
  TOP w0.114: v3(34.56,46.83) 34.58,46.86 R352.1 R354.2 35.64,45.39 35.52,45.27 C476.2 C477.1
BI: length 158.4
  TOP w0.114: PR10.2 164.3,195.32 v1(163.92,194.94)
  IN1 w0.127: v1(206.84,80.26) 207.23,80.64 207.23,89.53 206.29,90.47 196.76,90.47 196.2,91.03 196.2,96.47 196.56,96.82 196.56,97.48 194.14,99.89 194.14,107.82 194.02,107.95 194.02,108 188.23,113.79 187.17,113.79 185.43,115.53 185.43,115.57 184.21,116.79 184.21,123.31 184.54,123.64 185.25,123.64 185.84,124.23 185.84,125.14 183.86,127.12 183.86,133.58 176.63,140.81 170.62,140.81 166.71,144.73 166.71,145.28 166.03,145.97 165.27,145.97 164.86,146.38 164.86,148.46 165.44,149.04 165.44,150.41 166.08,151.05 166.89,151.05 169.25,153.41 170.14,153.41 170.74,154.01 170.74,156.29 170.31,156.72 170.31,159.46 168.74,161.03 168.74,161.38 166.94,163.19 166.08,163.19 165.82,163.44 165.82,169.92 165.06,170.68 165.06,175.64 165.66,176.24 165.66,181.1 163.28,183.48 163.28,191.26 v1(163.16,191.38)
  BOTTOM w0.114: Q40.3 207.61,77.21 207.1,77.72 207.1,80.01 v1(206.84,80.26) ; v1(163.16,191.38) 163.16,191.77 v3(163.59,192.2) 164.24,192.85 PJ1.6 164.24,194.62 v1(163.92,194.94)
BI_GATE: length 19.4
  BOTTOM w0.114: C765.1 212.53,77.82 212.81,78.1 213.83,78.1 214.49,78.77 SW1.3 SW1.4 208.29,78.05 v1(208.35,77.99) Q40.2 210.15,76.7 211.04,75.81 R719.2 212.3,74.93 Q56.5
BL#: length 5.1
  TOP w0.127: Q3.2 112.23,177.5 111.85,177.88 111.85,178.66 112.1,178.91 R52.1 111.97,179.18 111.58,178.8 Q3.3
BL_ON: length 37.3
  TOP w0.114: v1(136.23,187.19) 136.23,186.69 135.98,186.43 v3(134.84,186.43) 133.82,185.42 133.82,185.17 132.52,183.87 130.5,183.87 129.63,183 119.47,183 117.94,181.48 117.94,181.22 117.13,180.41 117.13,179.85 116.67,179.4 116.67,177.29 116.41,177.03 R58.1 116.08,177.11 D1.2 114.77,176.14 115.28,175.64 Q4.3 114.24,175.05 113.23,174.04 113.04,174.04 112.88,174.2 Q3.6
  BOTTOM w0.114: v1(136.23,187.19) 135.98,187.45 135.55,187.45 134.34,188.65 134.34,188.88 CN5.26
BOARD_ID0: length 13.9
  BOTTOM w0.076: U35.AN3 155.39,113.51 155.6,113.72 155.73,113.78 155.94,113.78 156.02,113.74 156.3,113.74 156.39,113.78 156.58,113.78 156.67,113.74 157.43,113.74 157.72,113.46 159.53,113.46 159.99,113.91 160.36,113.91
  BOTTOM w0.114: 160.36,113.91 160.74,113.91 161.32,114.49 162.48,114.49 162.49,114.49 162.85,114.49 162.85,114.49 165.22,114.49 165.23,114.5 165.23,114.5 R595.2 166.2,114.55 167.22,114.55 167.72,114.05 R600.1
BOARD_ID1: length 8.1
  BOTTOM w0.076: 160.36,113.69 159.99,113.69 159.6,113.29 157.65,113.29 157.42,113.52 156.49,113.52 U35.AN1
  BOTTOM w0.114: 160.36,113.69 161.05,113.69 161.43,114.07 R598.2 162.06,113.63 163.46,113.63 163.66,113.83 R599.1
BOARD_ID2: length 12.9
  BOTTOM w0.076: 160.36,113.46 160.03,113.46 159.7,113.13 157.58,113.13 157.4,113.3 156.72,113.3 156.59,113.24 156.38,113.24 156.29,113.28 156.07,113.28 U35.AN2
  BOTTOM w0.114: R608.1 167.41,112.46 166.12,112.46 R605.2 165.69,113.14 165.37,113.46 164.32,113.46 164.26,113.4 161.3,113.4 161.25,113.46 160.36,113.46
BOARD_ID3: length 10.4
  BOTTOM w0.076: 160.36,114.16 159.99,114.16 159.46,113.62 157.78,113.62 157.43,113.97 157.03,113.97 156.96,113.91 156.7,113.91 156.59,113.96 156.37,113.96 156.27,113.91 156.06,113.91 155.98,113.94 155.69,113.94 155.5,113.85 155.18,113.85 U35.AM4
  BOTTOM w0.114: 160.36,114.16 160.63,114.16 161.54,115.06 R592.2 162.09,114.72 163.46,114.72 163.66,114.92 R590.1
BOARD_ID4: length 125.8
  IN1 w0.127: v1(146.85,195.8) 146.85,193.85 147.47,193.23 150.72,193.23 151.99,191.96 155.96,191.96 160.62,187.3 160.62,185.66 165.41,180.86 165.41,176.59 164.55,175.74 164.55,170.81 165.57,169.79 165.57,158.91 167.26,157.22 167.26,152.59 166.68,152.01 165.72,152.01 164.64,150.93 164.64,149.63 164.08,149.08 164.08,144.13 169.75,138.46 172.54,138.46 173.95,137.05 v1(173.95,136.52)
  BOTTOM w0.076: U35.AM1 156.91,114.28 157.05,114.28 157.18,114.41 158.98,114.41 159.12,114.55 159.94,114.55 160.07,114.42 160.36,114.42
  BOTTOM w0.114: C803.2 146.89,197.1 147.16,196.83 R441.1 146.85,196.13 v1(146.85,195.8) ; 160.36,114.42 160.53,114.42 161.21,115.1 161.21,115.51 161.31,115.61 164.47,115.61 164.55,115.69 165.83,115.69 R593.1 166.75,114.78 167.37,114.78 167.73,114.42 169.25,114.42 169.79,114.96 169.79,115.69 170.9,116.8 172.46,116.8 173.76,118.11 v3(175.78,118.11) 175.86,118.11 177.5,119.75 177.5,123.63 177.96,124.09 177.96,128.9 177.31,129.55 177.31,130.72 175.56,132.47 175.56,134.77 173.95,136.38 v1(173.95,136.52)
BOARD_ID4_TOUCH_S: length 6.2
  BOTTOM w0.114: R441.2 v3(145.26,196.46) 145.05,196.46 143.7,197.81 142.76,197.81 142.58,197.63 142.58,197.19 142.85,196.92 143.12,196.92 143.56,196.48 CN5.2
BOARD_ID5: length 13.7
  BOTTOM w0.076: 160.36,114.8 159.14,114.8 158.92,114.58 157.11,114.58 156.98,114.44 156.71,114.44 156.63,114.4 156.39,114.4 U35.AM2
  BOTTOM w0.114: R607.1 167.6,115.3 167.6,115.83 R606.2 166.85,115.57 166.33,115.57 165.98,115.92 164.46,115.92 164.38,115.84 161.22,115.84 160.95,115.57 160.95,115.49 v1(160.64,115.18) 160.64,114.98 160.46,114.8 160.36,114.8
BOARD_ID6: length 9.6
  TOP w0.114: R765.1 162.73,117.17 161.12,117.17 R764.2 159.98,116.03 v1(159.98,115.77)
  BOTTOM w0.076: v1(159.98,115.77) 159.98,115.64 159.37,115.03 159.12,115.03 158.84,114.75 156.96,114.75 156.84,114.63 156.72,114.63 156.59,114.57 156.17,114.57 156.04,114.44 155.77,114.44 U35.AM3
BOARD_ID7: length 9.6
  BOTTOM w0.076: U35.AP4 155.12,113.11 155.61,113.11 155.73,113.06 155.94,113.06 156.05,113.11 156.26,113.11 156.34,113.08 156.63,113.08 156.71,113.12 157.1,113.12 157.15,113.06 157.41,113.06 157.51,112.96 159.77,112.96 160.04,113.23 160.36,113.23
  BOTTOM w0.114: 160.36,113.23 160.63,113.23 160.88,112.98 R766.2 161.95,112.5 163.18,112.5 R767.1
BT_EN: length 81.1
  BOTTOM w0.114: CN10.54 189.42,95.48 190.35,96.4 190.55,96.4 190.79,96.64 192.49,96.64 193.03,96.11 v1(193.23,96.11) 195.16,96.11 198.67,92.6 198.67,82.24 197.47,81.05 197.47,72.97 197.15,72.65 197.15,71.78 198.8,70.13 198.8,66.25 199.61,65.44 199.61,63.8 196.89,61.09 196.89,56.4 194.78,54.29 192.29,54.29 188.04,50.05 188.04,46.97 185.99,44.92 185.99,42.29 187.72,40.56 190.69,40.56 191.05,40.2 191.05,39.57 191.2,39.42 191.2,38.48 191.36,38.31 U45.82
BXTALOUT: length 14.7
  BOTTOM w0.102: 194.48,150.23 194.45,150.26 194.45,151.37 193.17,152.65 193,152.65 192.63,153.02 192.63,153.19 192.28,153.55 191.79,153.55 U34.C10
  BOTTOM w0.114: 194.48,150.23 195.99,148.72 195.99,142.41 195.55,141.97 R504.1
C_PEG_TX0: length 9.5
  BOTTOM w0.076: 152.14,134.76 152.13,134.75 152.13,134.69 151.89,134.46 151.89,134 150.73,132.84 148.73,132.84 147.47,131.58 147.47,130.77 147.42,130.72 147.26,130.72 147.2,130.77 U35.A17
  BOTTOM w0.114: 152.14,134.76 152.76,135.38 152.76,135.9 152.65,136 C652.2
C_PEG_TX1: length 12.5
  BOTTOM w0.076: U35.C16 147.9,130.1 147.9,131.17 149.16,132.43 150.91,132.43 152.66,134.18 152.66,134.23 152.66,134.24
  BOTTOM w0.114: C655.2 153.56,138.3 153.86,138.3 153.95,138.21 153.95,138.01 153.82,137.88 153.82,135.4 152.66,134.24
C_PEG_TX2: length 12.7
  BOTTOM w0.076: 151.7,135 151.7,134.93 151.66,134.89 151.66,134.17 150.63,133.14 148.43,133.14 146.93,131.64 146.93,130.82 146.96,130.76 146.96,130.47 146.93,130.42 146.92,130.39 146.92,130.21 146.97,130.09 146.97,130.09 146.99,130.05 146.99,129.71 147.05,129.64 U35.C17
  BOTTOM w0.114: C662.2 151.95,138.25 151.7,138.25 151.52,138.07 151.52,137.71 151.7,137.54 151.7,135
C_PEG_TX3: length 9.3
  BOTTOM w0.076: U35.A19 145.85,130.68 145.78,130.6 145.65,130.6 145.53,130.72 145.53,133.03 145.57,133.07 145.57,133.09
  BOTTOM w0.114: C660.2 146.36,138.67 145.22,137.54 145.22,133.94 145.57,133.6 145.57,133.09
C_PEG_TX#0: length 9.5
  BOTTOM w0.076: U35.B17 147.2,130.47 147.28,130.55 147.49,130.55 147.64,130.7 147.64,131.51 148.8,132.67 150.8,132.67 152.06,133.93 152.06,134.39 152.24,134.58 152.3,134.58 152.31,134.59
  BOTTOM w0.114: 152.31,134.59 153,135.28 153,135.75 C653.1
C_PEG_TX#1: length 12.6
  BOTTOM w0.076: U35.D16 147.77,129.48 148.06,129.78 148.06,131.1 149.22,132.27 150.98,132.27 152.78,134.07 152.83,134.07
  BOTTOM w0.114: 152.83,134.07 154.06,135.3 154.06,137.78 C656.2
C_PEG_TX#2: length 12.7
  BOTTOM w0.076: 151.46,135 151.46,134.93 151.5,134.89 151.5,134.24 150.57,133.31 148.36,133.31 146.77,131.71 146.77,130.79 146.79,130.74 146.79,130.72 146.79,130.51 146.76,130.43 146.76,130.18 146.8,130.07 146.82,130.02 146.82,129.64 146.93,129.54 146.93,129.27 U35.D17
  BOTTOM w0.114: 151.46,135 151.46,137.44 151.28,137.61 151.28,137.9 C661.2
C_PEG_TX#3: length 9.3
  BOTTOM w0.076: 145.33,133.09 145.33,133.07 145.36,133.03 145.36,130.65 145.58,130.44 145.71,130.44 U35.B19
  BOTTOM w0.114: C654.2 145.54,138.67 145.64,138.57 145.64,138.29 144.98,137.64 144.98,133.84 145.33,133.5 145.33,133.09
CATERR#: length 15.4
  BOTTOM w0.076: 119.75,134.36 119.8,134.31 119.8,133.93 121.18,132.55 121.18,132.04 121.52,131.7 121.52,130.87 121.46,130.7 121.46,130.56 121.52,130.33 121.52,130.2 121.37,129.86 121.37,129.29 U35.D63
  BOTTOM w0.114: 119.75,134.36 119.29,134.82 TP65.1 118.58,135.61 118.58,139.29 117.75,140.12 117.75,141.56 118.28,142.08 R788.2
CCD_PWR:
  vias: v1(129.88,189.48) v1(130.52,189.48) v3(130.85,192.32)
CFG4: length 4.5
  BOTTOM w0.076: 115.51,128.26 116.46,128.26 U35.E70
  BOTTOM w0.114: R548.1 113.67,128.26 115.51,128.26
CFG_RCOMP: length 14
  TOP w0.508: v1(115,131.11) 114.96,131.07 R156.2
  IN1 w0.508: v1(115,131.11) 116.18,132.29 119.44,132.29 119.81,131.92 119.81,131.23 120.95,130.08 122.22,130.08 122.69,129.62 v2(122.69,127.25)
  BOTTOM w0.305: U35.E60 122.57,127.73 122.57,127.36 122.68,127.24 v2(122.69,127.25)
CL_CLK: length 7.5
  BOTTOM w0.076: 159.85,128.65 158.5,128.65 157.01,127.16 156.73,127.16 156.52,127.24 156.07,127.13 155.51,127.4 U35.G3
  BOTTOM w0.114: 159.85,128.65 161.89,128.65 TP68.1
CL_DAT: length 5.5
  BOTTOM w0.076: 159.22,129.79 158.89,129.79 157.16,128.06 157.07,127.89 156.93,127.75 156.45,127.63 U35.G2
  BOTTOM w0.114: TP66.1 160.36,129.79 159.22,129.79
CL_RST#: length 8.4
  BOTTOM w0.076: 159.45,129.56 158.99,129.56 156.86,127.43 U35.G1
  BOTTOM w0.114: 159.45,129.56 160.87,129.56 161.93,130.62 161.93,131.74 TP67.1
CLK_PCI_EC: length 130.6
  TOP w0.114: R373.2 207.49,37.71 206.46,37.71 206.21,37.97 v1(205.96,37.97)
  IN2 w0.127: v1(165.27,49.75) 165.27,49.91 165.26,49.91 165.26,65.38 165.48,65.6 165.48,70.63 164.36,71.76 164.36,76.22 164.02,76.56 164.02,80.73 163.86,80.89 163.86,89.26 164.13,89.54 164.13,89.99 165.57,91.43 165.57,92.73 166.24,93.4 167.39,93.4 168.55,94.57 168.55,95.94 167.79,96.71 167.79,98.1 167.28,98.61 167.28,102.96 163.86,106.39 163.86,107.51 163.67,107.7 163.67,108.14 v5(163.03,108.78)
  BOTTOM w0.114: v1(165.27,49.75) 165.65,49.75 165.93,49.48 168.24,49.48 169.89,47.82 169.89,37.1 175.1,31.88 178.89,31.88 180.62,30.16 185.83,30.16 186.09,30.43 188.93,30.43 190.31,29.04 192,29.04 193.71,30.75 193.71,30.75 196.18,33.22 197.63,33.22 197.98,33.58 198.93,33.58 201.7,36.35 203.36,36.35 203.53,36.52 203.55,36.52 203.56,36.51 204.02,36.51 205.48,37.97 v1(205.96,37.97) 205.96,38.6 206.47,39.11 U45.13 ; R623.1 162.95,108.71 v5(163.03,108.78)
CLK_PCI_LPC: length 33.9
  IN1 w0.127: v1(173.06,91.51) 173.06,91.56 173.32,91.82 173.32,92.83 173.04,93.11 172.78,93.11 172.43,93.47 172.43,93.84 171.83,94.44 171.24,94.44 171.16,94.52 171.16,94.79 171.6,95.24 171.6,96.96 170.76,97.8 170.76,98.93 170.62,99.08 170.19,99.08 170.04,99.23 170.04,99.44 170.19,99.59 170.62,99.59 170.76,99.74 170.76,99.87 169,101.63 169,101.78 169.13,101.91 169.34,101.91 169.49,102.05 169.49,102.26 169.34,102.41 168.9,102.41 168.75,102.56 168.75,102.81 168.91,102.97 169.89,102.97 170.05,103.13 170.05,103.3 169.84,103.5 169.24,103.5 169.11,103.63 169.11,103.84 169.47,104.2 169.47,104.41 169.32,104.56 169.11,104.56 168.7,104.15 168.46,104.15 168.31,104.3 168.31,104.48 168.75,104.92 168.75,105.13 168.6,105.28 168.39,105.28 168.03,104.92 167.82,104.92 167.67,105.07 167.67,105.28 168.03,105.64 168.03,105.85 167.89,106 167.68,106 167.31,105.64 167.1,105.64 166.79,105.95 166.17,105.95 165.95,106.17 165.95,106.28 167.09,107.43 v1(167.09,107.67)
  BOTTOM w0.114: R627.1 167.07,107.69 v1(167.09,107.67) ; v1(173.06,91.51) 173.29,91.74 v3(175.17,91.74) 176.01,91.74 176.19,91.56 176.86,91.56 R694.2

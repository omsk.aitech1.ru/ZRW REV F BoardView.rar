# Allegro board Quanta ZRW REV F - BoardView (.BRD).brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
N17051540: length 22.1
  BOTTOM w0.114: PQ36.2 66.69,30.4 v3(66.41,30.68) 65.98,31.11 PQ33.2 63.92,31.64 63.54,32.03 61.38,32.03 61.07,31.72 61.07,31.44 60.34,30.7 58.69,30.7 PQ35.3 56.45,31.67 55.39,30.61 55.39,29.4 ; 55.39,29.4 54.67,30.12 PR337.1 PR336.2 ; 55.39,29.4 PQ39.2
N17051630: length 4.5
  BOTTOM w0.508: PR338.2 70.61,26.71 69.32,28 68.48,28 v3(68.34,28.14) 68.73,28.53 PQ36.3
N17051638: length 3.9
  BOTTOM w0.114: PR339.2 56.53,27.78 55.94,28.37 v1(55.64,28.37) PQ39.3
N17052468: length 1.3
  BOTTOM w0.508: PR258.1 PC196.1
N17052648: length 2.6
  TOP w0.508: PC62.1 80.15,120.54 v3(79.46,119.86) 80.07,119.25 PR76.2
N17067388: length 3.1
  BOTTOM w0.203: PU10.6 105.49,137.79 PR247.2 106.38,137.28 106.26,137.16 PR248.2
N17067390:
  vias: v3(102.35,140.05)
N17067402: length 1
  BOTTOM w0.203: PR246.2 PR247.1
N17067414: length 4
  BOTTOM w0.114: PU10.1 104.8,135.32 105.25,134.86 PC174.2 105.25,133.85 105.37,133.74 PR249.1 106.12,133.23 v1(106.24,133.35)
N17067429: length 4.3
  BOTTOM w0.114: PR245.1 106.38,140.59 v1(106.29,140.69)
  BOTTOM w0.203: PU10.5 103.85,139.01 104.23,139.39 105.6,139.39 106.03,139.82 PR245.1
N17067472: length 6.1
  TOP w0.114: v1(74.82,65.43) 74.69,65.3 PR154.2 73.88,64.77 73.9,64.74 PR155.1 PC104.2 72.33,64.56 72.35,64.59 72.35,65.97
N17067476: length 4.3
  TOP w0.114: PD4.1 78.93,68.83 79.34,68.42 v1(79.34,68.22) PR152.1 78.88,67.15 78.47,67.56 PQ12.1
N17067510: length 3.5
  TOP w0.114: PQ12.3 75.64,66.54 75.44,66.75 75.44,67.24 74.87,67.81 v3(74.84,67.81) 74.18,67.81 73.88,67.51 PR154.1
N17067514: length 5.2
  TOP w0.114: PQ12.2 77.89,65.53 v3(78.83,64.59) 78.83,65.17 PR152.2 80.1,65.68 80.61,65.17 PQ13.3
N17067548: length 17.7
  TOP w0.114: v1(72.5,69.74) 72.35,69.9 72.35,73.2 72.94,73.78 PC102.2 ; v1(75.37,64.94) PR155.2 76.49,63.88 v3(76.64,63.72) 76.77,63.6 76.77,60.55 77,60.32 PQ14.2
  BOTTOM w0.114: v1(72.5,69.74) 75.37,66.87 v1(75.37,64.94)
N17067560: length 62.6
  TOP w0.114: v1(85.81,79.62) 85.81,79.02 84.02,77.23 77.93,77.23 76.54,75.84 v3(76.54,74.98) 76.54,73.4 74.26,71.12 PQ9.3
  BOTTOM w0.076: PR262.1 109.69,112.27
  BOTTOM w0.114: 109.69,112.27 109.65,112.23 109.09,112.23 94.99,98.13 94.99,95.91 94.37,95.29 94.37,91.86 92.37,89.87 89.59,89.87 86.87,87.15 86.87,83.48 85.6,82.21 85.6,79.83 v1(85.81,79.62)
N17067629: length 5.5
  TOP w0.114: v3(50.13,71.62) PQ4.3 PR137.2
N17067635: length 4
  TOP w0.114: v3(52.18,66.42) 52.95,67.19 PR153.2 53.81,67.94 53.94,68.07 PQ10.3
N17067696: length 4
  BOTTOM w0.254: PR330.2 81.42,18.21 v3(81.65,18.44) 81.87,18.66 PR331.2 81.27,19.35 80.95,19.67 PU19.6
N17067698: length 4.4
  BOTTOM w0.508: PU19.4 80.29,21.56 v3(82.03,21.56) 82.11,21.56 82.44,21.89 PC278.1 83.3,22.75 83.29,22.76 PR333.1
N17067710: length 1.4
  BOTTOM w0.508: PR328.2 PR330.1
N17067722: length 3.6
  BOTTOM w0.114: PC271.2 PR326.1 v3(76.42,19.58) 76.51,19.67 PU19.1
N17067737: length 1.6
  BOTTOM w0.254: PU19.5 PR332.1
N17069078: length 70.7
  TOP w0.254: PC94.2 PR129.2 206.46,97.4 206.03,96.97 203.62,96.97 202.43,95.78 200.56,95.78 199.11,94.33 195.54,94.33 192.84,97.03 192.84,99.96 193.52,100.65 193.52,103.69 189.63,107.58 187.58,107.58 186.91,108.25 186.91,110.21 185.01,112.1 185.01,115.29 183.62,116.68 183.62,123.05 181.93,124.74 181.93,128.71 181.33,129.31 180.71,129.31 180.17,129.84 180.17,130.51 182.55,132.89 183.71,132.89 v3(184.19,133.37) 184.67,132.89 185.62,132.89 186.94,134.21 186.94,134.67 187.54,135.27 187.54,135.57 PR61.1 186.28,135.8 PR64.2
N17069086: length 68.7
  TOP w0.254: PR128.2 205.44,98.36 205.99,97.81 205.99,97.55 205.8,97.35 203.48,97.35 202.28,96.15 200.4,96.15 198.97,94.71 195.68,94.71 193.21,97.19 193.21,99.81 193.89,100.49 193.89,103.84 189.78,107.95 187.74,107.95 187.29,108.4 187.29,110.36 185.38,112.26 185.38,115.44 183.98,116.84 183.98,123.2 182.3,124.89 182.3,128.86 181.48,129.68 180.86,129.68 180.54,129.99 180.54,130.36 182.69,132.51 183.78,132.51 v3(184.19,132.1) 184.59,132.51 185.76,132.51 187.31,134.06 187.31,134.52 188.48,135.69 PR62.1 189.19,135.8 189.23,135.76 PR63.2
N17069105: length 2.8
  TOP w0.114: v3(193.99,99.23) 193.99,98.51 PC95.1 194.78,98.2 194.92,98.34 PQ2.2
N17069120: length 3.5
  BOTTOM w0.114: PC219.2 201.04,96.83 v3(201.16,96.72)
  BOTTOM w0.254: PR273.1 200.88,98.95 PR272.2 200.85,98.36 201.04,98.17 PC219.2
N17069170: length 1.4
  TOP w0.254: PR132.2 198.42,96.13 PR134.1
N17069179: length 7.9
  TOP w0.254: PR130.1 200,98.16 200.49,97.66 PC96.1 ; PC96.1 201.04,98.23 200.85,98.42 PR126.2 ; PC96.1 201.04,97.5 PR131.1 202.25,96.64 203.54,97.94 v1(203.64,97.94) 204.18,98.47 PR127.2
N17069186:
  vias: v3(197.29,106.85)
N17069257: length 1.4
  TOP w0.508: PC64.1 PR65.2
N17069297: length 2.5
  TOP w0.114: PR122.1 205.5,101.24 v1(205.07,101.67)
  TOP w0.254: PC89.2 205.96,101.46 PR122.1
N17069414: length 1.6
  TOP w0.508: PR67.2 PC66.1
N17069524: length 2.8
  TOP w0.254: PR130.2 198.83,98.94 v3(198.31,98.42) 197.93,98.04 PQ2.3
N17071623: length 13.2
  TOP w0.114: PR157.1 PR159.2 80.99,13.58 79.87,13.58 v1(79.77,13.69) 79.54,13.69 78.63,12.77 77.38,12.77 PQ16.2 75.32,12.39 73.14,12.39 72.35,11.6 PQ17.2
N17071639: length 4.9
  TOP w0.114: v1(82.69,9.95) 82.66,9.93 81.85,9.93 PC109.2 PR158.1 PR160.2 79.97,10.34 PQ15.2
N17071653: length 3.9
  TOP w0.114: 73.37,13.58 72.4,13.58 v3(71.88,14.11) 70.69,15.29 PR164.2
N17071727: length 2.6
  BOTTOM w0.203: PU11.3 212.7,118.32 212.47,118.09 211.75,118.09 211.54,117.88 PR260.2
N17071926:
  vias: v3(186.86,64.26)
N17192633: length 3.7
  TOP w0.254: R337.2 203.06,52.94 U19.7
N17310717: length 4.9
  TOP w0.508: D24.1 v1(67.4,8.5) R430.2
  BOTTOM w0.508: v1(67.4,8.5) 67.02,8.12 v1(67.02,6.45) 67.02,6.09 66.89,5.96 LED2.2
N17310725: length 8.4
  TOP w0.508: R433.2 v1(60.41,8.38) D27.1
  BOTTOM w0.508: LED1.1 57.42,4.95 57.37,5 57.37,5.71 58.51,6.85 58.51,8.63 58.89,9.01 v1(59.5,9.01) 59.91,9.01 60.41,8.5 v1(60.41,8.38)
N17310735: length 8.7
  TOP w0.508: R431.2 v1(68.54,8.5) D25.1
  BOTTOM w0.508: v1(68.54,8.5) v1(68.08,8.96) 67.78,9.27 67.14,9.27 66.38,8.5 66.38,6.73 65.24,5.58 65.24,5.13 65.39,4.98 LED2.1
N17310861: length 4.7
  TOP w0.508: R432.2 v1(59.27,8.38) D26.1
  BOTTOM w0.508: LED1.2 58.92,5.81 59.27,6.17 v3(59.27,7.29) v1(59.27,8.38)
N17398787: length 3.5
  BOTTOM w0.178: PR167.2 207.22,200.01 207,199.79 207,199.21 v1(206.82,199.03) 206.79,199 206.13,199 205.85,198.72 PU5.5
N17410561: length 8.9
  BOTTOM w0.114: 64.91,87.63 65.79,86.75 65.79,80.54 PR344.1
  vias: v3(62.7,94.51)
N17410571: length 5.9
  BOTTOM w0.114: PR280.2 R697.1 59.58,90.41 v1(59.73,90.27) 58.89,89.43 58.89,89.02 58.38,88.51 58.38,88.13 57.87,87.63 PR288.1
N17410716: length 2.6
  BOTTOM w0.114: PU14.10 58.37,80.37 PC230.2 PR292.1
N17410893: length 2.2
  BOTTOM w0.114: PU14.13 56.87,81.03 56.71,80.87 v1(56.17,80.87) 56.1,80.79 PR290.2
N17424918: length 2.7
  BOTTOM w0.178: PR177.2 209.54,194.81 v1(208.8,195.55) 208.72,195.63 208.5,195.63 208.38,195.74 PU5.11
N17424920: length 3.2
  BOTTOM w0.178: PR178.2 209.76,193.94 208.35,195.34 PU5.12
N17424921: length 4.1
  BOTTOM w0.178: PR170.2 208.98,199.39 208.55,198.95 208.55,198.78 208.01,198.24 206.84,198.24 206.65,198.05 PU5.7
N17424925: length 2.5
  BOTTOM w0.178: PU5.9 208.22,196.54 208.5,196.82 v1(208.8,196.82) 209.08,197.1 PR172.2
N17424950: length 4.8
  TOP w0.254: v1(208.37,193.54) 208.5,193.67 PR13.2 PR12.2
  BOTTOM w0.178: PU5.15 206.65,193.39 206.74,193.29 207.23,193.29 207.48,193.54 v1(208.37,193.54)
N17428106: length 16.8
  TOP w0.114: PQ7.2 194.37,70.25 v3(195.08,69.54) 195.57,69.06 200.65,69.06 201.03,69.44 PQ8.2 201.03,71.62 200.65,72 198.97,72 198.72,72.26 PQ6.3 199.61,73.88 PR141.2 PR140.1
N17428120: length 3
  TOP w0.114: v3(194.35,73.12) 194.58,72.89 PQ7.3 195.41,72.92 PR139.2
N17435661: length 6.4
  TOP w0.114: v3(51.8,72.26) 52.69,73.15 PQ5.3 PR138.2
N17542339: length 2.7
  BOTTOM w0.114: R710.2 177.24,88.02 C756.2 177.02,88.24 Q38.2
N17661815: length 3.1
  BOTTOM w0.178: PU5.8 207.57,196.94 207.89,197.25 207.89,197.71 v1(207.94,197.76) 208.14,197.96 208.6,197.96 208.88,198.24 PR171.2
N17716011: length 1.3
  BOTTOM w0.203: PC129.1 PR195.2
N17716199: length 8.8
  TOP w0.114: v3(136.97,182.42) 136.97,182.6 137.51,183.14 PR33.2
  TOP w0.203: PR33.2 138.13,183.38 PR31.1 139.8,182.6 PC25.2 139.8,182.35 140.03,182.12 PC27.1 141.05,182.24 PC26.2 142.57,182.75 v1(143.47,182.75)
  BOTTOM w0.203: PR201.2 143.98,182.24 v1(143.47,182.75)
N17716279: length 1.3
  TOP w0.203: PC15.1 PR23.2
N17716285: length 2.4
  TOP w0.114: PC16.1 153.46,188.84 v3(153.61,188.68)
  TOP w0.203: PR24.2 PC16.1
N17716287: length 6.7
  TOP w0.203: PC11.1 151.47,191.25 151.35,191.13 PC12.1 152.23,190.88 v1(152.34,190.98) 152.54,190.78 v1(152.54,190.35) 152.49,190.3 PC16.2
  BOTTOM w0.203: PR194.2 152.49,188.09 152.37,188.21 PR191.2 PR187.1 152.54,189.9 v1(152.54,190.35)
N17716423: length 1.3
  TOP w0.203: PC26.1 PR34.2
N17716551: length 29.9
  IN1 w0.203: v1(142.46,179.57) 142.15,179.27 142.15,177.67 138.42,173.94 138.42,171.94 141.44,168.91 141.44,165.71 142.49,164.67 142.49,162.33 140.73,160.57 140.73,157.27 v1(140.17,156.71)
  BOTTOM w0.203: v1(140.17,156.71) 140.55,156.33 PR243.1 ; PR205.1 143.04,180.21 v3(143.01,180.18) 143.01,180.13 v1(142.46,179.57)
N17716721: length 2.3
  TOP w0.203: PC34.1 144.1,177.99 v1(143.45,177.34) 142.96,177.82 PR41.1
N17716783: length 1.3
  BOTTOM w0.203: PC135.1 PR199.2
N17716824: length 1.3
  TOP w0.203: PC28.1 PR36.2
N17716831: length 7.8
  TOP w0.203: PC42.2 150.96,173.72 v1(150.96,173.48) 150.47,172.98 PC44.1 150.47,172.08 PC46.2 151.49,171.06 PR50.2 152.37,171.06 152.49,170.94 PR51.1
  BOTTOM w0.203: PR217.2 150.58,174.39 v3(150.74,174.24) 150.96,174.01 v1(150.96,173.48)
N17717020: length 1.3
  TOP w0.203: PC42.1 PR45.2
N17717324: length 2.2
  BOTTOM w0.203: PR224.1 142.19,170.17 142.07,170.05 PR235.2 PR236.2
N17717338: length 1.3
  TOP w0.203: PC41.1 PR44.2
N17717460: length 2
  BOTTOM w0.203: PR225.1 PR226.2 PR227.2
N17717526: length 2.4
  BOTTOM w0.114: PC139.1 147.54,177.64 v3(147.49,177.69)
  BOTTOM w0.203: PR216.2 148.29,175.88 148.29,175.91 PC139.1
N17717790: length 17.8
  IN1 w0.203: v1(153.89,161.42) 154.04,161.57 154.04,162.94 153.63,163.34 153.63,164.69 153.3,165.02 153.3,165.71 154.04,166.44 154.04,168 154.52,168.48 154.52,172.07 151.21,175.38 v1(151.09,175.38)
  BOTTOM w0.203: v1(153.89,161.42) PR242.1 ; v1(151.09,175.38) 151.59,175.88 PR218.1
N17717866: length 2.2
  TOP w0.114: PR48.1 153.91,175 154.14,174.77 v1(154.47,174.77)
  TOP w0.203: PR48.1 153.63,175.12 PC40.1
N17717963: length 50.9
  TOP w0.203: v1(130.06,173.86) 130.26,174.06 130.26,181.68 131.61,183.03 134.1,183.03 137.25,186.18 140.73,186.18 v3(140.93,185.97) 141.15,185.75 143.12,185.75 v1(143.22,185.85)
  BOTTOM w0.203: v1(130.06,173.86) 130.06,173.61 129.83,173.38 129.24,173.38 128.82,173.8 126.64,173.8 124.68,171.83 121.06,171.83 120.42,171.19 120.42,167.13 122.32,165.24 122.32,164.42 122.78,163.95 PR241.2 ; v1(143.22,185.85) 143.68,185.39 149.48,185.39 150.46,186.37 PR193.1
N17718066: length 1.2
  TOP w0.203: PR21.2 148.42,188.6 PC19.2
N17720504: length 24.5
  IN2 w0.203: v1(143.07,172.08) 142.84,172.08 142.41,171.65 142.41,168.03 143.04,167.39 143.04,162.12 141.49,160.57 141.49,158.44 142.07,157.86 142.33,157.86 v1(142.58,158.11)
  BOTTOM w0.203: v1(143.07,172.08) 143.07,173.43 v3(143.47,173.83) 143.07,174.23 143.07,175.01 PR215.2 ; PL4.3 145,158.34 144.77,158.11 v1(142.58,158.11)
N17720506: length 25.4
  IN2 w0.203: v1(142.33,172.33) 142.07,172.08 142.07,167.89 142.71,167.25 142.71,162.25 141.16,160.7 141.16,158.26 141.95,157.48 142.33,157.48 v1(142.58,157.22)
  BOTTOM w0.203: PR214.2 142.72,175.14 142.72,174.35 v3(142.2,173.83) 142.72,173.32 142.72,172.73 v1(142.33,172.33) ; PL4.4 145,157.02 144.79,157.22 v1(142.58,157.22)
N17720729: length 1.3
  TOP w0.508: PR60.2 144.61,161.06 PC58.1
N17721096: length 1.7
  BOTTOM w0.229: PU7.1 133.96,168.12 PR233.1
N17721116: length 63
  TOP w0.203: v1(148.88,191.13) 148.73,190.98 148.73,190.88 v1(148.27,190.42) 148.2,190.34 PR20.2 PR19.2
  IN2 w0.203: v1(124.47,159.23) 123.91,158.67 123.91,158.14 123.33,157.55 122.49,157.55 121.86,158.19 121.86,163.24 122.34,163.72 122.34,166.52 123.1,167.29 123.1,168.13 125.96,170.99 129.38,170.99 131,172.6 131,178.38 132.73,180.11 136.08,180.11 136.99,181.02 136.99,181.22 144.42,188.64 147.96,188.64 148.06,188.54 148.46,188.54 148.74,188.54 149.26,189.07 149.26,189.91 148.76,190.42 148.76,191 v1(148.88,191.13)
  BOTTOM w0.203: v1(124.47,159.23) 127.01,159.23 127.42,159.63 PL2.3
N17721136: length 68.9
  IN2 w0.203: v1(132.93,158.11) 132.42,157.6 132.42,155.44 132.23,155.25 123.17,155.25 122.47,155.96 122.47,156.64 121.2,157.91 121.2,163.51 121.68,164 121.68,166.8 122.44,167.56 122.44,168.48 129.12,175.16 129.12,179.77 131.95,182.6 134.98,182.6 137.93,185.54 140.35,185.54 144.32,189.52 144.45,189.52 v1(145.38,189.52)
  BOTTOM w0.203: PR190.2 PR189.2 145.61,190.34 145.38,190.11 v1(145.38,189.52) ; PL3.3 136.31,158.31 136.11,158.11 v1(132.93,158.11)
N17721174: length 65.9
  TOP w0.203: PR18.1 144.74,190.14 145.73,191.13 v1(148.25,191.13) 147.92,191.46 v1(147.92,191.66) PR17.2
  IN2 w0.203: v1(124.47,158.47) 124.47,158.16 123.53,157.22 122.36,157.22 121.53,158.05 121.53,163.38 122.01,163.86 122.01,166.66 122.77,167.42 122.77,168.27 125.82,171.32 129.25,171.32 130.67,172.74 130.67,178.54 132.57,180.44 135.95,180.44 136.66,181.16 136.66,181.35 144.28,188.97 148.1,188.97 148.2,188.87 148.6,188.87 148.93,189.2 148.93,189.73 148.42,190.24 148.42,190.95 v1(148.25,191.13)
  BOTTOM w0.203: v1(124.47,158.47) 127.01,158.47 127.42,158.06 PL2.4
N17721246: length 1.3
  BOTTOM w0.229: 123.53,168.14 123.68,167.99 PU6.23 ; PU6.24 123.51,168.49
  vias: v1(121.5,167.89) v3(121.7,167.2)
N17721250: length 1.3
  TOP w0.508: PC55.1 126.12,162.54 PR57.2
N17721295: length 3.9
  TOP w0.508: v1(131.28,167.51) 131.28,167.08 131.58,166.77 PR54.2
  BOTTOM w0.229: 132.79,167.63 132.79,166.88 132.95,166.72 PU7.23 ; 132.8,167.89 133.18,167.89 133.39,167.69 PU7.24
  vias: v1(132.12,169.13)
N17721303: length 77.4
  IN2 w0.203: v1(132.93,157.37) 132.8,157.25 132.8,155.19 132.54,154.92 123.04,154.92 122.14,155.82 122.14,156.51 120.87,157.78 120.87,158.05 120.87,158.05 120.87,163.65 121.35,164.13 121.35,166.93 122.11,167.7 122.11,168.61 128.79,175.29 128.79,179.91 131.81,182.93 134.85,182.93 137.79,185.87 140.21,185.87 144.83,190.5 146.93,190.5 v1(147.82,189.61)
  BOTTOM w0.203: PL3.4 136.31,157.08 136.01,157.37 v1(132.93,157.37) ; PR188.1 144.74,190.19 145.55,191 147.69,191 147.85,190.84 147.85,190.84 v1(148.25,190.45) 148.35,190.34 PR182.2 148.78,189.94 148.15,189.94 v1(147.82,189.61)
N17723090: length 21.6
  IN2 w0.203: v1(154.65,158.04) 154.51,157.91 153.79,157.91 153.39,158.31 153.39,164.51 152.64,165.26 152.64,166.52 153.12,167 153.12,168.31 153.38,168.57 153.38,171.57 v1(153.25,171.7)
  BOTTOM w0.203: v1(153.25,171.7) 152.74,172.2 152.74,172.87 PR222.2 ; v1(154.65,158.04) 156.97,158.04 157.31,158.39 PL5.3
N17723092: length 22.9
  IN2 w0.203: v1(154.65,157.25) 154.32,157.58 153.66,157.58 153.06,158.17 153.06,164.27 152.23,165.1 152.23,166.59 152.79,167.15 152.79,168.45 153.05,168.7 153.05,171.14 v1(152.49,171.7)
  BOTTOM w0.203: PL5.4 157.31,156.97 157.04,157.25 v1(154.65,157.25) ; v1(152.49,171.7) 152.49,171.95 152.36,172.08 152.36,172.49 PR221.2
N17723254: length 1
  TOP w0.508: v1(154.9,167.64) 154.69,167.42 PR56.2
N17723270: length 1.3
  TOP w0.508: PC57.1 155.92,161.69 155.94,161.67 PR59.2
N17738230: length 7.3
  TOP w0.114: v1(22.06,61.97) 21.68,62.35 R316.1
  BOTTOM w0.114: v1(22.06,61.97) 22.12,62.04 22.12,62.29 21.82,62.59 21.69,62.59 19.76,64.53 19.76,65.29 19.14,65.91 18.63,65.91 18.41,65.68 D31.1
N17738233: length 7.9
  TOP w0.114: R317.1 v1(22.69,61.97)
  BOTTOM w0.114: v1(22.69,61.97) 22.69,62.1 21.93,62.86 21.81,62.86 20.03,64.64 20.03,65.4 19.27,66.16 18.63,66.16 18.41,66.39 D30.1
N17762362: length 1.8
  BOTTOM w0.203: PU8.1 144.88,167.79 144.11,168.57 PR237.1
N17762374: length 1.6
  BOTTOM w0.203: PU8.2 145.38,168.01 145.12,168.27 PR238.1
N17762566: length 3.3
  TOP w0.508: PR55.2 142.68,166.14 141.95,166.87 v1(141.95,167)
  BOTTOM w0.229: PU8.23 143.75,166.6 143.6,166.75 143.6,167.06 143.63,167.1 PU8.24
  vias: v1(142.05,167.69)
N17766069:
  vias: v3(129.12,172.31)
N17766091:
  vias: v3(126.12,170.86)
N17766685: length 1.4
  BOTTOM w0.229: PR229.1 125.06,169.67 125.19,169.53 PU6.2
N17766721: length 1.6
  BOTTOM w0.229: PR228.1 124.69,169.52 PU6.1
N17769194: length 1.3
  TOP w0.508: PR58.2 135.17,161.37 PC56.1
N17771799: length 1.5
  BOTTOM w0.229: PU7.2 134.46,168.14 134.2,168.4 PR234.1
N17776478: length 1.5
  BOTTOM w0.203: PR240.1 155.79,168.27 156.18,167.88 PU9.2
N17776833:
  vias: v3(156.78,171.12)
N17777700: length 1.7
  BOTTOM w0.203: PR239.1 155.68,167.87 PU9.1
N17790538: length 3
  TOP w0.114: v1(124.12,116.15) 124.12,116.91 TP87.1
  BOTTOM w0.076: v1(124.12,116.15) 123.61,116.15 123.41,115.95 122.95,115.95 122.75,115.75 122.75,115.31 U35.AL61
N17790548: length 5
  TOP w0.114: TP86.1 124.75,116.66 v1(124.75,116.15)
  BOTTOM w0.076: 124.55,116.35 124.29,116.61 123.81,116.61 123.33,116.12 122.9,116.12 122.57,115.79 122.57,115.62 122.44,115.49 U35.AK62
  BOTTOM w0.114: 124.55,116.35 v1(124.75,116.15)
N17792383: length 49.4
  TOP w0.114: R172.1 v1(86.7,104.39)
  IN1 w0.127: v2(122.52,119.58) 122.15,119.58 121.13,120.61 120.74,120.61 120.12,121.22 118.93,121.22 118.56,121.59 116.78,121.59 115.54,122.82 107.92,122.82 102.99,117.89 100.23,117.89 100.14,117.8 98.89,117.8 93.32,112.22 93.32,108.7 89.71,105.09 87.4,105.09 v1(86.7,104.39)
  BOTTOM w0.114: U35.AC63 122.07,119.31 122.34,119.58 v2(122.52,119.58) ; R634.2 v1(86.7,104.39)
N17792405: length 49.5
  TOP w0.114: R176.1 v1(86.7,103.37)
  IN1 w0.127: v2(122.52,118.96) 122.42,118.96 121.02,120.35 120.57,120.35 119.96,120.97 118.82,120.97 118.46,121.33 116.67,121.33 115.43,122.57 108.02,122.57 103.09,117.64 100.34,117.64 99.21,116.51 99.21,115.04 95.41,111.24 94.98,111.24 94.77,111.02 94.77,109.79 89.81,104.83 88.16,104.83 v1(86.7,103.37)
  BOTTOM w0.114: v2(122.52,118.96) 122.43,118.96 122,118.53 121.52,118.53 U35.AE63 ; R636.2 v1(86.7,103.37)
N17792407: length 53.2
  IN1 w0.127: v1(89.12,105.53) 89.79,105.53 92.85,108.59 92.85,112.21 98.78,118.14 102.88,118.14 107.81,123.08 115.65,123.08 116.88,121.84 118.58,121.84 118.83,122.09 119.62,122.09 119.99,121.71 119.99,121.71 120.85,120.86 121.23,120.86 122.03,120.06 122.69,120.06 122.95,119.8 122.95,119.16 v1(123.47,118.64)
  IN2 w0.127: v1(123.47,118.64) 123.07,118.23 122.14,118.23 121.63,117.72 121.63,115.22 v2(121.81,115.05)
  BOTTOM w0.076: U35.AL63 121.55,114.78 v2(121.81,115.05)
  BOTTOM w0.114: R633.2 90.14,104.51 v1(89.12,105.53)
N17792421: length 53.3
  IN1 w0.127: v1(124.12,118.64) 123.2,119.55 123.2,119.91 122.76,120.35 122.1,120.35 121.34,121.11 120.95,121.11 119.73,122.34 118.72,122.34 118.47,122.09 116.99,122.09 116.76,122.33 115.75,123.33 107.67,123.33 102.8,118.46 98.59,118.46 91.91,111.78 91.91,108.28 v1(89.65,106.02)
  IN2 w0.127: v1(124.12,118.64) 123.43,117.95 123.43,116.66 122.97,116.2 v2(122.34,116.2)
  BOTTOM w0.076: U35.AJ62 122.25,116.11 v2(122.34,116.2)
  BOTTOM w0.114: v1(89.65,106.02) 90.55,105.11 90.55,104.07 90.55,104.06 90.55,103.78 R632.2
N17817978: length 3.8
  TOP w0.508: v1(60.54,5.33) 60.69,5.18 v3(60.69,4.62) 60.62,4.69 R440.1 R438.1
  BOTTOM w0.508: LED1.3 60.42,5.2 v1(60.54,5.33)
N17818190: length 3.9
  TOP w0.508: R437.1 R439.1 67.51,4.72 v3(68.44,4.72) 68.39,4.77 v1(68.39,5.43)
  BOTTOM w0.508: LED2.3 v1(68.39,5.43)
N17828598:
  vias: v3(146.44,171.14)
N18005998: length 4.8
  TOP w0.254: R326.2 v3(226.05,59.46) 227.11,58.39 CN14.18
N18020348: length 2.3
  TOP w0.114: TP17.1 142.56,113.31 142.28,113.58 142.28,114.19 142.53,114.45 v2(142.71,114.45)
  BOTTOM w0.076: v2(142.71,114.45) 142.95,114.68 U35.AM23
N18021386: length 3.2
  TOP w0.114: v2(143.6,116.07) 143.88,115.79 144.84,115.79 TP14.1
  BOTTOM w0.076: 143.98,115.03 143.98,114.79 U35.AM22
  BOTTOM w0.114: 143.98,115.03 143.98,115.27 143.6,115.65 v2(143.6,116.07)
N18022283: length 1.5
  TOP w0.114: v1(138.04,125.57) 138.04,125.73 TP12.1
  BOTTOM w0.114: v1(138.04,125.57) 138.19,125.57 U35.K32
N18022286: length 8.6
  TOP w0.114: v2(139.61,116.43) 139.53,116.35 139.53,115.44 138.6,114.5 138.6,110.97 139.03,110.54 TP20.1
  BOTTOM w0.114: U35.AK32 138.6,116.11 138.82,116.33 139.51,116.33 v2(139.61,116.43)
N18079286: length 14.5
  BOTTOM w0.114: R509.1 R510.2 181.57,141.98 182.46,142.87 183.65,142.87 186.37,145.59 186.37,145.79 186.88,146.3 186.88,147.49 187.11,147.72 187.49,147.72 187.74,147.98 187.74,148.31 188,148.56 188.33,148.56 188.56,148.79 188.56,149.86 188.93,150.24 U34.F6
N18137715: length 27.5
  IN1 w0.127: v1(158.71,106.27) 158.56,106.42 157.28,106.42 155.37,108.33 153.52,108.33 151.6,110.25 151.6,111.01 150.95,111.66 v2(150.95,111.86)
  IN2 w0.127: v1(158.71,106.27) 158.71,105.66 159.12,105.25 159.12,102.5 158.98,102.36 158.98,99.51 160.83,97.66 165.34,97.66 165.77,98.09 v1(165.77,98.8)
  BOTTOM w0.076: U35.AU11 150.69,111.63
  BOTTOM w0.114: v2(150.95,111.86) 150.92,111.86 150.69,111.63 ; v1(165.77,98.8) 166.26,99.28 TP29.1
N18834425: length 8.3
  BOTTOM w0.114: Q56.2 215.86,74.93 215.73,74.8 215.73,74.42 215.88,74.28 Q56.3 217.62,74.28 218.91,75.56 v1(218.91,75.87) 218.91,76.07 218.92,76.08 R717.2 C764.1
N18834459: length 3.4
  BOTTOM w0.114: R717.1 217.89,77.08 217.39,76.58 R757.1 R756.1 216.89,78.52 v3(216.88,78.53)
N18849499: length 8.3
  TOP w0.114: R6.2 141.51,197.72 v1(141.11,198.12)
  BOTTOM w0.114: v1(141.11,198.12) 139.95,198.12 138.02,196.19 138.02,194.84 138.55,194.32 139.35,194.32 CN5.11
N18849555: length 8.3
  TOP w0.114: R5.2 140.92,197.72 141.11,197.53 v1(141.11,197.33)
  BOTTOM w0.114: CN5.10 139.8,194.56 138.65,194.56 138.26,194.94 138.26,196.08 140.06,197.87 140.74,197.87 141.11,197.51 v1(141.11,197.33)
N18953365: length 6.7
  BOTTOM w0.076: U35.AY3 155.53,109.6 155.82,109.31 155.82,108.86 156.04,108.63 156.48,108.63 156.91,108.2 158.33,108.2 158.53,108.4 158.53,108.78 158.94,109.19 158.94,109.44 R759.1
N18953425: length 6.2
  BOTTOM w0.076: v3(111.32,110.54) 111.32,109.95 ; 112.16,109.11 115.02,109.11 115.34,109.43 U35.AY71
  BOTTOM w0.114: 111.32,109.95 111.32,109.58 R760.1 111.79,109.11 112.16,109.11
N18954271: length 14
  BOTTOM w0.076: U35.C64 120.33,130.14 120.33,131.58 120.22,131.7 120.22,132.19 119.8,132.61 118.07,132.61
  BOTTOM w0.114: 118.07,132.61 117.67,132.61 117.63,132.65 114.61,132.65 111.35,135.91 R761.1
N18954886: length 44.9
  IN1 w0.127: v2(125.34,112.42) 125.79,112.87 125.79,114.53 125.39,114.93 124.98,114.93 124.82,115.1 123.88,115.1 123.67,115.3 123.67,117.76 122.91,118.53 122.26,118.53 121.92,118.87 121.92,119.1 121,120.01 120.55,120.01 119.85,120.72 118.72,120.72 118.35,121.08 116.57,121.08 115.35,122.3 113.23,122.3 112.61,121.68 107.49,121.68 103.2,117.38 101.4,117.38 99.57,115.55 99.57,115.04 95.33,110.79 v1(95.21,110.79)
  BOTTOM w0.114: v2(125.34,112.42) 125.02,112.73 U35.AR56 ; R762.1 94.5,111.5 v1(95.21,110.79)
N18954889: length 15.8
  TOP w0.114: TP88.1 116.57,120.75 v1(115.84,120.75)
  IN1 w0.127: v2(125.36,113.66) 124.9,114.12 124.9,114.65 124.71,114.84 123.75,114.84 123.42,115.17 123.42,117.66 122.8,118.27 122.16,118.27 121.66,118.77 121.66,118.99 120.91,119.74 120.47,119.74 119.74,120.46 118.61,120.46 118.25,120.82 115.91,120.82 v1(115.84,120.75)
  BOTTOM w0.127: U35.AP56 125.08,113.38 v2(125.36,113.66)
N18994895: length 6
  BOTTOM w0.076: 160.36,126.11 159.6,126.11 159.47,126.23 158.25,126.23 158,125.98 158,125.27 157.82,125.09 157.06,125.09 156.71,125.44 U35.L1
  BOTTOM w0.114: C793.2 161.01,126.11 160.36,126.11
N19011701:
  vias: v3(59.02,77.49)
N19018012: length 19.5
  BOTTOM w0.114: 150.51,121.15 150.51,117.45 150.81,117.14 154.09,117.14 154.55,117.6 154.55,117.62 154.72,117.8 154.75,117.8 154.75,117.8 155.94,117.8 155.94,117.8 155.97,117.8 156.15,117.62 156.15,117.37 156.4,117.12 157.01,117.12 157.11,117.01 159.22,117.01 159.75,117.55 160.35,117.55 160.8,118 161.45,118 v1(161.51,118.06) 161.73,118.28 R775.2 162.93,118.71 164.06,118.71 164.28,118.49 C794.2
N19138106: length 18.9
  TOP w0.114: R80.2 195.28,150.63 193.94,151.96 193.94,158.56 193.71,158.79 193.71,160.04 193.28,160.47 v1(193.28,161.39) 193.28,162.58 191.19,164.68 189.97,164.68 189.5,164.21 v1(189.32,164.21)
  BOTTOM w0.254: v1(189.32,164.21) 188.94,163.82 U34.F22
N19138109: length 22.2
  TOP w0.114: v1(186.85,164.28) 187.27,163.86 188.7,163.86 188.96,163.61 188.96,163.27 189.23,162.99 189.57,162.99 189.81,162.75 189.81,162.32 190.49,161.64 190.49,160.91 190.94,160.45 191.73,160.45 v1(192.16,160.02) 192.9,159.28 192.9,158.26 193.05,158.11 193.05,151.33 193.89,150.49 193.89,148.84 194.91,147.82 R87.2
  BOTTOM w0.114: v1(186.85,164.28) 186.56,163.99 U34.J22
N19520551: length 9.9
  BOTTOM w0.114: v3(143.65,14.63) R776.1 144.5,16.61 D34.1 145.28,17.14 148.93,17.14 149.57,16.51 150.58,16.51 150.79,16.72 CN20.27
N19736816: length 3.7
  TOP w0.114: v1(149.21,115.2) 148.97,115.44 148.22,115.44 147.71,115.95 TP84.1
  BOTTOM w0.114: v1(149.21,115.2) 148.7,114.68 U35.AM15
N19940934:
  vias: v3(72.4,53.34)
N19940984: length 2.4
  BOTTOM w0.114: v3(69.72,43.88) 69.71,43.89 69.71,44.92 PC6222.1
  BOTTOM w0.635: PR6289.2 69.72,44.93 PC6222.1
N19941046: length 4.6
  BOTTOM w0.203: PR6283.1 69.12,55.25 69.21,55.16 69.85,55.16 70.01,54.99 PR6284.2 68.95,54.63 v1(68.81,54.49) 68.64,54.32 PU6010.7
N19941108: length 2.6
  BOTTOM w0.114: v1(62.54,55.64) 62.46,55.56 PC6211.1
  BOTTOM w0.508: PD6008.3 61.01,56.21 61.01,56.21 PC6211.1
N19941112: length 4.4
  TOP w0.508: v1(60.86,53.71) 61.59,52.98 PC6099.2 61.68,52.85 v3(61.68,51.91)
  BOTTOM w0.508: v1(60.86,53.71) 60.79,53.71 60.79,53.71 60.74,53.71 60.71,53.74 60.62,53.74 60.24,54.12 60.24,54.38 PR6285.2 PC6211.2
N19941118: length 9.6
  TOP w0.508: PD6004.1 62.03,56.79 v1(61.92,56.79) 59.1,56.79 PC6097.2
  BOTTOM w0.114: v1(58.97,59.38) 59.43,58.91 PD6008.2
  BOTTOM w0.508: PD6008.2 60.35,58.6 60.99,57.96 61.65,57.96 61.91,57.7 61.91,56.8 v1(61.92,56.79)
N19941180: length 3.8
  TOP w0.508: PD6004.3 60.12,54.72 PC6099.1 60.12,52.01 60.13,51.99 v3(60.13,51.91)
N19941188: length 2.4
  BOTTOM w0.114: PR6288.2 67.12,45.03 68.13,45.03 v3(68.13,45.04)
  BOTTOM w0.635: PC6221.1 67.34,45.76 67.12,45.54 PR6288.2
N19941230:
  vias: v1(60.19,50.9)
N19949969: length 5.8
  TOP w0.114: PQ6058.2 89.79,33.17 PR6290.1 88.46,30.83 PQ6057.3 88.91,29.49 v3(88.73,29.31)
N20339214: length 14.2
  TOP w0.114: v2(153.76,115.24) 154.81,114.19 155.66,114.19 156.96,112.88 159.43,112.88 159.83,112.49 163.07,112.49 163.45,112.87 163.85,112.87 R778.1
  BOTTOM w0.076: U35.AG4 153.76,115.73 v2(153.76,115.24)
N20463413: length 3.4
  BOTTOM w0.305: R755.1 213.53,18.11 214.08,18.11 R787.1 214.92,18.95 CN22.5
N20915811: length 2.8
  TOP w0.114: TP95.1 151.04,116.38 v1(149.85,115.2)
  BOTTOM w0.114: U35.AK13 149.53,115.52 v1(149.85,115.2)
N21263014: length 4.6
  TOP w0.102: 192.11,153.03 192.11,153.54 191.73,153.92 190.59,153.92 190.46,154.05 189.67,154.05 v1(189.42,154.3)
  TOP w0.114: 192.11,153.03 192.11,152.6 TP7.1
  BOTTOM w0.114: v1(189.42,154.3) 189.44,154.3 U34.E10
N21263017: length 1.4
  TOP w0.102: TP6.1 190.16,153.51 v1(189.42,153.51)
  BOTTOM w0.114: U34.F10 189.03,153.9 v1(189.42,153.51)
N108831390: length 5.9
  TOP w0.114: Q14.3 176.75,138.81 v1(176.87,138.68) 176.58,138.39 R121.2 R129.1 R128.1 R120.2
N108831783: length 10.2
  TOP w0.114: R125.1 169.89,137.66 169.89,138.74 169.89,138.94 169.34,139.48 169.33,139.48 169.21,139.48 169.04,139.65 169.04,140.15 R106.1 R107.2 169.6,140.74 v3(170.65,140.74) 170.8,140.58 Q15.3 171.92,141.22 171.67,141.47 171.16,141.47 170.9,141.74 R99.1
N108845535: length 5.8
  TOP w0.114: v1(165.04,145.64) 164.93,145.54 Q8.3 164.05,147.1 C147.1 163.95,148.67 R81.1 163.73,148.89 Q6.2
N108845564: length 3.4
  TOP w0.114: R104.1 C162.1 163.16,141.98 v1(162.95,142.19) 163.03,142.26 Q8.2
N112371482: length 3.7
  TOP w0.114: R117.2 R116.1 207.99,136.24 v1(208.27,135.96) 208.27,135.84 208.6,135.5 Q17.3
N112371495: length 6
  TOP w0.114: Q11.2 207.76,142.24 207.99,142.01 v1(207.99,141.09) 207.99,140.59 208.25,140.33 C166.1 208.25,139.98 208.01,139.75 207.71,139.75 207.47,139.51 C167.2 207.47,138.79 207.99,138.27 R116.2
N112697336: length 10.9
  BOTTOM w0.114: TP60.1 177.56,141.7 177.56,144.56 179.38,146.37 179.38,150.73 179.01,151.09 U34.V7
N112697339: length 13.8
  BOTTOM w0.114: TP56.1 170.65,143.25 171.92,144.52 174.24,144.52 176.14,146.41 176.14,149.84 176.48,150.19 176.67,150.19 176.97,150.49 176.97,150.68 177.66,151.36 U34.W7
N112698577: length 8.9
  BOTTOM w0.114: TP53.1 177.08,143 177.08,144.67 178.58,146.17 178.58,150.2 U34.W6
N112698579: length 12.3
  BOTTOM w0.114: TP57.1 171.54,142.87 171.54,143.76 172.05,144.27 174.79,144.27 176.32,145.8 176.92,146.4 176.92,149.86 177.37,150.31 U34.Y6
N112698609: length 1.4
  TOP w0.114: TP9.1 184.54,151.68 v1(184.44,151.79)
  BOTTOM w0.114: v1(184.44,151.79) 184.02,151.36 U34.M7
N112698611: length 11.1
  BOTTOM w0.114: TP50.1 179.84,143.86 181.29,143.86 183.54,146.11 183.54,149.87 183.25,150.16 183.07,150.16 182.81,150.41 182.81,150.84 183.17,151.2 U34.N7
N112698638: length 11.4
  BOTTOM w0.114: U34.P6 182.33,150.49 182.77,150.06 182.77,146.05 181.52,144.8 179.9,144.8 178.88,143.79 178.88,142.45 TP59.1
N112698654: length 10.4
  BOTTOM w0.114: U34.T7 181.06,151 181.06,147.17 180.79,146.91 180.4,146.91 178.07,144.57 TP54.1
N112698670: length 1.8
  TOP w0.114: v1(181.9,152.14) 181.27,152.14 TP8.1
  BOTTOM w0.114: U34.R7 181.49,151.73 v1(181.9,152.14)
N112698723: length 1.3
  TOP w0.114: v1(181.93,150.97) 182.23,151.28 TP10.1
  BOTTOM w0.114: U34.R6 181.52,150.56 v1(181.93,150.97)
N112699151: length 11.3
  BOTTOM w0.114: TP55.1 181.04,142.62 181.47,143.05 181.47,143.48 184.37,146.38 184.37,148.19 184.71,148.54 184.94,148.54 185.28,148.88 185.28,150.99 U34.K7
N112699156: length 1.3
  TOP w0.114: v1(186.93,151) 187.39,150.54 TP11.1
  BOTTOM w0.114: U34.J7 186.57,151.36 v1(186.93,151)
N112699170: length 9.4
  BOTTOM w0.114: TP52.1 186.02,145.94 186.02,148.2 186.38,148.56 186.6,148.56 186.93,148.89 186.93,149.07 187.16,149.3 187.38,149.3 187.66,149.57 187.66,150.2 U34.H6
N112699184: length 9.4
  BOTTOM w0.114: U34.J6 186.45,150.32 186.07,149.93 186.07,148.83 185.78,148.54 185.55,148.54 185.25,148.24 185.25,146.12 182.49,143.35 TP51.1
N112700854: length 2.7
  TOP w0.102: TP5.1 190.05,154.73
  TOP w0.114: 190.05,154.73 189.11,154.73 188.79,154.4 v1(188.53,154.4)
  BOTTOM w0.114: v1(188.53,154.4) 188.87,154.74 U34.F11
N112701566: length 9.8
  BOTTOM w0.114: TP61.1 176.01,141.09 176.01,144.07 177.03,145.09 177.79,145.85 177.79,149.3 U34.W5
N112701580: length 6.8
  BOTTOM w0.114: U34.AE2 173.23,147.11 172.86,146.73 172.86,146.33 172.43,145.89 168.67,145.89 TP49.1
N112701871: length 2.7
  TOP w0.102: v1(191.05,164.23) 192.09,163.19 TP2.1
  BOTTOM w0.102: v1(191.05,164.23) 190.63,164.64 U34.D23

## Copper pours and planes (outline as drawn)
1.5VGFX_BST on BOTTOM (solid shape): 218.78,121.24 218.78,120.26 218.66,120.14 218,120.14 217.47,120.67 217.33,120.81 216.9,120.81 216.8,120.71 216.8,120.49 216.79,120.42 216.8,120.34 216.8,120.18 216.96,120.01 216.96,119.84 216.95,119.83 216.24,119.83 216.22,119.86 216.22,121 216.22,121 216.22,121.17 216.42,121.38 218.64,121.38
1.5VGFX_BST1 on BOTTOM (solid shape): 218.78,123.69 218.78,121.79 218.66,121.66 218.15,121.66 217.89,121.92 217.89,123.69 218.02,123.82 218.66,123.82
1.5VGFX_SW on TOP (solid shape): 216.5,121.53 216.5,120.26 216.24,120.01 215.61,120.01 215.48,120.14 215.48,121.79 215.61,121.92 216.12,121.92
1.5VGFX_SW on BOTTOM (solid shape): 218.91,125.22 218.91,124.46 218.78,124.33 217.89,124.33 217.36,123.8 217.36,122.94 217.15,122.73 216.79,122.73 216.38,122.32 216.38,121.64 215.9,121.16 215.9,119.23 215.37,118.69 214.44,118.69 214.35,118.79 215.16,118.79 215.16,119.45 214.77,119.45 214.77,118.79 214.35,118.79 214.24,118.9 214.24,119.83 215.17,119.83 215.17,120.92 214.68,120.92 214.68,119.83 214.24,119.83 214.24,120.94 214.09,121.09 213.39,121.09 212.43,122.04 212.43,125.22 212.81,125.6 218.53,125.6
5VMCU on TOP (solid shape): 21.12,113.48 21.12,112.24 21.03,112.15 21.03,110.69 20.83,110.69 20.83,112.3 20.15,112.98 20.03,112.98 19.95,113.05 19.95,113.79 20.82,113.79
51211V_DRVH on BOTTOM (solid shape): 79.05,112.26 79.05,111.9 78.9,111.75 78.59,111.75 78.38,111.96 78.38,112.06 78.31,112.13 77.01,112.13 77.01,112.19 77.01,112.36 77.01,112.41 78.9,112.41
51211V_DRVL on BOTTOM (solid shape): 82.21,123.41 82.21,121.27 82.21,121.26 81.6,121.26 81.56,121.28 81.55,121.31 81.55,123.36 81.7,123.52 82.11,123.52
51211V_SW on BOTTOM (solid shape): 86.88,125.65 86.88,118.7 86.01,117.83 82.33,117.83 81.94,118.21 78.02,118.21 77.99,118.23 77.97,118.26 77.97,120.35 77.98,120.36 81.97,120.36 82.79,121.18 82.79,125.6 83.45,126.26 86.27,126.26
51211V_SW on BOTTOM (solid shape): 80.13,113.49 80.13,112.83 80.09,112.79 79.18,112.79 79.02,112.63 77.85,112.63 77.01,112.63 77.01,112.68 77.01,112.86 77.01,112.91 78.23,112.91 78.84,113.52 80.1,113.52
51211V_VBST on BOTTOM (solid shape): 80.15,112.14 80.15,111.12 79.57,110.54 78.35,110.54 78.02,110.87 77.23,110.87 77.01,111.08 77.01,111.91 78.09,111.91 78.37,111.63 79.01,111.63 79.26,111.88 79.26,112.14 79.39,112.26 80.02,112.26
+1.5V on TOP (solid shape): 26.96,72.65 26.96,72.2 26.36,71.6 26.13,71.6 25.96,71.76 25.96,72.32 26.42,72.78 26.83,72.78
+1.5V on TOP (solid shape): 29.17,42.67 29.17,42.21 29,42.04 26.88,42.04 26.76,42.16 26.76,42.67 26.89,42.79 29.04,42.79
+1.5V on TOP (solid shape): 21.45,65.32 21.45,65.04 20.91,64.5 20.44,64.5 20.35,64.58 20.35,65.14 20.49,65.28 20.8,65.28 20.95,65.43 21.34,65.43
+1.5V on BOTTOM (solid shape): 74.41,22.19 74.41,19.13 73.53,18.24 73.53,16 73.4,15.87 69.01,15.87 68.75,15.99 68.48,15.87 68.44,15.87 68.31,16.01 68.31,21.48 68.64,21.81 72.53,21.81 72.78,22.07 72.78,22.27 72.91,22.4 74.21,22.4
+1.5V on IN1 (solid shape): 29.3,42.41 29.3,41.52 29.04,41.27 28.03,41.27 27.65,41.65 27.65,42.54 27.77,42.67 29.04,42.67
+1.5V on IN1 (solid shape): 26.76,73.02 26.76,71.88 26.25,71.37 24.67,71.37 24.58,71.43 24.59,71.53 24.29,72.15 23.99,71.53 24.01,71.43 23.91,71.37 21.93,71.37 21.68,71.12 21.68,66.42 21.81,66.29 21.81,65.02 21.3,64.51 20.54,64.51 19.9,65.15 19.9,66.56 19.93,66.58 20.16,66.92 19.93,67.27 19.9,67.29 19.9,73.15 20.15,73.4 26.38,73.4
+1.05V_GFX on TOP (solid shape): 187.54,143.12 187.54,141.35 186.91,140.71 183.86,140.71 182.97,139.82 179.29,139.82 179.16,139.95 179.16,140.71 179.29,140.84 179.67,140.84 179.79,140.71 182.46,140.71 182.84,141.09 182.84,141.85 183.22,142.24 185.38,142.24 185.89,142.74 185.89,143.12 186.14,143.38 187.29,143.38
+1.5V_GFX on TOP (solid shape): 183.99,164.18 184.08,164.13 184.41,163.91 184.75,164.12 184.83,164.17 184.92,164.13 185.23,163.97 185.54,164.13 185.63,164.18 185.72,164.12 186.06,163.91 186.39,164.14 186.45,164.16 186.51,164.14 186.63,163.99 186.8,163.91 186.82,163.91 187.16,163.57 187.16,163.44 187.03,163.32 186.52,163.32 186.27,163.06 186.27,162.94 186.14,162.81 184.32,162.81 183.97,162.47 183.97,161.73 183.96,161.72 183.96,161.57 183.58,161.18 182.21,161.18 181.8,161.59 181.8,163.03 181.82,163.08 181.86,163.12 182.08,163.16 182.24,163.32 182.33,163.37 182.42,163.32 182.74,163.12 183.07,163.3 183.16,163.35 183.24,163.3 183.82,163.23 183.75,163.81 183.7,163.9 183.75,163.98 183.84,164.05 183.9,164.13
+1.05V_GFX on TOP (solid shape): outline of 837 points within 165.71,153.01 177.43,167.97
+1.5V_GFX on TOP (solid shape): outline of 8579 points within 163.72,147.32 221.07,193.49
+1.05V_GFX on BOTTOM (solid shape): outline of 127 points within 183.28,73.02 192.11,84.34
+1.5V_GFX on BOTTOM (solid shape): outline of 129 points within 181.32,174.06 184.54,181.76
+1.5V_GFX on BOTTOM (solid shape): outline of 162 points within 177.43,156.1 189.51,164.1
+1.5V_GFX on BOTTOM (solid shape): outline of 814 points within 176.36,183.97 183.56,191.36
+1.5V_GFX on BOTTOM (solid shape): outline of 1069 points within 188.88,169.29 212.89,192.27
+1.5V_GFX on BOTTOM (solid shape): outline of 1117 points within 195.92,127.91 220.72,172
+1.5V_GFX on BOTTOM (solid shape): outline of 1273 points within 161.25,171.67 179.61,190.11
+1.05V_GFX on BOTTOM (solid shape): outline of 1984 points within 165.57,153.42 177.24,168.27
+1.5V_GFX on SVCC (solid shape): outline of 97 points within 162.65,142.74 221.7,190.88
+1.05V_GFX on SVCC (solid shape): 165.49,157.48 168.19,157.48 168.49,157.77 168.49,158.11 176.39,158.11 176.87,157.62 176.87,156.44 176.75,156.31 176.75,154.58 177.63,153.69 177.63,140.99 178.16,140.46 179.94,140.46 180.24,140.16 180.24,129.17 179.98,128.92 179.98,128.5 185.25,123.23 185.25,110.39 184.46,109.48 185.25,108.56 185.25,90.64 184.21,89.48 185.25,88.31 185.25,83.52 181.36,79.62 180.51,79.62 180.43,79.71 180.43,120.09 166.42,134.11 161.08,134.11 160.24,134.95 160.24,139.27 159.22,140.29 159.22,141.52 160.13,142.43 160.36,142.8 160.36,157.8 161.61,159.25 163.71,159.25
+1.5V_GFX on IN1 (solid shape): outline of 6306 points within 163.74,143.89 222.21,193.39
+1.05V_GFX on IN2 (solid shape): outline of 364 points within 175.6,139.44 179.79,156.84
+1.5V_GFX on IN2 (solid shape): outline of 509 points within 203.14,148.51 222.01,187.7
+1.5V_GFX on IN2 (solid shape): outline of 806 points within 164.1,171.4 173.01,191.26
+1.5V_GFX_VCC on BOTTOM (solid shape): 218,119.97 218.8,119.97 218.93,119.84 218.93,119.34 218.77,119.18 218.42,119.18 218.17,119.43 216.26,119.43 216.2,119.49 216.2,119.56 216.25,119.61 216.96,119.61 217.08,119.73 217.08,120.06 216.91,120.23 216.91,120.61 216.99,120.69 217.29,120.69
+1.5VA on TOP (solid shape): 36.66,32.79 36.92,32.79 36.94,32.76 39.48,32.76 39.74,32.51 39.74,31.39 39.71,31.36 39.71,30.86 39.59,30.73 39.31,30.73 38.76,31.28 38.7,31.35 38.64,31.4 37.5,32.54 36.51,32.54 36.24,32.8 35.21,32.8 35.21,33.01 36.45,33.01
+1.8V_S5 on TOP (solid shape): 165.19,119.2 165.19,118.1 165.14,118.06 164.34,118.06 164.24,117.95 163.86,117.95 163.58,118.24 163.15,118.24 162.91,118 162.91,117.81 162.65,117.56 161.96,117.56 161.84,117.67 161.84,118.61 161.94,118.7 162.71,118.7 162.78,118.77 162.78,119.19 162.93,119.34 165.05,119.34
+1.8V_S5 on BOTTOM (solid shape): 102.3,134.97 102.3,129.59 102.1,129.38 99.81,129.38 99.41,129.79 99.41,131.52 99.4,131.53 99.4,134.52 99.1,134.82 99.1,136.24 101.03,136.24
+1.8V_S5 on SVCC (solid shape): 165.95,115.21 165.95,111.35 165.53,110.93 164.51,110.93 163.59,111.85 163.61,111.85 164.17,112.41 164.17,115.33 164.53,115.69 165.46,115.69
+1.35VSUS on TOP (solid shape): 177.38,49.27 177.38,47.37 177.11,47.1 176,47.1 175.6,47.49 175.6,49.53 175.86,49.78 176.87,49.78
+1.35VSUS on TOP (solid shape): 177.43,71.07 177.43,70.25 177.23,70.05 175.89,70.05 175.65,70.05 175.48,70.23 175.48,71.24 175.55,71.32 177.18,71.32
+1.35VSUS on TOP (solid shape): outline of 11234 points within 114.72,32.15 174.45,115.43
+1.35VSUS on BOTTOM (solid shape): 178.75,70.84 178.75,70.33 179.03,70.05 179.03,68.83 178.98,68.78 178.88,68.78 178.84,68.82 178.84,69.61 178.36,70.09 176.89,70.09 176.75,70.23 176.75,71.07 176.87,71.19 178.4,71.19
+1.35VSUS on BOTTOM (solid shape): outline of 442 points within 170.88,37.71 184.11,50.29
+1V_S5 on TOP (solid shape): 162.1,124.19 162.1,123.22 161.94,123.06 161.51,123.06 161.38,123.19 160.36,123.19 160.24,123.31 160.24,124.2 160.36,124.33 161.96,124.33
+1V_S5 on TOP (solid shape): outline of 538 points within 85.56,38.35 110.32,86.99
+1V_S5 on TOP (solid shape): outline of 1351 points within 144.08,117.19 162.39,136.6
+1V_S5 on BOTTOM (solid shape): 156.76,137.31 156.76,136.42 157.09,136.09 157.09,135.76 156.78,135.45 156.46,135.45 155.89,134.88 155.35,134.88 155.28,134.81 155.28,134.06 155.2,133.98 154.95,133.98 154.93,133.96 154.41,133.96 154.41,134.78 154.68,135.04 154.68,137.29 155.03,137.64 156.43,137.64
+1V_S5 on BOTTOM (solid shape): 95.9,125.98 95.9,121.56 96.56,120.9 98.26,120.9 98.77,120.39 98.77,117.27 98.78,117.26 98.78,115.07 95.97,112.26 90.08,112.26 89.74,112.61 89.74,114.18 89.75,114.19 89.75,117.55 90.56,118.36 90.56,121.31 89.85,122.02 89.85,126.39 90.26,126.79 95.08,126.79
+1V_S5 on BOTTOM (solid shape): 159.73,125.75 159.73,125.27 159.71,125.25 159.69,125.23 159.66,125.17 159.66,125.11 159.66,124.83 159.71,124.69 159.86,124.63 160.16,124.63 160.3,124.69 160.36,124.83 160.36,124.89 160.45,124.99 161.48,124.99 161.78,124.69 163.13,124.69 164.13,123.69 164.13,122.8 163.59,122.27 161.19,122.27 161.11,122.35 161.11,122.94 160.99,123.06 159.52,123.06 159.09,122.63 156.39,122.63 156.31,122.71 156.31,122.87 156.39,122.96 157.05,122.96 158.43,124.33 158.43,124.52 158.43,124.58 158.43,124.64 158.43,125.31 158.2,125.54 158.2,125.84 158.44,126.08 159.4,126.08
+1V_S5 on BOTTOM (solid shape): 173.98,78.58 173.98,78.2 173.96,78.16 173.93,78.15 173.67,78.15 173.65,78.15 173.63,78.17 172.95,77.97 173.63,77.78 173.65,77.8 173.67,77.8 173.93,77.8 173.96,77.79 173.98,77.75 173.98,76.2 173.68,75.9 172.46,75.9 171.67,76.69 171.4,76.69 170.73,77.36 170.73,78.33 171.2,78.81 173.76,78.81
+1V_S5 on SVCC (solid shape): 103.72,122.28 103.72,116.66 93.81,106.63 93.81,83.52 92.72,82.42 88.82,82.42 84.42,86.82 84.42,87.88 83.36,87.88 78.83,92.41 78.83,107.23 94.79,123.19 102.42,123.19
+1V_S5 on SVCC (solid shape): 179.41,119.67 179.41,77.78 179.25,77.7 179.16,77.42 177.68,75.94 173.49,75.94 172.6,75.05 172.03,75.05 171.54,75.54 171.54,77.32 171.16,77.7 171.16,89.74 172.3,90.88 172.3,105.68 174.59,107.97 174.59,114.78 173.3,116.07 170.7,116.07 169.51,117.27 169.51,120.5 168.22,121.79 160.85,121.79 158.46,124.18 158.46,125.07 158.2,125.32 158.2,128.06 158.46,128.31 158.46,128.56 160.24,130.34 160.24,133.01 160.32,133.09 165.99,133.09
+1V_S5 on IN1 (solid shape): outline of 343 points within 170.22,45.21 174.33,78.99
+1V_S5 on IN1 (solid shape): outline of 1933 points within 143.98,116.01 160.2,135.17
+1V_S5 on IN2 (solid shape): outline of 609 points within 98.26,33.33 173.33,78.86
+1V_S5 on IN2 (solid shape): outline of 1343 points within 142.84,116.07 161.46,125.34
+1V_SUS on BOTTOM (solid shape): 150.76,137.26 150.76,136.7 150.61,136.55 150.36,136.55 150,136.9 147.82,136.9 147.61,137.11 147.61,137.87 147.87,138.12 149.9,138.12
+1V_VCCST on BOTTOM (solid shape): 149.16,136.37 149.16,135.38 148.91,135.12 147.76,135.12 147.61,134.97 147.61,134.73 147.61,134.47 147.61,134.45 147.61,133.4 146.84,132.63 146.72,132.59 146.63,132.68 146.63,133.77 146.68,133.83 146.68,135.24 147.19,135.75 147.19,136.23 147.46,136.5 148.78,136.5 148.83,136.55 148.98,136.55
+3V on TOP (solid shape): 28.92,113.66 28.92,112.39 28.79,112.26 27.39,112.26 27.27,112.39 27.27,113.53 27.52,113.79 28.79,113.79
+3V on TOP (solid shape): 40.96,42.54 40.96,41.78 40.73,41.55 38.75,41.55 38.6,41.7 38.6,42.46 38.8,42.67 40.83,42.67
+3V on TOP (solid shape): 132.42,190.5 132.42,188.21 132.17,187.96 131.53,187.96 131.28,188.21 131.28,190.5 131.53,190.75 132.17,190.75
+3V on TOP (solid shape): 84.92,87.12 88.48,87.12 88.61,86.99 88.61,83.82 88.23,83.43 83.4,83.43 82.77,84.07 82.77,87.24 83.4,87.88 84.16,87.88
+3V on TOP (solid shape): 25.87,42.79 26.38,42.79 26.5,42.67 26.5,42.16 26.38,42.03 26.12,42.03 25.62,41.52 25.36,41.52 25.11,41.78 25.11,42.79 25.23,42.92 25.74,42.92
+3V on TOP (solid shape): 160.36,186.43 160.36,185.92 160.16,185.72 159.42,185.72 159.35,185.8 157.31,185.8 157.19,185.92 157.19,186.33 157.29,186.43 159.14,186.43 159.5,186.79 160.01,186.79
+3V on TOP (solid shape): 147.54,199.51 147.54,198.24 147.15,197.86 145.88,197.86 145.5,197.48 145.5,196.85 145.38,196.72 143.09,196.72 142.71,197.1 142.71,197.48 143.09,197.86 143.73,197.86 144.49,198.62 144.49,199.51 144.74,199.77 147.28,199.77
+3V on TOP (solid shape): 164.55,152.78 164.55,149.6 164.17,149.22 163.66,149.22 163.54,149.35 163.54,149.6 163.79,149.86 163.79,150.62 163.66,150.74 161.89,150.74 161.76,150.62 161.76,150.11 161.63,149.98 161.25,149.98 161.25,151.38 162.9,153.03 164.3,153.03
+3V on TOP (solid shape): 19.93,112.26 19.93,112.09 20.23,111.78 20.23,111.68 20.23,111.68 20.23,110.69 20.03,110.69 20.03,110.71 20.03,111.58 19.94,111.67 19.43,111.67 19.39,111.63 18.88,111.63 18.63,111.88 18.63,112.01 19.01,112.39 19.8,112.39
+3V on TOP (solid shape): 116.67,183.89 116.67,182.37 116.8,182.24 117.69,182.24 117.94,182.49 117.94,183.76 118.07,183.89 118.45,183.89 118.71,183.64 118.71,182.62 116.93,180.84 116.55,180.84 116.42,180.97 116.42,181.48 115.79,182.11 115.79,184.02 115.91,184.15 116.42,184.15
+3V on TOP (solid shape): 211.34,44.73 211.34,43.79 210.83,43.28 209.13,43.28 208.88,43.53 208.88,44.08 208.91,44.17 209,44.2 209.06,44.21 209.12,44.23 209.33,44.46 209.29,44.77 209.29,44.86 209.51,45.08 210.99,45.08
+3V on TOP (solid shape): 165.96,129.29 166.18,129.03 166.52,129.05 166.86,129.05 169.32,126.59 170.55,126.59 170.98,126.15 170.98,125.83 170.79,125.64 169.72,125.64 169.51,125.85 169.2,125.85 168.64,126.41 167.93,126.41 167.4,126.94 167.4,127 166.26,128.14 164,128.14 163.89,128.25 163.89,129.17 164.06,129.34 165.95,129.34
+3V on TOP (solid shape): 170.35,107.94 170.54,107.94 170.65,107.83 170.65,107.06 170.5,106.91 170.5,106.91 170.24,106.65 168.85,106.65 168.74,106.75 168.74,107.14 168.78,107.16 168.9,107.25 168.97,107.37 168.97,107.39 169,107.41 169,107.69 168.92,107.77 168.92,108.01 168.69,108.48 168.22,108.24 168.21,108.2 167.81,108.2 167.7,108.3 167.7,108.63 167.78,108.7 168.16,108.7 168.21,108.65 168.87,108.65 169.19,108.97 169.32,108.97
+3V on TOP (solid shape): 57.37,31.64 57.37,29.71 57.11,29.46 56.22,29.46 55.89,29.79 55.86,29.91 55.94,30 56.04,30.64 55.45,30.38 55.44,30.32 53.02,30.32 52.83,30.13 52.71,30.05 52.63,29.93 52.54,29.84 52.54,24.25 52.03,23.74 47.96,23.74 47.59,24.12 47.59,26.41 49.51,28.34 49.51,29.23 52.16,31.87 57.13,31.87
+3V on TOP (solid shape): 91.31,41.38 91.31,40.34 90.99,40.02 87.94,40.02 87.42,39.49 87.42,34.12 87.07,33.78 87.07,30.35 87.76,29.66 87.76,27.89 84.49,24.62 80.85,24.62 80.69,24.78 80.69,25.99 80.9,26.2 80.91,26.2 82.59,27.87 82.61,27.87 82.77,27.91 82.9,28.01 82.99,28.05 83.09,28.01 83.64,27.95 83.77,28.49 83.76,28.59 83.83,28.66 83.91,28.71 83.98,28.78 84.08,28.82 84.17,28.78 84.87,28.88 84.5,29.47 84.38,29.55 84.41,29.69 84.42,29.7 84.42,39.99 86.38,41.95 90.74,41.95
+3V on TOP (solid shape): outline of 617 points within 170.65,87.28 193.4,101.21
+3V on BOTTOM (solid shape): 83.13,27.05 83.13,25.08 83,24.96 80.67,24.96 80.52,25.11 80.52,25.21 80.52,25.27 80.52,25.32 80.52,26.23 80.67,26.38 81.73,26.38 82.52,27.17 83,27.17
+3V on BOTTOM (solid shape): 212.97,45.3 212.97,43.96 212.56,43.56 211.67,43.56 211.47,43.76 210.35,43.76 210.18,43.92 210.18,44.77 210.43,45.02 211.61,45.02 211.8,45.21 211.81,45.21 212.04,45.44 212.83,45.44
+3V on BOTTOM (solid shape): 166.03,129.05 166.03,128.69 165.82,128.48 165.29,128.48 164.97,128.16 164.43,128.16 164.43,128.16 164.19,128.16 163.43,128.16 163.27,128.16 162.61,127.5 162.32,127.5 162.29,127.53 162.29,127.99 162.33,128.02 162.54,128.02 163.29,128.77 164.3,128.77 164.93,129.41 165.67,129.41
+3V on BOTTOM (solid shape): 31.03,62.99 31.03,60.96 29.76,59.69 25.36,59.69 25.11,59.94 25.11,61.2 25.23,61.2 25.24,61.14 25.25,61.09 25.28,61.04 25.31,60.99 25.34,60.94 25.38,60.91 25.43,60.88 25.48,60.85 25.53,60.84 25.59,60.83 25.64,60.83 25.7,60.84 25.75,60.85 25.8,60.88 25.85,60.91 25.89,60.94 25.93,60.99 25.96,61.04 25.98,61.09 25.99,61.14 26,61.2 26,61.25 25.99,61.31 25.97,61.36 25.94,61.41 25.91,61.45 25.87,61.49 25.83,61.53 25.78,61.56 25.73,61.58 25.67,61.59 25.62,61.59 25.56,61.59 25.51,61.58 25.45,61.56 25.4,61.53 25.36,61.49 25.32,61.45 25.29,61.41 25.26,61.36 25.25,61.31 25.24,61.25 25.23,61.2 25.11,61.2 25.11,62.45 26.45,63.8 30.21,63.8
+3V on BOTTOM (solid shape): 27.88,105.61 27.88,104.24 27.52,103.88 27.52,102.23 27.39,102.1 24.22,102.1 22.95,103.37 22.86,103.37 22.84,103.39 22.8,103.42 22.75,103.44 22.7,103.46 22.64,103.46 22.59,103.46 22.54,103.46 22.49,103.44 22.44,103.42 22.4,103.39 22.38,103.37 20.99,103.37 20.71,103.65 18.99,103.65 18.86,103.78 18.86,104.06 19.11,104.31 20.33,104.31 20.41,104.39 21.44,104.39 21.44,104.34 21.45,104.28 21.47,104.23 21.5,104.19 21.53,104.14 21.57,104.11 21.61,104.07 21.66,104.05 21.71,104.03 21.77,104.02 21.82,104.02 21.87,104.03 21.93,104.04 21.97,104.06 22.02,104.09 22.06,104.12 22.1,104.16 22.13,104.21 22.15,104.26 22.17,104.31 22.17,104.36 22.17,104.42 22.17,104.47 22.15,104.52 22.13,104.57 22.1,104.62 22.06,104.66 22.02,104.69 21.97,104.72 21.93,104.74 21.87,104.75 21.82,104.76 21.77,104.76 21.71,104.75 21.66,104.73 21.61,104.71 21.57,104.67 21.53,104.64 21.5,104.59 21.47,104.55 21.45,104.5 21.44,104.44 21.44,104.39 20.41,104.39 21.2,105.18 22.87,105.18 23.61,104.44 25.95,104.44 27.24,105.74 27.75,105.74
+3V on BOTTOM (solid shape): outline of 91 points within 25.62,73.27 29.55,75.94
+3V on BOTTOM (solid shape): 27.84,43.16 27.87,43.07 27.81,42.99 27.62,42.83 27.58,42.6 27.58,42.24 27.88,42.05 27.9,42.05 28.04,42.07 28.15,42.14 28.22,42.17 28.29,42.14 28.71,42.09 28.9,42.47 28.92,42.56 29,42.59 34.73,42.59 35.55,43.4 39.64,43.4 39.94,43.1 39.94,41.4 39.74,41.19 38.22,41.19 38.13,41.24 38.13,41.35 38.12,41.72 37.78,41.89 37.7,41.92 37.67,42 37.04,42.29 37.33,41.67 37.41,41.64 37.44,41.56 37.45,41.45 37.49,41.35 37.48,41.24 37.4,41.19 32.02,41.19 31.43,40.61 25.31,40.61 25.01,40.92 25.01,41.03 25.02,41.04 25.1,41.28 25.01,41.51 25.01,41.87 25.01,44.32 25.23,44.55 26.45,44.55
+3V on SVCC (solid shape): 174.08,114.57 174.08,108.18 171.79,105.89 171.79,92.07 170.9,91.18 166.92,91.18 166.59,91.52 166.59,93.51 169,95.92 169,101.43 164.55,105.87 164.55,108.86 164.91,109.22 169.4,109.22 169.94,108.68 170.6,108.68 171.11,109.19 171.11,110.79 171.03,110.87 171.03,115.33 171.26,115.57 173.08,115.57

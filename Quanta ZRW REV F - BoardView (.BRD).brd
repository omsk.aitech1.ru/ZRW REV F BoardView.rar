# Allegro board Quanta ZRW REV F - BoardView (.BRD).brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
+1.35VSUS: length 294.4
  TOP w0.203: C308.2 142.71,111.73 v2(142.72,111.73)
  TOP w0.508: 117.56,43.94 114.39,43.94 113.37,44.95 113.37,46.1 112.86,46.6 107.78,46.6 106.64,47.75 106.64,50.41 104.61,52.45 104.61,55.27 106.1,56.76 106.1,60.6 105.66,61.05 103.83,61.05 103.39,61.49 103.39,63.32 102.9,63.81 101.81,63.81 96.52,58.52 94.93,58.52 v1(94.2,57.78) 93.31,56.89 R330.2 ; v1(94.32,72.89) 94.32,72.51 95.34,71.5 95.34,70.85 R309.2 ; C323.1 144.11,107.65 v1(144.27,107.49) ; 144.41,75.48 150.46,75.48 150.71,75.74 150.71,76.81 147.28,80.23 147.28,87.47 150.1,90.29 v1(157.37,90.29)
  TOP w1.27: 175.98,70.68 175.62,70.68 173.32,68.38 173.32,51.68 176.06,48.94
  IN1 w0.508: v1(144.27,107.49) 144.27,107.78 142.74,109.32 142.74,111.72 v2(142.72,111.73) ; v1(94.2,57.78) 94.32,57.91 v1(94.32,72.89) 94.45,73.02 94.45,74.32 94.91,74.77 94.91,77.88 95.39,78.35 95.39,81.48 94.65,82.22 94.65,89.58 94.07,90.17 94.07,91.69 v1(95.21,92.83)
  IN2 w0.305: v4(175.53,42.85) 176.42,42.85 177.63,44.06 184.39,44.06 185.94,45.61 185.94,50.62 185.31,51.25 185.31,54.74 185.66,55.09 185.66,62.53 182.99,65.2 182.99,66.65 182.51,67.13 v1(181.9,67.13)
  BOTTOM w0.132: v1(134.02,106.81) 134.02,106.81 134.02,108.72 U35.BB41 ; v1(144.27,107.49) 144.24,107.49 144.01,107.72 144.01,108.43 143.96,108.48 U35.BB23
  BOTTOM w0.178: U35.BB47 130.37,107.66 130.39,107.64 v1(130.39,107.49) ; U35.BB32 138.99,108.71 138.99,106.84 139.15,106.68 v1(139.15,106.45) ; U35.BB51 127.91,107.67 v1(127.88,107.64)
  BOTTOM w0.203: v1(181.9,67.13) 181.8,67.24 PU15.9
  BOTTOM w0.254: JDIM2.99 133.04,56.52 v1(133.18,56.66) ; v1(135.17,57.3) 134.84,56.98 JDIM2.105
  BOTTOM w0.305: JDIM2.93 131.24,56.74 130.59,57.4 v1(130.26,57.4) ; JDIM1.88 129.74,58.43 130.14,58.03 v1(130.26,58.03) ; v1(136.88,56.79) 136.64,56.56 JDIM2.111 ; JDIM2.124 140.54,45.61 v1(140.25,45.31) ; JDIM2.118 138.74,45.68 v1(138.43,45.36) ; JDIM1.111 136.64,70.05 v1(136.69,70.1) 137.88,70.1 138.44,69.54 JDIM1.117 ; v1(130.31,58.66) 131.09,58.66 131.54,59.12 JDIM1.94 ; U35.AU28 v2(139.98,111.76) ; JDIM1.105 134.84,69.58 132.93,71.5 v1(131.53,71.5) ; U35.AU23 v2(142.72,111.73) ; JDIM1.106 135.14,58.9 135.09,58.85 v1(135.09,58.82) ; U35.AU35 v2(136.32,111.11) ; JDIM1.100 133.34,59.14 134.33,58.16 v1(135.09,58.16) ; v1(139.31,57.05) 138.68,57.05 138.44,56.81 JDIM2.117 ; v2(132.68,111.11) 133.11,111.43 U35.AU42 ; JDIM1.76 126.14,58.6 126.71,58.03 v1(127.09,58.03) 127.22,58.03 127.94,58.76 JDIM1.82 ; v1(127.13,56.89) 127.64,56.38 JDIM2.81 ; JDIM2.112 v1(136.94,45.37) ; v1(131.53,70.7) 131.53,70.26 131.24,69.97 JDIM1.93 ; v1(131.53,70.7) 132.28,70.7 133.04,69.93 JDIM1.99 ; v1(131.53,70.7) 130.48,70.7 129.44,69.66 JDIM1.87 ; 125.51,70.22 127.04,70.22 127.64,69.62 JDIM1.81 ; 125.51,70.22 v1(125.22,70.52) ; 125.51,70.22 125.84,69.89 JDIM1.75 ; v1(131.57,45.62) 131.54,45.64 JDIM2.94 ; JDIM2.106 v1(135.14,45.33) ; v1(140.8,70.35) 140.8,70.06 140.24,69.5 JDIM1.123 ; v1(125.13,57.15) 125.6,56.68 125.6,56.67 125.84,56.42 JDIM2.75 ; JDIM1.118 138.74,58.95 139.05,58.65 v1(139.76,58.65) 140.09,58.65 140.54,59.1 JDIM1.124 ; v1(130.26,56.76) 129.89,56.76 129.44,56.31 JDIM2.87 ; JDIM2.76 126.14,45.91 v1(125.44,45.21) ; JDIM1.112 136.94,58.97 v1(137.25,58.67) ; v1(127.94,45.62) JDIM2.82 ; JDIM2.100 v1(133.34,45.49) ; v1(129.74,45.61) JDIM2.88 ; v1(140.31,56.83) 140.24,56.76 JDIM2.123
  BOTTOM w0.508: v1(157.37,90.29) 157.19,90.29 155.54,91.94 155.54,92.58 154.65,93.47 154.65,97.27 R679.1 ; Q35.2 v3(98.46,98.14) 97.22,98.14 95.85,96.77 95.85,95.84 95.21,95.21 v1(95.21,92.83)
  vias: v1(177,70.99) v1(177,70.35) v1(177,48) v1(177,47.37) v3(174.82,49.68) v4(172.53,38.96) v4(172.53,38.13) v4(173.19,39.75) v4(173.29,38.96) v4(173.29,38.15) v4(173.95,39.75) v4(174.05,38.96) v4(174.05,38.15)
+1V_S5: length 138.8
  TOP w0.508: v1(105.37,142.74) 101.82,139.19 101.82,136.01 98.77,132.96 96.48,132.96 92.04,128.52 92.04,121.28 v1(91.15,120.39)
  IN1 w0.508: v1(125.82,141.47) 126.15,141.8 129.12,141.8 129.47,141.46 136.67,141.46 136.76,141.36 139.42,138.71 143.78,138.71 144.31,139.24 150.05,139.24 152.18,137.11 154.09,137.11 155.28,135.91 v1(156.65,135.91) 159.5,133.07 159.5,131.87 160.36,131.01 v1(160.77,131.01)
  BOTTOM w0.076: U35.K19 146.08,125.41
  BOTTOM w0.254: PC212.1 89.45,116.45 88.89,115.9 88.89,111.1 87.41,109.62 70.9,109.62 69.68,110.84 69.68,112.9 70.83,114.04 PR251.1 ; 154.6,134.34 153.46,133.19 152.3,133.19 151.08,131.97 149.34,131.97 148.78,131.42 148.78,130.84 U35.A14 ; U35.A10 151.48,131.9 152.44,132.85 153.64,132.85 C680.1
  BOTTOM w0.279: U35.L21 144.77,124.67 144.77,124.67 144.75,124.61 144.48,124.35 144.47,124.35 v2(144.47,124.23)
  BOTTOM w0.305: U35.Y18 146.27,120.01 146.27,119.85 146.08,119.66 U35.AB19 145.8,119.36 145.8,119.22 ; v2(145.76,120.9) 145.76,120.99 U35.V20 U35.V21 ; U35.L19 145.76,124.34 v2(145.76,124.25) ; U35.AK20 145.01,115.87 144.59,115.87 v2(144.23,116.23) ; 146.08,125.41 v2(145.76,125.08) ; 145.8,119.22 v2(145.76,119.22) U35.AB20 ; 145.8,119.22 146.96,119.22 U35.AB17 ; v2(147.11,125.09) 147.11,125.23 U35.K17 ; v2(145.11,124.25) 145.11,124.15 U35.N20 ; U35.K15 148.4,125.22 v2(148.4,125.09) 148.4,124.96 U35.L15 ; U35.V15 148.67,121.32 148.38,121.6 v2(148.38,121.73) ; U35.N16 147.71,124.15 v2(147.71,124.25) 147.53,124.25 147.38,124.1 U35.N17 ; U35.AF21 v2(145.11,118.38) U35.AF20 ; U35.N15 148.36,124.15 v2(148.36,124.25) ; v2(146.41,123.41) 146.41,123.32 U35.P18 ; v2(146.42,121.74) 146.42,121.82 U35.T19 145.91,122.32 145.6,122.32 U35.T20 ; U35.N18 146.73,123.9 v2(146.41,124.22) ; U35.AF19 146.08,117.87 v2(146.41,117.54) U35.AF18 ; U35.P15 v2(148.36,123.41) ; U35.P16 v2(147.71,123.41)
  BOTTOM w0.508: v1(105.37,142.74) 106.26,142.74 107.53,141.47 PQ23.3 ; v1(125.82,141.47) R512.2
  vias: v1(146.42,119.68) v1(149.77,121.79) v1(153.2,133.68) v1(153.62,134.16) v1(154.04,134.63) v1(155.52,131.4) v1(157.06,131.4) v1(158.41,125.75) v1(158.71,127.59) v1(159.3,129.08) v1(159.35,125.75) v1(159.93,129.08) v1(160.41,123.41) v1(161.04,123.39) v3(158.89,126.64) v3(159.6,128.44) v4(90.44,83.82) v4(90.44,83.05) v4(91.43,86.61) v4(91.43,85.72) v4(91.43,84.83) v4(91.43,84.07) v4(91.43,83.23) v4(92.42,85.85) v4(92.42,84.7) v4(92.42,83.82) v4(94.53,112.57) v4(95.08,113.13) v4(95.59,113.71) v4(95.64,112.59) v4(96.18,114.27) v4(96.15,113.18) v4(96.71,114.83) v4(96.74,113.74) v4(97.27,115.39) v4(97.27,114.3) v4(97.8,115.92) v4(97.83,114.85) v4(98.36,116.4) v4(98.36,115.39) v4(106.44,38.68) v4(106.64,40) v4(107.28,38.68) v4(107.48,40) v4(108.12,38.68) v4(108.32,40) v4(108.95,38.68) v4(109.16,40) v4(109.79,38.68) v4(109.99,40) v4(171.46,47.06) v4(171.46,46.33) v4(171.72,78.23) v4(171.72,77.47) v4(172.3,47.8) v4(172.3,47.06) v4(172.3,46.33) v4(172.3,45.59) v4(172.4,78.53) v4(172.4,77.8) v4(172.38,77.06) v4(172.48,76.32) v4(173.14,77.06) v4(173.14,48.54) v4(173.14,47.8) v4(173.14,47.06) v4(173.14,46.33) v4(173.24,76.32)
+1V_S5_ON: length 252
  TOP w0.114: v1(200.6,44.19) v3(201.79,44.19) 202.93,44.19 204.28,42.85 205.85,42.85 206.39,43.38 206.45,43.38 v1(206.67,43.6) ; v1(49.75,104.14) 49.49,104.39 49.49,111.88 51.02,113.41 68.16,113.41 69.56,112.01 70.3,112.01 70.7,112.41 v1(70.7,113.03)
  IN1 w0.127: v1(186.8,29.76) 185.43,29.76 184.95,29.28 183.2,29.28 182.84,29.64 180.4,29.64 179.18,30.86 171.89,30.86 171.59,31.16 171.59,31.82 166.97,36.44 100.42,36.44 79.26,57.6 79.26,57.86 72.61,64.51 68.08,64.51 63.18,69.41 63.18,73.45 60.24,76.4 59.22,76.4 56.63,78.99 55.41,78.99 49.8,84.6 49.03,84.6 47.71,85.92 47.71,88.01 52.03,92.32 52.03,96.26 51.78,96.52 51.78,102.87 50.51,104.14 v1(49.75,104.14)
  IN2 w0.127: v1(186.8,29.76) 188.79,29.76 191.33,32.3 191.33,41.22 193.26,43.15 193.28,43.15 193.31,43.18 195.26,43.18 195.59,43.51 199.91,43.51 v1(200.6,44.19)
  BOTTOM w0.114: PR254.1 v1(70.7,113.03) ; v1(206.67,43.6) 206.75,43.52 U45.2
+1V_SUS: length 140.8
  TOP w0.254: v4(173.32,125.7) 173.32,125.98 171.34,127.96 169.89,127.96 168.46,129.39 168.46,129.65 165.65,132.45 165.1,132.45 164.18,133.37 159.35,133.37 158.46,134.26 158.46,137.08 157.8,137.74 151.35,137.74 v1(150.46,136.85) ; v1(194.88,78.05) 194.96,78.05 195.41,77.59 PR139.1
  IN1 w0.254: v1(194.88,78.05) 194.88,78.51 194.14,79.24 193.33,79.24 191.97,80.6 190.77,80.6 186.14,85.23 186.14,86.7 183.96,88.88 183.96,90.65 184.24,90.93 184.24,97.15 184.37,97.28 184.37,101.44 184.67,101.75 184.67,104.05 180.68,108.04 180.68,109.23 179.29,110.63 179.29,112.04 179.67,112.42 179.67,116.56 178.96,117.27 178.96,120.9 178.6,121.26 178.6,121.94 176.4,124.14 175.13,124.14 173.57,125.7 v4(173.32,125.7)
  IN1 w0.508: v1(126.43,137.84) 126.96,137.84 128.54,136.27 130.9,136.27 131.79,135.38 134.33,135.38 135.2,134.51 136.66,134.51 138.07,135.91 148.17,135.91 148.45,135.63 149.44,135.63 150.46,136.65 v1(150.46,136.85)
  IN2 w0.508: v1(126.43,137.84) 126.05,137.84 125.62,138.27 123.37,138.27 122.3,139.34 121.35,139.34 120.94,139.75 117.94,139.75 117.03,140.66 111.37,140.66 v1(109.84,142.19)
  BOTTOM w0.508: PQ23.1 PC6230.2 110.86,143.2 v1(109.84,142.19)
  BOTTOM w0.762: v1(174.09,125.47) 173.55,125.47 v4(173.32,125.7)
+1V_VCCST: length 221.7
  TOP w0.508: C815.2 154.4,189.34 v1(154.72,189.02) ; v1(148.93,136.27) 151.24,138.58 156.25,138.58 157.52,139.85 157.52,141.89 157.52,141.89 157.52,142.43 157.52,148.11 157.31,148.33 R85.2 157.31,149.97 158.71,151.38 v1(159.73,151.38) ; PR340.1 PR341.1 157.7,182.99 PC6228.1 159.26,182.99 v1(159.5,183.23)
  IN1 w0.508: v1(114.76,143.38) 114.76,140.83 112.99,139.06 v1(112.99,137.54) 110.32,137.54 v1(109.56,138.3) ; v1(126.72,140.16) 136.05,140.16 139.56,136.65 148.55,136.65 v1(148.93,136.27) ; v1(122.51,135.13) 124.6,137.22 v1(124.6,138.93) 124.6,140.38 v1(124.68,140.46)
  IN2 w0.508: v1(112.48,182.75) 113.22,183.49 113.22,184.12 115.15,186.05 115.91,186.05 118.96,189.1 121.37,189.1 122.52,190.24 122.52,191.89 130.86,200.24 132.82,200.24 134.16,201.58 136.07,201.58 v1(137.91,199.74) 138.42,199.74 140.21,201.53 145.01,201.53 147.56,198.98 149.54,198.98 154.72,193.8 v1(154.72,189.02) 154.85,189.02 155.28,188.59 155.28,183.99 156.3,182.98 159.25,182.98 v1(159.5,183.23) ; v1(114.76,143.38) 116.54,141.6 117.38,141.6 117.89,141.08 v1(120.33,141.08) 120.89,141.08 121.76,140.21 v1(122.39,140.21) 122.53,140.36 124.57,140.36 v1(124.68,140.46) 125.18,139.95 126.51,139.95 v1(126.72,140.16)
  BOTTOM w0.203: U35.A18 146.53,132.44 146.9,132.81
  BOTTOM w0.254: U33.5 163.4,162.92 161.51,161.03 161.51,158.36 162.39,157.48
  BOTTOM w0.508: R529.1 R788.1 119.43,141.99 v1(120.33,141.08) 120.73,140.69 R513.2 ; Q31.3 162.39,157.48 161.5,156.59 R488.2 C628.1 161.12,153.67 160.62,153.67 160.23,153.28 C816.2 160.23,151.88 v1(159.73,151.38) ; v1(124.6,138.93) 124.6,138.1 R538.1 ; v1(112.48,182.75) 112.49,182.74 C817.2 112.49,179.54 113.18,178.85 113.18,174.23 113.64,173.77 C819.2 113.64,145.14 114.76,144.01 v1(114.76,143.38) ; v1(112.99,137.54) 112.99,138.04 R134.1 ; v1(122.51,135.13) R559.1 ; R761.2 110.45,137.27 C814.2 ; C814.2 R138.1 ; C814.2 109.57,138.29 v1(109.56,138.3) ; C818.2 138.44,200.27 v1(137.91,199.74) ; R514.1 122.64,140.47 v1(122.39,140.21) ; v1(124.68,140.46) 124.05,140.46 R515.1
+3V: length 816.2
  TOP w0.178: C413.1 25.48,62.62 24.69,63.4 U18.37 ; C386.1 27.47,73.09 27.47,72.31 26.4,71.24 26.12,71.24 25.89,71.01 U18.11
  TOP w0.203: 18.33,106.19 18.33,106.24 18.86,106.78 U13.10 ; v1(21.33,104.82) U13.14
  TOP w0.254: U7.5 194.67,135.72
  TOP w0.279: Q2.2 Q2.5 143.09,192.91 143.47,192.53 v1(143.47,192.27) ; R245.2 187.8,94.2 187.39,94.61 186.58,94.61 186.32,94.86 186.27,94.86 Q23.5
  TOP w0.305: U10.5 176.98,132.09 C180.2 ; R82.2 168.94,149.41 168.56,149.79 168.56,150.11 168.3,150.37 166.99,150.37 165.9,151.46 163.87,151.46 ; U9.5 171.91,133.62 171.9,133.62 171.65,133.62 171.54,133.73 C177.2
  TOP w0.381: R211.1 166,110.23 166.64,109.6 v1(166.64,109.51) ; v1(173.6,113.36) 173.37,113.36 172.82,113.91 R204.2 ; R207.1 166.72,112.01 168.49,112.01 168.69,111.81 171.23,111.81 v1(171.56,112.14) ; v1(30.42,63.17) 30.37,63.17 30.33,63.12 30.08,63.12 29.94,62.99 R319.2
  TOP w0.508: v1(168.11,134.49) 168.72,135.1 168.72,136.24 169.23,136.75 169.23,137.49 R115.2 R110.2 ; Q20.2 177.15,120.54 176.64,120.04 v1(175.15,120.04) ; 160.92,70.61 159.85,69.54 159.85,65.27 160.92,64.21 160.92,61.26 162.45,59.74 163.27,59.74 ; 160.92,70.61 161.44,70.08 v1(163.04,70.08) 162.9,70.23 C390.1 163.54,70.96 163.66,70.84 R305.2 164.04,71.36 164.07,71.4 C388.1 ; 160.92,70.61 160.92,71.42 162.27,72.77 166.42,72.77 167.98,71.21 170.11,71.21 v1(170.17,71.27) ; v1(139.41,190.37) 139.91,190.87 R12.2 ; R311.1 v1(18.24,70.61) ; v1(204.58,38.55) 204.59,38.57 205.15,38.57 R374.2 ; v1(143.09,197.35) 143.14,197.35 143.51,196.98 R7.2 ; R257.1 167.61,91.3 v1(167.09,91.82) ; v1(59.65,107.56) 59.52,107.69 R218.1 ; v1(59.65,107.56) 60.29,108.2 66.52,108.2 R609.1 69.97,109.72 v1(71.38,111.12) ; v1(59.65,107.56) 59.65,99.31 v1(62.32,96.64) ; PR137.1 v1(48.95,78.87) ; v1(202.93,22.81) 202.93,21.67 202.21,20.95 199.1,20.95 198.82,21.23 v1(198.82,21.84) ; v1(161.99,106.41) 161.11,106.41 160.63,106.89 158.45,106.89 156.68,105.12 v1(156.68,103.5) ; R306.2 v1(31.08,70.48) ; R223.2 170.52,104.26 v1(170.14,103.88) 169.9,103.64 R227.2 ; R321.1 24.73,60.96 v1(25.49,60.19) ; R216.2 228.31,109.09 227.41,109.99 R209.2 226.91,110.99 225.39,109.47 219.8,109.47 218.53,108.2 210.53,108.2 v1(208.62,106.29) ; U16.1 79.18,91.44 v1(78.83,91.44) ; R297.1 v1(24.85,74.93) ; C413.1 25.99,62.62 26.38,62.23 26.38,61.08 v1(26,60.7) ; R293.1 v1(23.84,77.47) ; v1(169.53,99.11) 169.53,99.28 169,99.82 R234.2 ; v1(19.14,104.03) 18.61,104.03 C342.1 18.2,104.9 18.33,105.02 18.33,106.19 ; v1(204.17,92.84) C356.1 ; R298.1 v1(25.87,74.93) ; U17.6 202.36,90.5 202.41,90.55 v1(202.41,91.18) C360.1 C353.1 ; 194.74,134.49 195.16,134.49 195.39,134.72 195.39,136.24 v1(195.36,136.27) ; 194.74,134.49 194.67,134.56 194.67,135.72 ; 194.74,134.49 C175.2 ; v1(204.18,78.35) R286.1 ; R285.2 203.16,78.74 203.42,78.48 v1(203.42,78.35) ; 178.65,92.2 178.65,94.1 176.49,96.26 176.49,100.71 177.18,101.39 177.18,103.55 180.96,107.34 180.96,109.67 181.24,109.95 181.24,112.09 180.17,113.15 180.17,116.07 180.38,116.28 v1(180.38,117.85) ; v1(28.03,72.89) 28.03,73.39 C386.1 ; v1(171.56,112.14) 171.82,111.88 174.83,111.88 175.09,111.62 R208.2 ; v1(38.14,78.63) 37.94,78.83 R281.1 37.94,80.89 R277.1 38.56,80.51 40.47,80.51 Q25.2 ; R322.2 v1(29.94,60.82) ; v1(25.23,36.32) R378.1 ; v1(171.87,132.96) 171.54,132.96 171.17,133.34 C177.2 ; R58.2 116.17,179.57 116.67,180.08 116.67,180.96 C41.1 ; R11.1 128.05,192.07 v1(127.39,192.07) ; R365.2 26.01,42.3 v1(25.62,41.91) ; R220.2 175.09,104.44 174.27,103.62 172.42,103.62 171.93,103.13 R228.2 171.93,102.49 v1(171.54,102.1) ; R292.1 v1(22.82,77.47) ; v1(204.81,64.38) R318.1 ; v1(143.37,194.56) 143,194.56 R9.2 ; v1(172.3,49.63) 171.74,49.63 167.59,45.47 165.38,45.47 163.24,47.61 R347.1 163.24,48.85 164.81,50.41 164.81,53.72 164.27,54.26 C448.1 164.27,55.45 C439.1 163.92,56.17 163.64,56.45 v1(163.64,57.27) 163.66,57.3 163.66,59.34 163.27,59.74 ; Q1.2 145.5,199 v1(144.49,197.99) ; 165.57,160.9 v1(166.46,160.9) ; v1(180.89,119.71) 180.89,119.96 180.23,120.62 180.23,122.42 179.79,122.86 179.79,127.41 177,130.21 177,132.07 C180.2 176.99,132.32 177.51,132.84 177.99,132.84 v1(178.02,132.81) ; 190.21,93.34 188.56,93.34 188.56,93.35 R245.2 ; 163.27,59.74 R324.1 ; v1(53.43,19.86) 59.27,14.02 R426.2 ; PR196.1 PR197.1
  TOP w1.016: Q1.2 146.9,199.26 148.16,199.26 148.76,199.86 149.79,199.86 151.41,198.23 151.41,195.45 159.89,186.97 159.89,185.84 165.58,180.15 165.58,176.41 164.62,175.45 164.62,171.67 165.27,171.03 165.27,166.83 164.62,166.19 164.62,162.74 165.57,161.79 165.57,160.55 165.87,160.25 165.87,155.36 163.16,152.65
  IN1 w0.508: v1(208.62,106.29) 208.62,105.53 205.94,102.85 205.94,102.1 204.94,101.1 v1(204.94,92.58) ; v1(62.32,96.64) 62.45,96.64 67.65,91.44 v1(78.83,91.44) ; v1(169.25,129.78) 169.08,129.6 169.08,128.14 170.68,126.54 v1(170.68,125.98) ; v1(161.38,150.24) 161.63,149.98 161.63,149.5 161.05,148.92 161.05,143.71 162.52,142.24 162.52,137.49 163.72,136.29 165.29,136.29 165.66,135.93 166.05,135.93 167.36,134.62 167.98,134.62 v1(168.11,134.49) 168.11,133.7 168.85,132.96 v1(168.85,132.08) 169.84,132.08 170.12,132.36 171.26,132.36 v1(171.87,132.96) 172.07,133.17 174.09,133.17 174.74,132.52 176.68,132.52 176.97,132.81 v1(178.02,132.81) ; v1(117.07,138.43) 117.07,140.93 118.9,142.76 118.9,154.89 118.9,155.56 120.36,157.02 120.36,162.04 119.02,163.38 119.02,173.17 116.55,175.64 116.55,179.45
  IN1 w1.016: 39.84,41.02 40.45,40.41 45.66,40.41 48.93,37.13 48.96,37.13 49.9,36.19 49.9,32.71 51.9,30.7 v1(51.9,25.01) v1(51.9,24.13) 51.9,21.08 53.12,19.86 v1(53.43,19.86) 57.34,19.86 59.68,22.2 59.68,23.14 60.87,24.33 72.61,24.33 73.16,23.77 77.84,23.77 ; v1(51.27,77.92) 49.9,77.92 v1(48.95,78.87) 48.04,78.87 47.43,78.25 46.6,78.25 44.72,80.13 39.64,80.13 v1(38.14,78.63) 37.6,78.1 30.06,78.1
  IN2 w0.508: v1(28.49,112.64) 32.98,112.64 36.28,109.34 38.95,109.34 39.71,110.1 42.13,110.1 42.51,109.72 48.72,109.72 50.38,108.07 54.44,108.07 55.49,109.11 58.1,109.11 v1(59.65,107.56) ; v1(169.25,129.78) 169.25,130.76 171.46,132.96 v1(171.87,132.96) ; v1(170.68,125.98) 170.95,125.98 171.74,125.19 171.74,122.97 172.11,122.6 172.71,122.6 174.21,121.1 174.21,120.6 174.76,120.04 v1(175.15,120.04) ; v1(161.99,106.41) 161.99,109.19 162.39,109.6 162.9,109.6 ; v1(202.93,22.81) 203.37,22.81 203.67,23.11 203.67,26.35 202.25,27.77 202.25,28.91 203.92,30.59 203.92,34.87 201.79,37 201.79,38.58 202.63,39.42 203.44,39.42 204.3,38.55 v1(204.58,38.55) ; v1(54.97,76.22) 53.3,76.22 51.6,77.92 v1(51.27,77.92)
  IN2 w1.016: 28.41,75.94 30.21,77.75 30.21,88.03 30.7,88.51 30.7,98.55 30.06,99.18 28.54,99.18 26.38,101.34
  BOTTOM w0.254: v1(168.11,134.49) 168.11,134.23 R561.1 ; v1(161.99,106.41) 161.85,106.55 R630.1
  BOTTOM w0.279: Q32.2 164.91,126.95 165.09,127.12 165.09,127.91 164.63,128.37 ; Q43.2 198.97,23.11 198.82,22.96 v1(198.82,21.84) ; Q43.5 202.53,23.11 202.83,22.81 v1(202.93,22.81) ; v1(167.55,127.2) 167.29,126.95 Q32.5
  BOTTOM w0.305: v1(163.64,57.27) 163.04,56.68 JDIM2.199 ; JDIM1.199 v1(163.04,70.08)
  BOTTOM w0.381: R780.2 169.51,132.08 v1(168.85,132.08) ; R572.2 169.77,129.55 169.54,129.78 v1(169.25,129.78) 168.83,130.2 R781.2
  BOTTOM w0.457: R575.2 R574.2 R573.2
  BOTTOM w0.508: v1(54.97,76.22) 54.97,76.58 PR293.2 ; v1(170.17,71.27) 171.55,69.9 PR295.2 ; 138.86,187.32 139.28,186.9 139.28,185.92 138.9,185.54 137.76,185.54 136.87,184.65 R444.2 ; 138.86,187.32 139.79,188.25 v1(139.79,188.59) ; 138.86,187.32 R448.1 ; R576.2 R577.2 170.14,126.74 170.68,126.21 v1(170.68,125.98) ; v1(167.09,106.68) R629.1 ; v1(117.07,138.43) 116.82,138.18 R533.1 ; v1(195.36,136.27) 191.99,136.27 191.86,136.39 191.05,136.39 190.67,136.01 182.59,136.01 180.68,134.11 180.56,134.11 179.08,132.63 178.19,132.63 v1(178.02,132.81) ; v1(180.89,119.71) 180.89,119.66 181.11,119.43 181.11,118.26 180.71,117.85 v1(180.38,117.85) ; v1(38.14,78.63) 41.5,82 R711.1 ; 163.84,109.7 163.82,109.72 R618.2 ; 163.84,109.7 v1(163.92,109.7) ; 163.84,109.7 163.87,109.72 R619.1 ; v1(166.46,160.9) 166.2,160.9 165.44,161.67 R485.1 ; PR266.2 207.1,103.5 208.37,104.77 208.37,106.04 v1(208.62,106.29) ; 26.5,41.02 26.5,38.86 25.87,38.22 25.87,36.57 25.62,36.32 v1(25.23,36.32) ; PR257.2 v1(71.38,111.12) ; v1(18.25,75.94) 18.25,75.31 18.12,75.18 Q41.2 ; R722.1 13.8,73.46 14.62,72.64 18,72.64 v1(18.25,72.89) ; v1(166.64,109.51) 166.64,109.37 166.47,109.2 R625.1 ; R789.2 164.58,96.59 165.38,96.59 165.61,96.36 165.61,95.37 165.47,95.23 165.47,94.45 166.23,93.69 166.23,92.68 v1(167.09,91.82) ; R723.1 215.58,62.25 214.46,63.37 v1(210.65,63.37) ; PR304.2 195.29,65.15 v1(194.91,64.77) ; R631.2 164.79,106.55 v1(165.06,106.28) ; R449.1 v1(139.41,190.37) ; R639.1 v1(156.68,103.5)
  BOTTOM w0.762: v1(19.01,111.88) 19.01,113.15 22.19,116.33 26.25,116.33 28.49,114.09 v1(28.49,113.41) v1(28.49,112.64) 28.03,112.64 27.5,112.11 27.5,104.44 27.24,104.19
  BOTTOM w1.016: 25.77,44.12 25.77,51.69 26.58,52.5 26.58,59.13 27.52,60.07 ; 28.54,74.16 29.04,73.66 29.04,65.02 27.39,63.37 27.39,61.84 26.63,61.08
  vias: v1(25.23,102.36) v1(25.49,42.67) v1(26,102.36) v1(27.9,75.56) v1(28.54,75.56) v1(38.98,41.88) v1(39.61,41.86) v1(80.71,25.75) v1(81.34,25.75) v1(81.28,25.12) v1(81.91,25.12) v1(81.98,25.75) v1(90.13,41.27) v1(90.45,40.64) v1(90.77,41.27) v1(91.08,40.64) v1(117.31,181.61) v1(117.82,182.09) v1(131.53,189.99) v1(132.04,190.5) v1(165.09,128.88) v1(165.72,128.88) v1(169.23,108.89) v1(169.25,108.25) v1(170.98,95.88) v1(170.98,95.25) v1(193.13,90.65) v1(193.13,90.01) v1(193.13,89.38) v1(193.13,88.74) v1(210.5,44.6) v1(210.5,43.96) v3(25.79,103.53)
+3V3_TPM: length 10.2
  BOTTOM w0.406: v1(213.55,47.98) 213.6,47.98 214.11,48.48 U44.24 ; U44.10 217.36,56.67 217.45,56.76 217.45,57.46 217.89,57.91 C768.1 ; C774.1 217.64,47.49 217.36,47.77 U44.19
  BOTTOM w0.508: v1(217,46.99) C774.1 ; v1(218.02,57.15) 218.14,57.26 C768.1 ; v1(213.83,59.94) R724.1 214.46,59.57 214.59,59.43 R727.1
  vias: v1(213.55,47.34) v3(214.62,47.54)
+3V3_TPM_VSB: length 8.6
  BOTTOM w0.406: U44.5 214.11,56.26 213.32,57.04 C766.1
  BOTTOM w0.508: R723.2 213.32,61.21 213.32,61.18 v3(212.74,60.6) 212.18,60.04 212.15,60.04 R725.1 C767.1 212.16,58.03 C766.1
+3V_CR:
  vias: v3(58.38,30.98)
+3V_EC: length 1.7
  BOTTOM w0.203: v1(206.54,40.43) 206.54,40.31 206.93,39.91 U45.11
  vias: v3(208.34,40.69)
+3V_GFX: length 346.3
  TOP w0.381: v1(174.54,146.83) 174.58,146.79 R91.2 ; R108.2 168.3,141.47 170.01,141.47 170.28,141.74 170.28,142.51 170.58,142.8 171.74,142.8 172.17,142.36 ; R90.2 162.92,146.48 v1(163.11,146.29) ; R101.1 205.77,141.61 v1(206.06,141.32)
  TOP w0.508: R382.2 197.02,34.62 v1(197.12,34.51) ; v1(206.39,36.37) 206.31,36.44 205.75,36.44 205.49,36.71 R379.2 ; 170.9,138.55 171.56,138.55 171.84,138.83 v1(171.84,139.29) ; C145.1 190.51,146.01 191.43,145.09 191.6,145.09 191.86,144.84 191.86,143.99 192.69,143.16
  TOP w1.016: v1(100.29,27.55) 101.33,26.51 164.5,26.51 165.39,25.62 177.79,25.62 178,25.84 178.08,25.84 v1(178.08,26.2)
  IN1 w0.508: 208.04,36.22 208.01,36.19 206.57,36.19 v1(206.39,36.37) ; v1(196.38,23.47) 196.94,24.02 196.94,28.27 199.25,30.58 199.25,32.6 199.07,32.78 199.07,33.6 198.16,34.51 v1(197.12,34.51)
  IN1 w1.016: 211.52,45.44 211.52,42.77 213.12,41.17 213.12,39.28 210.05,36.22 208.04,36.22 208.04,30.4 208.6,29.84 208.6,29.25 v1(209.03,28.82) v1(209.92,28.82) ; 212.5,48.7 212.51,48.71 213.07,49.27 213.07,51.15 216.24,54.33 216.24,57.4 217.89,59.05 217.89,59.94 216.41,61.42 216.41,64.48 214.06,66.83 214.06,68.17 210.68,71.55 210.68,91.21 214.95,95.47 215.23,95.47 216.04,96.29 216.07,96.29 217.44,97.66 217.44,100.55 217.41,100.58 217.41,102.46 215.48,104.39 215.48,108.68 214.59,109.57 214.59,118.39 210.27,122.7 210.27,134.36 209.26,135.38 209.26,139.82
  IN2 w0.508: 196.56,20.09 196.38,20.27 v1(196.38,23.47) ; v1(211.75,47.93) 211.34,47.52 209.46,47.52 207.68,49.3 206.69,49.3 205.78,50.21 v1(205.19,50.21)
  IN2 w1.016: 210.78,27.96 211.29,27.45 211.29,22.86 211.09,22.65 211.09,20.49 210.07,19.48 209.18,19.48 205.75,16.05 199.53,16.05 197.32,18.26 197.32,19.33 196.56,20.09 193.69,20.09 192.48,21.3 192.48,24.93 191.4,26.01 189.8,26.01 188.99,25.19 179.21,25.19
  BOTTOM w0.381: v1(165.37,147.7) 165.37,147.65 R498.2 164.72,147.11 164.5,146.88 164.43,146.88 163.83,146.29 v1(163.11,146.29) ; R489.2 165.66,150.11 v1(165.95,150.11) ; R499.2 185.27,140.24 v1(185.25,140.23)
  BOTTOM w0.457: v1(189.75,138.22) 189.75,138.75 R518.2 190.11,138.83 190.35,139.08 R516.2
  BOTTOM w0.508: v1(173.44,141.91) 171.92,140.38 171.92,139.37 v1(171.84,139.29) ; v1(100.29,27.55) 98.89,26.16 90.39,26.16 90.04,26.16 85.79,21.91 85.79,21.19 84.82,20.21 84.82,18.59 82.38,16.15 81.57,16.15 80.91,15.49 v3(78.75,15.49) v1(77.1,15.49) ; v1(188.81,140.08) R508.1 188.85,140.87 R501.2 ; R506.2 v1(183.98,140.2) ; R511.2 182.74,140.61 v1(181.57,139.44) ; v1(186.4,140.2) R507.1 187.52,140.83 R500.2 ; v1(180.56,138.68) 180.43,138.68 180.05,139.06 180.05,139.59 180.3,139.85 R509.2 ; v1(205.19,50.21) R740.2
  vias: v1(174.08,141.91) v1(174.69,141.68) v1(176.1,152.63) v1(176.11,151.89) v1(178.8,26.18) v1(187.62,154.2) v1(198.84,140.08) v1(198.84,139.44) v1(209.26,141.09) v1(209.89,141.09)
+3V_LAN: length 3.5
  TOP w1.016: R248.1 45.14,94.36 v3(45.73,93.78) 45.73,93.75 46.39,93.09 Q24.3
+3V_MAIN: length 47.5
  TOP w0.254: v1(204.81,142.26) 204.81,141.6 204.47,141.26 Q13.5 ; v1(200.49,141.22) 200.53,141.26 Q13.2
  TOP w0.508: v1(166.33,142.87) 166.28,142.87 165.32,141.91 165.32,141.35 164.93,140.97 R104.2
  BOTTOM w0.508: 200.37,141.6 199.86,141.09 198.46,141.09 198.02,140.65 198.02,137.73 197.57,137.28 196.94,137.28 196.68,137.02 192.5,137.02 191.99,137.54 190.97,137.54 190.11,136.67 180.33,136.67 178.07,138.93 176.75,138.93 176.37,138.56 171.53,138.56 169.51,140.58 169.51,141.6 168.24,142.87 v1(166.33,142.87)
  vias: v1(187.69,152.73) v1(189.33,144.68) v1(189.52,142.72) v1(189.57,143.38) v1(206.9,144.57) v1(207,145.33) v1(207.66,145.33) v3(205.3,143.84)
+3V_MAIN_EN: length 32
  TOP w0.114: v1(206.72,138.86) 207.57,138.01 207.57,135.22 207.96,134.82 207.96,133.75 Q17.2 208.75,133.47 209.69,134.41 209.92,134.41 210.27,134.77 v3(210.27,135.81) R118.2
  IN2 w0.127: v1(206.72,138.86) 206.26,139.31 206.01,139.31 205.14,140.18 204.99,140.28 199.33,140.28 195.67,143.94 192.8,143.94 v1(192.57,144.17)
  BOTTOM w0.114: v1(192.57,144.17) 192.57,144.82 193.63,145.87 193.63,147.57 193.07,148.12 U34.A3
+3V_PCH_ME: length 29
  TOP w0.508: R232.2 174.45,101.22 174.08,101.6 v1(172.81,101.6) ; v1(175.95,115.03) 177.71,115.03 178.37,114.37 178.37,112.87 179.29,111.96 179.29,111.58 180.09,110.78 180.09,107.83 176.95,104.69 v3(176.23,104.69) 176.23,104.67 174.52,102.97 v1(172.81,102.97)
  IN1 w0.508: v1(171.41,116.33) 174.38,116.33 175.68,115.03 v1(175.95,115.03)
  BOTTOM w0.508: R597.1 175.96,114.99 175.97,115.01 v1(175.95,115.03) ; v1(171.41,116.33) 171.03,116.33 170.26,115.56 R591.1
+3V_RTC: length 315.5
  TOP w0.381: R249.2 v1(163.79,92.02)
  TOP w0.508: v1(162.78,91.44) 162.04,91.44 R252.2
  TOP w0.635: D7.3 82.85,72.6 v1(83.4,73.15) 83.66,73.41 R299.1 ; R299.1 R300.1 ; R299.1 83.66,74.43 83.91,74.67 C381.1 ; v1(158.08,44.95) 158.08,46.35 156.93,47.49 156.93,53.97 155.67,55.24 155.67,67.43 155.54,67.56 153.12,67.56 151.4,69.29 151.4,77.24 150.11,78.53 147.97,80.67 147.97,87.17 150.25,89.45 150.3,89.45 150.41,89.56 159.09,89.56 v1(159.75,88.9)
  IN1 w0.635: v1(83.4,73.15) 84.04,72.51 84.04,63.7 92.16,55.57 92.16,54.82 102.86,44.13 130.33,44.13 130.9,43.56 141.31,43.56 142.01,44.26 157.38,44.26 v1(158.08,44.95) ; v1(159.75,88.9) 161.51,88.9 162.78,90.17 ; v1(213.07,75.81) 213.07,76.4 213.12,76.45 213.12,76.48 213.55,76.91 213.58,76.91 215.02,78.35 v1(215.48,78.35) 216.04,78.35 217.18,77.21 217.18,73.94 217.64,73.48 217.64,68.17 221.63,64.18 221.63,51.35 220.31,50.03 220.31,48.13 220.71,47.72 220.71,43.76 218.53,41.58 218.53,33.9 213.83,29.21 213.83,26.03 215.35,24.51 215.35,17.52 v1(212.81,14.98)
  IN2 w0.635: v1(212.81,14.98) 212.05,14.22 198.58,14.22 196.67,16.12 194.93,16.12 190.59,20.47 v1(190.59,24.13)
  BOTTOM w0.508: R756.2 216.11,77.73 v1(215.48,78.35) ; R719.1 v1(213.07,75.81)
  BOTTOM w0.635: v1(158.08,44.95) 158.08,39.87 164.15,33.8 167.2,33.8 173.19,27.81 188.73,27.81 190.59,25.95 v3(190.59,25.14) v1(190.59,24.13)
+3V_RTC_1: length 2.9
  TOP w0.508: R308.2 85.06,70.73 85.38,71.06 v3(85.38,71.67) 85.38,71.85 D7.1
+3V_RTC_2: length 4.6
  TOP w0.508: D7.2 84.22,71.24 82.44,71.24 v1(82.33,71.34) 81.79,71.89 R304.1 R301.2
+3V_S5: length 723.1
  TOP w0.254: 54.18,13.85 54.13,13.9 U50.5
  TOP w0.305: C811.2 219.55,22.08 U48.5 ; U49.5 54.18,10.04 C812.2 ; 54.18,13.85 C813.2
  TOP w0.508: v1(212.76,36.04) 212.43,36.37 212.43,38.5 211.05,39.89 R779.1 ; R182.2 162.66,120.72 163.11,120.26 164,120.26 v1(164.25,120.51) ; R167.1 R166.1 R169.2 ; v1(56.55,10.04) C812.2 ; v1(206.62,23.69) 206.27,24.04 204.65,24.04 204.2,24.48 L19.2 R402.1 ; R283.2 160.11,79.37 v1(161.18,78.3) ; R240.2 170.29,98.7 v1(170.08,98.48) ; v1(178.07,111.71) 177.37,112.4 R205.2 176.62,113.36 175.32,114.65 175.32,115.29 175.34,115.3 175.34,115.31 176.42,116.39 176.42,117.17 176.95,117.7 178.07,117.7 R186.2 178.61,117.16 R177.2 ; R275.2 R280.2 151.5,86.64 150.33,85.47 150.33,81.5 155.35,76.48 158.2,76.48 159.35,77.62 159.35,78.22 R290.2 159.5,78.23 160.62,77.11 v1(161.18,77.11) 161.18,74.24 162.03,73.39 166.68,73.39 168.17,71.9 172.19,71.9 173.32,73.02 v1(175.86,73.02) ; 165.95,93.09 165.95,93.85 165.61,94.2 165.61,94.31 164.82,95.1 164.82,95.5 164.46,95.87 164.44,95.87 163.86,96.45 163.86,96.68 163.23,97.31 160.71,97.31 155.03,102.99 v1(155.03,103.5) ; v1(157.37,124.58) 157.37,124.58 157.44,124.5 R169.2 ; v1(177,73.91) 176.8,74.11 174.49,74.11 174.05,74.54 172.17,74.54 171.28,75.43 168.74,75.43 ; R440.2 58.64,4.69 v1(58,5.33) ; v1(166.19,123.57) 166.19,123.82 166.57,124.2 167.37,124.2 169.23,122.35 R179.2 169.08,120.88 169.08,119.43 ; R160.2 157.23,125.74 v1(157.42,125.74) ; v1(66,5.33) 66,5.2 66.38,4.82 R439.2 ; v1(106.26,141.73) 105.51,141.73 102.67,138.89 102.67,135.82 99.02,132.18 97.08,132.18 92.8,127.9 92.8,120.01 92.42,119.63 87.54,119.63 84.52,116.61 84.52,108.3 80.71,104.49 80.71,91.95 v1(82.31,90.34) 85.17,87.49 91.14,87.49 v1(94.77,91.12) ; R187.2 160.57,119.22 160.49,119.15 159.88,119.15 v1(159.83,119.2) ; v1(56.55,14.35) 54.69,14.35 C813.2 ; R169.2 156.86,123.96 156.6,124.21 R165.2 ; v1(207.35,23.69) 208.19,23.69 208.75,24.25 211.54,24.25 213.71,22.09 C811.2
  TOP w1.016: 188.48,108.71 190.08,108.71 192.01,106.78 193.18,106.78 194.98,104.97 194.98,102.23 ; 167.47,76.07 166.2,77.34 166.2,88.13 ; 177.76,75.74 181.55,75.74 182.49,76.68 192.34,76.68 193.13,75.89 193.13,68.47 193.66,67.94 v1(197.52,67.94) v1(201.28,67.94) 202.15,67.94 v1(202.53,67.56) ; 210.72,66.04 210.72,65.52 212.69,63.55 v1(212.69,61.46) 218.58,61.46 221.75,58.29 v1(224.85,58.29) v1(226.02,58.29)
  IN1 w0.508: v1(207.35,23.69) v1(206.62,23.69) ; v1(66,5.33) 65.37,4.69 58.64,4.69 v1(58,5.33)
  IN1 w1.016: 64.76,29.49 67.65,32.38 73.55,32.38 76.42,29.51 76.42,27.81 v1(76.75,27.48) 77.61,27.48 81.27,31.14 88.53,31.14 90.82,33.42 165.24,33.42 170.9,27.76 170.9,26.17 172.44,24.63 188.66,24.63 193.87,19.43 206.62,19.43 208.27,21.08 208.27,22.09 207.85,22.51 ; 197.42,93.42 198.11,94.1 198.11,96.97 195.03,100.05 195.03,100.66
  IN2 w0.508: v1(64.48,27.53) 63.56,26.62 63.56,18.94 58.97,14.35 v1(56.55,14.35) v1(56.55,10.04) 56.55,8.73 58.97,6.32 65.01,6.32 v1(66,5.33) ; v1(169.25,106.17) 169.51,105.91 169.51,103.6 169.91,103.2 169.91,100.17 170.27,99.81 170.27,98.68 v1(170.08,98.48) ; v1(202.73,52.07) 203.75,51.05 204.54,51.05 205,51.51 206.64,51.51 209.66,54.53 209.66,58.7 212.43,61.46 v1(212.69,61.46) ; v1(82.16,23.82) 80.4,23.82 v1(76.75,27.48)
  IN2 w1.016: 207.1,24.81 207.1,25.37 207.71,25.98 207.71,27.2 207.05,27.86 207.05,32.63 208.11,33.7 208.11,34.67 208.75,35.3 210.25,35.3 210.99,36.04 v1(212.76,36.04) 216.05,32.75 216.05,32.73 218.15,30.63 223.15,30.63 225.39,32.86 225.39,52.75 226.02,53.39 v1(226.02,58.29) v1(224.85,58.29) ; v1(82.31,90.34) 82.31,91.43 79.84,93.9 60.24,93.9 58.89,92.55 v1(58.89,91.82) 58.89,90.8 v1(57.87,89.78) 56.1,91.56 55.35,91.56 54.83,91.04 v1(54.83,89.78) 51.22,86.18 51.22,82.65 ; v1(201.28,67.94) 202.15,67.94 v1(202.53,67.56) 203.67,66.42 207.94,66.42 208.51,66.99 209.33,66.99
  BOTTOM w0.381: v1(155.03,103.5) 155.03,103 R651.1
  BOTTOM w0.508: v1(168.29,75.18) 168.34,75.23 v1(168.34,75.89) 168.34,76.04 168.62,76.32 171.51,76.32 172.92,74.91 174.45,74.91 v1(175.73,76.2) ; R733.2 R734.2 202.29,52.2 202.43,52.07 v1(202.73,52.07) ; v1(82.16,23.82) 82.26,23.72 83.88,23.72 84.06,23.54 84.06,23.49 84.07,23.49 84.07,23.16 84.07,23.16 PR333.2 ; R725.2 210.68,59.71 212.43,61.46 v1(212.69,61.46) ; v1(106.26,141.73) 105,141.73 PR244.2 ; R586.1 160.25,120.13 160.62,120.49 160.98,120.49 R585.1 161.01,120.52 164.12,120.52 164.13,120.51 v1(164.25,120.51) ; R697.2 v1(58.89,91.82) ; PR292.2 56.94,78.7 56.94,78.27 v1(56.18,77.51) ; R705.2 v1(54.83,89.78) ; R543.2 156.17,142.12 157.88,140.41 158.79,140.41 159.23,139.97 R541.2 159.47,138.94 R540.2 R542.2 v1(158.46,138.17) ; v1(94.77,91.12) 96.86,93.21 96.86,95.88 98.01,97.03 R682.1 ; PQ37.1 73.42,25.45 69.88,25.45 PR338.1 ; v1(170.29,109.52) 169.89,109.11 169.89,107.12 R628.1 169.64,106.56 v1(169.25,106.17) ; R708.2 v1(57.87,89.78) ; v1(161.18,77.11) v1(161.18,78.3)
  BOTTOM w1.016: 197.04,90.37 197.04,84.35 197.07,84.32 ; v1(197.52,67.94) 196.2,69.26 196.2,73.4 196.48,73.68 196.48,81.58 197.04,82.14 197.04,83.41 197.07,83.43
  vias: v1(44.74,96.72) v1(44.74,95.96) v1(45.45,96.72) v1(45.48,95.96) v1(46.19,96.67) v1(46.19,95.96) v1(51.22,81.5) v1(51.75,80.77) v1(64.22,28.32) v1(64.86,28.32) v1(65.14,27.53) v1(65.62,28.32) v1(66.03,27.5) v1(167.14,89.94) v1(167.6,90.42) v1(168.41,116.66) v1(169.05,116.63) v1(169.96,110.1) v1(176.24,75.69) v1(178.22,111.07) v1(181.95,113.86) v1(182.41,113.41) v1(187.79,109.72) v1(187.87,109.09) v1(194.93,102.18) v1(194.96,101.47) v1(195.59,84.36) v1(197.04,92.15) v1(197.04,91.41) v1(210.71,67.59) v1(210.71,66.72)
+3V_WLAN: length 35.4
  TOP w0.508: v1(181.44,93.47) 180.94,93.47 179.36,95.04 179.36,99.61 178.39,100.58 178.39,101.99 178.24,102.14 178.24,102.98 180.03,104.77 181.06,104.77 181.7,105.41 Q22.3 183.02,105.79 183.66,106.43 R221.1
  BOTTOM w0.508: v1(181.44,93.47) 181.7,93.47 182.08,93.09 182.08,91.82 182.84,91.05 182.84,87.63 182.47,87.26 181.53,87.26 v3(181.47,87.32) 180.63,88.16 179.36,88.16 177.41,90.11 174.72,90.11 Q38.3
+3VPCU: length 720.1
  TOP w0.254: R53.1 R52.2 110.95,179.96 v1(110.93,179.98)
  TOP w0.305: RP1.10 195.47,26.69 v1(194.7,27.45) ; v1(198.62,28.04) 198.62,27.83 198.11,27.33 RP1.2
  TOP w0.508: v1(63.59,10.28) 63.84,10.03 R434.2 ; R368.2 205.32,41.55 204.64,42.24 v1(204.64,42.39) ; v1(204.1,93.57) 204.73,94.2 209.92,94.2 213.32,90.8 217.26,90.8 220.31,93.85 221.86,93.85 222.42,93.29 v1(223.46,93.29) 223.46,92.17 222.97,91.69 220.05,91.69 219.29,90.93 219.29,80.64 v1(215.23,76.58) ; v1(65.49,6.85) 65.61,6.85 R437.2 ; v1(64.99,9.52) R435.2 ; R304.2 81.55,71.11 83.65,69 83.65,65.78 83.27,65.4 83.27,61.97 80.73,59.43 75.15,59.43 74.79,59.79 69.43,59.79 69.1,59.46 v1(69.05,59.46) ; R436.2 v1(57.49,8.76) C555.1 ; v1(163.28,194.94) PR9.2 ; R427.2 60.42,11.93 60.92,11.93 61.18,11.68 v1(61.18,10.66) ; R278.2 171.18,81.38 170.52,82.04 R271.2 170.33,82.51 v1(169.1,82.51) ; 47.97,91.05 48.74,90.28 C369.2 R260.1 49.34,87.15 49.34,84.48 49.7,84.11 49.7,81.83 v1(47.03,79.16) ; v1(178.09,110.08) 177.33,110.08 177.1,110.31 174.61,110.31 174.26,110.66 R210.2 ; v1(57.37,6.73) 58,6.73 58.88,5.85 R438.2 ; PR125.1 197.02,99.61 v1(197.62,99.01) ; R428.2 R429.2 69.32,11.94 v1(69.51,11.76) ; v1(199.1,42.39) 199.1,42.13 199.33,41.91 D12.1 ; v1(25.13,31.36) R388.1 ; v1(205.7,192.78) 206.84,192.78 207.23,193.17 PR14.2 207.75,193.03 207.75,192.64 208.11,192.27 v1(208.42,192.27) 209.06,192.27 209.44,191.89 210.15,191.89 210.54,192.28 PR16.2 ; v1(183.48,101.47) 182.97,100.96 R231.1 C345.2 182.47,102.52 182.71,102.76 182.71,103.75
  IN1 w0.254: v1(110.93,179.98) 110.93,181.33 111.87,182.27 111.87,182.86 112.27,183.26 114.99,183.26 119.09,187.35 121.2,187.35 133.23,199.39 136.54,199.39 137.66,200.5 146.04,200.5 146.55,201.01 155.51,201.01 160.39,196.13 162.09,196.13 v1(163.28,194.94)
  IN1 w0.508: v1(204.1,93.57) 203.92,93.75 203.92,94.48 200.37,98.04 198.6,98.04 v1(197.62,99.01) ; v1(221.4,149.2) 221.25,149.2 218.07,146.02 218.07,129.64 219.6,128.11 219.6,116.66 220.08,116.18 220.08,110.61 221.07,109.62 221.07,101.04 221.86,100.25 221.86,94.89 v1(223.46,93.29) ; v4(87.97,42.92) 87.46,42.92 83.71,46.68 82.03,46.68 74.41,54.3 71.62,54.3 71.16,54.76 71.16,55.06 68.9,57.32 68.9,59.3 v1(69.05,59.46) 66.73,61.78 65,61.78 60.34,66.44 60.34,71.24 58.25,73.33 v1(58.25,75.31) ; v1(80.95,41.16) 78.88,43.24 78.88,48.89 74.1,53.67 71.35,53.67 70.52,54.5 70.52,54.8 66.68,58.64 v1(66.68,59.56) ; v1(178.09,110.08) 178.27,110.08 179.41,108.94 179.41,108.05 183.48,103.99 v1(183.48,101.47) ; v1(176.24,79.24) 176.16,79.17 173.47,79.17 170.14,82.5 169.12,82.5 v1(169.1,82.51) ; v1(163.28,194.94) 163.28,195.2 164.1,196.03 164.88,196.03 166.28,197.43 177.97,197.43 179.24,198.7 181.9,198.7 182.82,199.61 192.32,199.61 193.52,198.42 197.27,198.42 198.03,197.66 198.03,196.57 198.32,196.27 199.5,196.27 201.82,193.96 201.82,192.65 202.19,192.27 205.19,192.27 v1(205.7,192.78) ; v1(189.24,101.34) 188.89,100.99 188.89,93.09 190.18,91.79 v1(190.18,89.05)
  IN2 w0.508: v1(76.34,26.16) 77.84,24.66 77.84,19.6 v1(78.5,18.94) ; v1(199.1,42.39) 198.11,42.39 196.41,40.69 194.5,40.69 192.14,38.32 192.14,32.1 188.66,28.62 188.66,27.48 ; v1(78.5,18.94) 80.35,20.8 81.8,20.8 86.75,25.75 v1(87.08,25.75) ; v1(78.5,18.94) 78.5,17.47 77.18,16.15 73.9,16.15 v1(69.51,11.76) ; v1(47.03,79.16) 48.22,77.97 48.45,77.97 50.95,75.47 58.09,75.47 v1(58.25,75.31) ; v1(186.4,53.97) 187.97,55.55 187.97,63.45 185.18,66.24 185.18,71.83 182.08,74.93 178.41,74.93 176.17,77.16 176.17,79.18 v1(176.24,79.24) 177.25,80.26 178.01,80.26 180.58,82.83 180.58,84.59 182.78,86.79 v1(183.48,86.79) ; 188.66,27.48 188.1,27.48 187.13,28.44 178.9,28.44 v1(178.78,28.57) ; 188.66,27.48 191.81,27.48 192.67,26.62 193.94,26.62 ; v1(25.13,31.36) 25.13,34.46 25.87,35.2 25.87,37.84 26.53,38.5 30.61,38.5 30.84,38.73 31.33,38.73 32.35,39.75 32.35,40.25 35.41,43.3 37.93,43.3 39.36,44.73 47.33,44.73 58,34.06 66.46,34.06 68.41,36.01
  BOTTOM w0.203: v1(66.68,59.56) 66.68,59.21 PR6279.1
  BOTTOM w0.508: PR6284.1 70.79,55.2 70.6,55.39 70.6,56.13 70.29,56.43 70.29,57.17 70.6,57.48 70.6,58.31 69.46,59.46 v1(69.05,59.46) ; v1(189.98,48.97) 190.31,48.64 192.24,48.64 ; v1(204.64,42.39) 203.26,42.39 202.9,42.02 199.47,42.02 v1(199.1,42.39) ; R695.1 223.1,91.82 223.46,92.17 v1(223.46,93.29) ; v1(76.34,26.16) 76.34,26.72 75.53,27.53 PQ37.3 ; 192.24,48.64 192.69,48.64 193.46,49.41 R741.2 ; 192.24,48.64 192.11,48.76 192.11,50.77 193.3,51.96 196.32,51.96 196.57,52.2 R730.2 R731.2 R732.2 ; v1(208.42,192.27) 209,192.27 209.38,191.89 210.15,191.89 210.54,192.28 ; v1(215.23,76.58) R757.2 ; R753.2 193.65,24.02 v1(193.63,24.04) ; v1(221.4,149.2) 221.4,149.3 221.7,149.6 221.7,167.2 220.59,168.32 220.59,174.29 218.1,176.78 216.93,176.78 211.67,182.04 211.67,185.16 210.22,186.61 210.22,191.16 210.54,191.47 210.54,192.28 ; v1(190.18,89.05) 187.92,86.79 v1(183.48,86.79) 183.86,87.17 183.86,92.32 185.89,94.36 185.89,98.55 185.25,99.18 184.75,99.18 184.37,99.56 184.37,100.58 v1(183.48,101.47) ; 210.54,192.28 PR16.2 ; v1(197.62,99.01) 192.99,99.01 190.67,101.34 v1(189.24,101.34) ; R747.1 188.81,45.76 v1(189.66,46.6)
  vias: v1(94.7,36.06) v1(94.7,35.43) v1(95.34,36.06) v1(95.34,35.43) v1(186.4,53.34) v1(186.4,52.7) v1(186.4,52.07) v3(59.27,11.43) v3(85.66,36.93) v3(190.13,56.59) v4(88.61,37.26) v4(88.61,36.24) v4(88.76,42.92) v4(89.01,37.94) v4(89.42,37.26) v4(89.45,36.24) v4(89.6,42.92)
+3VPCU_EC: length 109.8
  TOP w0.762: v1(195.03,39.92) 194.53,39.92 194.2,40.25 192.27,40.25 189.67,42.85 188.91,42.85 188.18,42.11 v4(187.85,42.11) ; v4(192.42,47.76) 193.88,47.76 194.41,47.23 197.86,47.23 198.58,47.95 198.58,48.5 199.12,49.04 v1(199.73,49.04) 203.34,49.04 v1(203.47,49.17) v3(206.74,49.17) v1(207.73,50.16)
  IN2 w0.762: v1(195.03,39.92) 196.13,39.92 197.22,38.83 197.22,37.41 198.02,36.61 198.3,36.61 v1(198.46,36.44) 198.72,36.44 200.49,34.67 200.49,32.95 199.91,32.37 199.91,27.94 199.63,27.66 199.63,26.74 v1(199.48,26.59) 199.34,26.59 198.59,25.84 198.59,23.22 198.06,22.68 198.06,20.6 200.93,17.73 202.58,17.73 202.65,17.65 205.8,17.65 209.26,21.1 209.26,27.1 208.06,28.29 208.06,32.1 209.23,33.27 v1(209.23,34.18) ; v4(187.85,42.11) 187.85,43.15 190.16,45.46 191.6,45.46 192.07,45.92 192.07,47.4 v4(192.42,47.76)
  BOTTOM w0.203: U45.121 203.51,46.45 204.05,46.99 C771.1 ; U45.106 197.51,47.81 197.19,48.13 C769.1 ; U45.26 208.76,33.91 209.03,34.18 v1(209.23,34.18) ; U45.114 200.71,48.66 C770.1 ; U45.92 191.22,42.31 191.06,42.48 ; U45.50 199.51,28.15 C780.1
  BOTTOM w0.254: C777.1 190.08,43.46 191.06,42.48
  BOTTOM w0.508: C771.1 203.88,48.76 v1(203.47,49.17) ; v1(197.83,49.02) 197.71,49.02 197.45,48.76 C769.1 ; v1(199.48,26.59) 199.48,27.39 C780.1 ; R747.2 189.42,43.96 C777.1 ; C770.1 200.02,48.76 v1(199.73,49.04)
  BOTTOM w0.762: R747.2 188.33,43.96 187.85,43.48 v4(187.85,42.11)
+3VPCU_ECPLL: length 1.1
  BOTTOM w0.203: 205.96,46.6 205.91,46.56 U45.127
  vias: v3(206.62,47.44)
+5V: length 410.5
  TOP w0.508: v1(73.62,22.8) 72.67,22.8 72.22,22.36 C810.1 ; v1(19.9,74.93) Q26.3 ; 49.49,54.1 49.49,64 50.88,65.39 PR153.1 ; R343.2 29.4,48.15 v1(29.4,48.89) ; C809.1 v1(224.24,27.3) ; 21.81,115.69 23.01,116.9 23.14,116.9 v1(23.58,117.34) ; U12.2 54.85,108.96 C321.2 v1(54.98,109.85) ; v1(163.49,80.16) 161.75,80.16 159.48,82.38 CN3.1
  IN1 w0.508: v1(19.9,74.93) 19.9,74.8 20.79,73.91 27.14,73.91 27.27,73.78 27.27,71.62 28.66,70.23 28.66,49.63 v1(29.4,48.89) 32.52,48.89 v1(34.2,50.57) ; v1(163.49,80.16) 164.99,78.66 164.99,75 168.49,71.5 168.49,49.32 166.33,47.16 v1(166.33,46.1)
  IN1 w1.016: 219.04,97.28 218.71,97.61 218.71,108.12 216.01,110.82 216.01,120.53 217.39,121.9 217.39,127.38 215.89,128.88 215.89,131.62 ; 147.94,194.56 150.84,194.56 152.74,192.65 156.25,192.65 157.49,191.41 159.25,191.41 160.49,192.65 165.06,192.65 166.46,194.05 178.9,194.05 180.25,195.4 184.19,195.4 185.76,196.97 188.56,196.97 190.97,194.56 195.85,194.56 196.48,193.92 198.64,193.92 199.38,193.19 199.38,192.27 199.45,192.2 ; 210.02,189.48 210.53,188.97 210.53,187.32 214.97,182.88 214.97,182.49 221.04,176.42 221.04,171.6 222.21,170.43 222.21,165.67 223.68,164.21 223.68,151.8 223.1,151.23 220.4,151.23 215.99,146.81 215.99,132.84
  IN2 w0.508: v1(164.55,25.22) 167.91,28.57 v1(173.65,28.57) ; v1(54.98,109.85) 53.84,108.71 50.64,108.71 48.86,110.49 43.52,110.49 43.27,110.74 39.45,110.74 38.69,109.98 36.66,109.98 33.36,113.28 29.86,113.28 26.18,116.96 23.96,116.96 v1(23.58,117.34) ; v1(14.44,111.86) 14.44,107.18 13.8,106.55 13.8,105.07 18.42,100.45 25.36,100.45 27.14,98.67 27.14,96.77 29.81,94.1 29.81,89.02 29.32,88.54 29.32,82.05 23.95,76.68 21.27,76.68 19.9,75.31 v1(19.9,74.93)
  BOTTOM w0.305: C720.2 14.23,110.02 U40.5 ; C713.2 16.87,113.78 U37.5
  BOTTOM w0.508: v1(166.33,46.1) 166.37,46.1 168.09,44.37 168.09,33.88 172.01,29.96 173.4,28.57 v1(173.65,28.57) ; v1(17.74,113.79) C713.2 ; D31.2 D30.2 15.79,69.54 19.39,73.15 19.39,74.42 v1(19.9,74.93) ; v1(14.44,111.86) 14.44,111.17 v3(14.36,111.1) 14.09,110.83 C720.2
  vias: v1(53.48,50.75) v1(53.48,50.11) v1(53.48,49.48) v1(136.36,188.34) v1(136.99,188.34) v1(147.49,195.8) v1(148.12,195.8) v1(214.21,132.43) v1(214.21,131.77) v1(215.1,73.15) v1(215.1,72.51) v1(215.1,71.88) v1(215.1,71.24) v1(218.15,96.13) v1(218.78,96.13) v1(219.42,96.13) v1(220.05,96.13) v1(221.07,49.53) v1(221.07,48.89) v1(221.7,49.53) v1(221.7,48.89) v4(82.59,28.29) v4(82.84,29.04) v4(83.4,28.29) v4(83.65,29.04) v4(84.49,29.05)
+5V_HDD:
  vias: v3(226.91,54.61)
+5V_KB:
  vias: v3(211.82,135.78)
+5V_KB_R:
  vias: v1(211.19,139.39) v1(211.19,138.76) v1(211.73,139.07)
+5V_ODD:
  vias: v3(221.6,101.09)
+5V_PVDD: length 5.3
  IN2 w0.508: v1(36.84,33.24) 36.84,33.65 36.06,34.44 36.06,35.84 36.79,36.57 37.81,36.57 v1(38.06,36.32)
  vias: v3(43.17,35.76)
+5V_S5: length 378.2
  TOP w0.508: 80.68,35.23 82.54,35.23 84.01,33.75 84.01,31.24 81.55,28.77 81.55,27.73 78.6,24.79 66.03,24.79 61.56,29.26 60.11,29.26 59.6,28.75 v1(59.6,26.72) ; PR56.1 153.42,165.95 v1(153.12,166.24) 151.73,167.64 148.44,167.64 146.54,169.54 143.47,169.54 142.96,169.03 PR55.1 142.35,167.61 141.69,168.27 141.69,168.52 140.42,169.79 131.66,169.79 131.28,169.41 ; PR54.1 131.28,169.01 131.28,169.41 ; 131.28,169.41 131.01,169.68 123.29,169.68 122.77,169.16 PR53.1 ; PR99.1 208.11,107.18 v1(208.37,107.44) 212.94,112.01 212.94,115.95 214.97,117.98 214.97,121.92 218.17,125.12 218.17,133.88 217.84,134.21 217.84,146.12 220.28,148.56 222.06,148.56 224.85,151.35 224.85,179.98 219.67,185.16 212.18,185.16 211.29,186.05 208.7,186.05 207.42,187.33 207.42,188.08 206.59,188.91 205.2,188.91 203.49,190.62 202.13,190.62 200.2,192.55 199.12,192.55 198.02,193.66 192.28,193.66 191.58,192.96 190.28,192.96 189.44,193.8 185.24,193.8 184.85,193.42 182.76,193.42 182.15,194.03 181.65,194.03 181.19,193.57 178.93,193.57 178.63,193.26 175.27,193.26 174.66,193.87 167.81,193.87 165.82,191.89 164.68,191.89 v1(164.17,191.38)
  IN1 w0.508: v1(153.12,166.24) 153.5,166.62 153.5,168.15 154.01,168.66 154.01,171.88 151.52,174.37 v1(148.68,174.37)
  IN1 w1.016: v1(222.34,102.48) 223.43,101.39 223.43,95.07 224.61,93.89 224.61,92.72 223.48,91.59 219.7,91.59 215.86,87.75 215.86,80.67 212.12,76.92 212.12,72.12 215.48,68.75 215.48,67.43 218.05,64.87 218.05,61.84 219.68,60.21 219.68,55.79 215.99,52.1 215.99,50.21 214.44,48.66 214.44,46.86 214.08,46.5 214.08,43.38 214.85,42.62 214.85,39.39 210.48,35.02 210.48,34.16 210.07,33.75 210.07,31.85
  IN2 w0.508: v1(164.17,191.38) 162.9,190.11 162.9,185.62 157.11,179.83 155.66,179.83 154.71,178.88 v1(153.19,178.88)
  BOTTOM w0.508: PR204.1 153.89,181.96 153.57,181.65 153.57,179.8 153.24,179.46 153.24,178.93 v1(153.19,178.88) 152.87,178.56 150.84,178.56 150.57,178.82 149.96,178.82 149.19,178.05 149.19,174.87 v1(148.68,174.37) ; v1(59.6,26.72) 59.6,27.02 58.85,27.78 PR339.1 ; v1(208.37,107.44) 208.38,107.43 208.63,107.43 209.4,106.66 209.4,104.76 210.6,103.55 219.62,103.55 220.69,102.48 v1(222.34,102.48)
  vias: v1(34.51,58.03) v1(35.14,58.03) v1(35.78,58.03) v1(36.41,58.03) v1(71.22,57.78) v1(71.54,58.42) v1(71.86,57.78) v1(72.17,58.42) v1(72.49,57.78) v1(209.51,30.35) v1(209.49,29.71) v1(210.15,30.35) v1(210.15,29.71) v1(210.78,30.35) v1(210.78,29.71) v3(40.55,63.85) v4(78.07,35.23) v4(78.83,35.23) v4(79.59,35.99) v4(79.59,35.23) v4(80.35,35.99) v4(81.11,35.99)
+5VA: length 1.1
  TOP w0.508: v1(40.73,29.08) 40.86,28.95 R395.1
  vias: v1(29.38,29.84) v1(30.04,29.82) v1(43.27,31.24) v1(43.27,30.6) v3(28.56,29.59)
+5VODD:
  vias: v3(229.02,101.16)
+5VPCU: length 324.4
  TOP w0.203: v1(57.24,36.96) 54.72,39.48 54.72,46.88 55.69,47.85 55.69,52.85 54.72,53.82 54.72,55.55 56.5,57.32 v1(63.54,57.32)
  TOP w0.508: v1(33.11,103.17) 44.63,114.69 70.38,114.69 71.26,115.57 79.64,115.57 v1(80.15,115.06) ; R356.1 R360.1 ; v1(87.82,32.62) PR6290.2
  TOP w0.559: v4(65.23,51.5) 65.22,51.5 65.22,52.27 PD6004.2
  IN1 w0.508: v1(97.12,46.86) 98.77,46.86 103.19,42.44 159.3,42.44 159.93,41.8 173.93,41.8 174.28,42.16 176.42,42.16 177.85,43.6 185.47,43.6 188.3,46.43 188.3,48.13 187.1,49.34 187.1,54.24 183.91,57.43 183.91,58.47 183.48,58.9 v1(183.48,62.73) ; v4(82.89,33.55) 84.65,35.3 v1(93.41,35.3) ; v1(25.62,57.15) 25.62,51.05 24.47,49.91 22.8,49.91 21.91,49.02 21.91,44.67 21.53,44.29 21.53,42.62 22.31,41.83
  IN1 w0.559: v4(65.23,51.5) 65.21,51.48 65.21,50.8 67.07,48.94 67.07,36.97 v1(67.06,36.96)
  IN2 w0.508: v1(25.62,57.15) 25.62,57.65 29.43,61.47 29.43,73.15 38.54,82.27 38.54,88.29 37.05,89.78 33.53,89.78 32.89,90.42 32.47,90.42 31.84,91.05 31.84,93.85 32.98,94.99 32.98,103.04 v1(33.11,103.17)
  BOTTOM w0.203: v1(63.54,57.32) 63.73,57.51 PR6281.2 ; PU15.12 179.74,65.7 180.26,65.17 180.4,65.17
  BOTTOM w0.508: v1(183.48,62.73) 182.17,64.04 PC242.2 180.71,64.87 180.4,65.17 ; v1(93.41,35.3) 93.41,35.86 95.14,37.59 95.14,44.88 v1(97.12,46.86) ; v1(80.15,115.06) 79.76,114.67 PC194.2
  vias: v1(23.08,40.13) v1(23.08,39.49) v1(23.71,40.08) v1(23.96,39.49) v1(24.35,40) v1(28.03,44.83) v1(28.05,44.17) v1(28.56,45.36) v1(28.66,44.42) v1(29.07,44.95) v1(48.32,46.3) v1(48.32,45.64) v1(48.32,44.98) v1(48.96,46.48) v1(48.96,45.82) v3(37.25,46.53) v3(67.22,32.38) v4(81.78,32.76) v4(82.13,33.55) v4(82.54,32.76) v4(83.3,32.76)
+15V: length 391.1
  TOP w0.508: PR148.1 47.46,64.38 v1(48.48,63.37) ; v1(37.02,48.18) 36.84,48 R345.1 ; PR161.1 78.47,15.62 80.89,18.03 v1(80.89,18.92) 80.89,19.96 84.42,23.49 87.37,23.49 92.01,28.13 92.01,41.55 87.85,45.72 87.85,45.72 83.35,50.22 83.35,52.09 79.13,56.31 77.28,56.31 74.49,59.1 69.63,59.1 69.33,58.8 68.75,58.8 67.35,60.19 54.83,60.19 v4(52.16,62.86) ; v1(216.88,51.73) 216.88,51.75 212.47,56.16 212.47,59.76 208.85,63.38 208.85,63.97 205.45,67.37 204.61,68.21 204.61,75.76 204.33,76.04 PR143.1 203.54,77.08 204.05,77.59 206.34,77.59 208.55,79.8 208.55,86.46 209.26,87.17 v1(209.26,88.01)
  IN1 w0.508: v1(80.89,18.92) 81.29,19.33 83.83,19.33 90.03,25.52 99.96,25.52 101.33,24.15 122.82,24.15 130.41,16.57 166.78,16.57 174.02,9.34 192.69,9.34 194.27,10.92 194.27,13.2 195.15,14.08 208.24,14.08 213.45,19.29 213.45,24 212.19,25.26 212.19,29.85 215.86,33.52 215.86,43.79 215.66,43.99 215.66,48.48 216.88,49.7 v1(216.88,51.73) ; v1(37.02,48.18) 38.75,49.91 43.01,49.91 44.16,48.76 v1(48.86,48.76) 48.86,59.56 v4(52.16,62.86)
  BOTTOM w0.508: v1(209.26,88.01) 210.07,88.01 213.7,91.64 213.7,94.61 214.59,95.5 R686.2 ; PR334.1 51.22,37.92 51.22,46.4 v1(48.86,48.76) ; v1(48.48,63.37) 48.73,63.62 v4(52.16,63.62) ; PR6275.1 61.32,62.24 59.11,62.24 58.33,61.46 53.56,61.46 v3(52.87,62.15) v4(52.16,62.86)
+15V_ALWP: length 5.2
  BOTTOM w0.508: PC6209.2 v1(59.13,61.29) 60.48,61.29 PR6275.2 61.67,60.1 PD6008.1
+A3VPCU: length 2.4
  BOTTOM w0.203: U45.74 193.21,35.11 193.27,35.06 193.84,35.06 194.32,35.54 v1(194.32,35.61)
  vias: v3(194.63,36.52)
+VCCATS_1P8: length 7.6
  TOP w0.381: v1(159.19,119.17) 159.19,119.75 C250.1 159.51,120.06 159.98,120.06 v1(160.24,119.81) 160.49,120.06 161.76,120.06 R180.1
  BOTTOM w0.203: v1(159.19,119.17) 159.19,119.55 158.46,120.29 156.63,120.29 U35.AA1
+VCCCORE: length 79.8
  TOP w0.254: v1(140.93,182.75) 140.3,183.38 PR31.2
  IN2 w0.254: v1(140.93,182.75) 140.93,182.24 138.2,179.51 138.2,177.52 139.31,176.42 139.89,176.42 149.34,166.97 149.34,166.11 152.23,163.22 152.23,154.05 147.92,149.73 v4(147.31,149.73)
  BOTTOM w0.127: 132.2,126.31 U35.K43 ; U35.K43 132.2,125.67 ; U35.K43 132.52,125.99 ; U35.K38 135.26,125.99 ; U35.K38 134.55,125.99 ; U35.K38 134.95,126.31 ; U35.K38 134.95,125.67 ; 137.69,126.31 U35.K33 137.37,125.99 ; 139.06,126.77 U35.J30 ; U35.J30 138.74,126.46 ; U35.J30 139.38,126.46 ; U35.J30 139.06,126.14 ; U35.G35 136.78,127.24 ; U35.G35 136.78,126.6 ; U35.G35 137.09,126.92 ; U35.J40 133.26,126.46 ; U35.J40 133.58,126.77 ; U35.J40 133.89,126.46 ; U35.J40 133.58,126.14 ; 135.47,125.99 U35.K37 ; U35.K37 135.86,125.67 ; U35.K37 135.86,126.31 ; U35.K37 136.18,125.99 ; U35.AL33 137.83,115.16 ; U35.AL33 138.15,115.47 ; U35.AL33 138.46,115.16 ; U35.AL33 138.15,114.84 ; U35.K42 133.44,125.99 ; U35.K42 133.12,126.31 ; U35.K42 132.8,125.99 ; U35.K42 133.12,125.67 ; 135.54,114.69 135.86,114.69 ; 135.86,114.69 U35.AM37 135.86,114.37 ; 135.86,114.69 136.18,114.69 ; 135.86,114.69 135.86,115 ; 137.69,115.3 U35.AK33 ; U35.AK33 137.69,115.94 ; U35.AK33 138.01,115.62 ; 134.03,126.31 U35.K40 ; U35.K40 134.35,125.99 ; U35.K40 134.03,125.67 ; U35.K40 133.71,125.99 ; 139.52,126.6 U35.G30 139.2,126.92 ; 138.29,114.69 138.6,114.69 ; 138.6,114.69 U35.AM32 138.6,114.37 ; 138.6,114.69 138.6,115 ; 138.92,126.92 U35.G32 138.6,126.6 ; U35.G40 134.03,126.6 ; U35.G42 133.12,126.6 ; U35.AL37 136.32,114.84 ; U35.AL37 136.64,115.16 ; U35.AL37 136,115.16 ; U35.AL37 136.32,115.47 ; 134.03,115.94 U35.AK40 ; U35.AK40 134.03,115.3 ; U35.AK40 134.35,115.62 ; 134.95,114.37 U35.AM38 134.95,114.69 ; 134.95,114.69 135.26,114.69 ; 134.95,114.69 134.95,115 ; 134.95,114.69 134.63,114.69 ; 134.63,115.6 134.95,115.6 ; 134.95,115.6 134.95,115.28 ; 134.95,115.6 U35.AK38 134.95,115.92 ; 136.78,114.69 136.78,115 ; 136.78,114.69 U35.AM35 136.78,114.37 ; 136.78,114.69 136.46,114.69 ; 136.78,114.69 137.09,114.69 ; 135.86,115.6 U35.AK37 135.86,115.92 ; 135.86,115.6 136.18,115.6 ; 135.86,115.6 135.86,115.28 ; 137.09,125.99 U35.K35 ; U35.K35 136.78,126.31 ; U35.K35 136.38,125.99 ; U35.K35 136.78,125.67 ; 137.37,126.92 U35.G33 137.69,126.6 ; 136.78,115.94 U35.AK35 ; U35.AK35 136.78,115.3 ; U35.AK35 136.46,115.62 ; U35.AL40 134.81,115.16 ; U35.AL40 134.49,115.47 ; U35.AL40 134.17,115.16 ; U35.AL40 134.49,114.84 ; 135.01,126.46 U35.J37 ; U35.J37 135.72,126.46 ; U35.J37 135.4,126.14 ; U35.J33 137.23,126.77 ; U35.J33 136.92,126.46 ; U35.J33 137.23,126.14 ; U35.J33 137.55,126.46 ; 137.37,114.69 137.69,114.69 ; 137.69,114.69 138.01,114.69 ; 137.69,114.69 U35.AM33 137.69,114.37 ; 137.69,114.69 137.69,115 ; U35.G37 135.86,126.6 ; U35.G38 134.95,126.6
  BOTTOM w0.203: U35.A44 131.66,132.2 v1(131.66,132.2)
  BOTTOM w0.508: C676.1 C675.1 v1(132.73,134.61)
  vias: v1(134.51,116.53) v1(134.49,115.88) v1(134.94,117.01) v1(135.22,117.9) v1(135.39,116.56) v1(135.7,121.46) v1(135.7,120.82) v1(135.7,120.14) v1(135.88,117.01) v1(136.06,117.9) v1(136.33,116.53) v1(136.32,115.88) v1(136.44,121.51) v1(136.44,120.87) v1(136.44,120.19) v1(136.56,131.19) v1(136.79,117.01) v1(137.22,116.53) v1(137.33,121.51) v1(137.33,120.87) v1(137.33,120.19) v1(138.06,131.82) v1(139.19,131.34) v2(129.12,123.24) v2(129.73,123.24) v2(130.34,123.24) v2(132.73,125.55) v2(133.57,125.55) v2(134.53,125.55) v2(135.37,125.55) v2(135.47,114.37) v2(136.23,125.55) v2(136.32,114.36) v2(137.25,114.37) v2(138.11,114.34) v3(139.18,138.53) v4(139.92,143.25) v4(139.92,142.36) v4(139.92,141.35) v4(139.97,140.46) v4(140.8,143.76) v4(140.8,142.87) v4(140.8,141.85) v4(140.8,140.97) v4(142.43,152.4) v4(143.29,152.4) v4(143.78,151.25) v4(143.83,149.73) v4(143.85,148.84) v4(144.11,152.01) v4(144.11,150.52) v4(144.67,151.25) v4(144.72,149.73) v4(145,152.01) v4(145,150.52) v4(145.12,152.8) v4(145.55,151.25) v4(145.61,149.73) v4(145.88,152.01) v4(145.88,150.52) v4(146.01,152.8) v4(146.44,151.25) v4(146.49,149.73) v4(146.77,152.01) v4(146.77,150.52) v4(147.03,152.78) v4(147.33,151.25) v4(147.66,152.01) v4(147.66,150.52)

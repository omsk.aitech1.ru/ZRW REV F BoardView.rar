# Allegro board Quanta ZRW REV F - BoardView (.BRD).brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
VMA_CLK1: length 87
  TOP w0.114: v1(186.66,180.25) 186.38,180.53 186.21,180.53 185.7,181.03 185.7,182.05 185.56,182.19 185.3,182.19 U3.J7 ; v1(180.5,179.71) 180.31,179.9 180.1,179.9 180,179.8 180,178 180.61,177.39 180.61,174.48 181.29,173.79 181.29,172.62 R68.1 ; U2.J7 173.14,181.96 173.32,182.14 173.44,182.14 173.63,181.95 173.63,181.47 173.99,181.11 174.46,181.11 174.48,181.09 174.49,181.09 174.66,180.92 174.66,180.87 v1(174.66,180.87)
  IN1 w0.127: v1(182.75,163.49) 183.01,163.49 183.12,163.6 183.12,163.8 182.59,164.33 182.59,166.06 183.06,166.53 183.06,167.06 182.9,167.22 181.79,167.22 181.29,167.72 180.85,167.72 180.09,166.97 180.09,166.77 180.26,166.61 180.26,165.87 180,165.61 179.27,165.61 178.98,165.33 178.82,165.17 178.39,165.17 177.98,165.57 177.55,165.57 176.38,164.4 175.03,164.4 173.87,165.56 170.75,165.56 168.74,167.56 168.74,168.13 169.06,168.44 169.56,168.44 171.32,166.69 176.74,166.69 177.57,167.52 178.14,167.52 178.51,167.15 178.69,167.15 178.98,167.45 178.98,167.66 178.41,168.23 178.41,172.37 178.98,172.94 178.98,173.81 179.57,174.41 179.57,175.72 180.49,176.64 180.49,176.94 181.46,177.91 181.46,178.56 181.76,178.86 182.16,178.86 182.28,178.99 182.28,179.88 182.16,180.01 180.8,180.01 v1(180.5,179.71) 180.28,179.93 179.76,179.93 177.34,182.34 176.14,182.34 175.52,181.73 175.52,181.51 175.14,181.12 174.92,181.12 v1(174.66,180.87)
  IN2 w0.127: v1(180.5,179.71) 180.72,179.93 181.34,179.93 182.52,181.12 185.56,181.12 186.05,180.62 186.13,180.55 186.21,180.46 186.44,180.46 186.66,180.25 v1(186.66,180.25)
  BOTTOM w0.114: v1(186.66,180.25) 186.85,180.44 187.13,180.44 187.38,180.68 187.38,181.26 187.84,181.73 187.84,182.08 187.95,182.19 188.1,182.19 188.21,182.08 U29.J7 ; v1(174.66,180.87) 174.88,181.09 174.9,181.09 175.08,181.09 175.44,181.44 175.44,181.72 175.91,182.19 176.05,182.19 U28.J7 ; v1(182.75,163.49) 182.75,163.64 183,163.88 U34.N22
VMA_CLK1#: length 87.5
  TOP w0.114: v1(180.53,180.4) 180.24,180.11 180.01,180.11 179.79,179.89 179.79,177.91 180.4,177.31 180.4,174.39 181.09,173.71 181.09,172.62 R68.2 ; U2.K7 173.14,182.52 173.3,182.36 173.53,182.36 173.84,182.04 173.84,181.99 173.84,181.56 174.08,181.33 174.48,181.33 v1(174.65,181.5) ; U3.K7 185.01,182.66 185.27,182.41 185.65,182.41 185.92,182.14 185.92,181.12 186.3,180.74 186.57,180.74 v1(186.7,180.88)
  IN1 w0.127: v1(183.56,163.49) 183.35,163.7 183.35,163.9 182.82,164.43 182.82,165.96 183.29,166.43 183.29,167.15 183,167.45 181.89,167.45 181.38,167.95 180.75,167.95 179.87,167.07 179.87,166.67 180.03,166.51 180.03,165.96 179.9,165.84 179.17,165.84 178.76,165.42 178.73,165.4 178.49,165.4 178.08,165.8 177.46,165.8 176.28,164.63 175.12,164.63 173.96,165.79 170.84,165.79 168.97,167.66 168.97,168.04 169.15,168.22 169.47,168.22 171.22,166.46 176.84,166.46 177.67,167.29 178.05,167.29 178.42,166.93 178.79,166.93 179.21,167.35 179.21,167.75 178.64,168.32 178.64,172.28 179.21,172.84 179.21,173.72 179.8,174.31 179.8,175.63 180.72,176.54 180.72,176.84 181.69,177.81 181.69,178.47 181.85,178.63 182.25,178.63 182.51,178.89 182.51,179.97 182.25,180.23 180.69,180.23 v1(180.53,180.4) 180.29,180.16 179.85,180.16 177.44,182.57 176.04,182.57 175.29,181.82 175.29,181.6 175.04,181.35 174.8,181.35 v1(174.65,181.5)
  IN2 w0.127: v1(186.7,180.88) 186.52,180.69 186.31,180.69 185.65,181.35 182.43,181.35 181.24,180.16 180.76,180.16 v1(180.53,180.4)
  BOTTOM w0.114: v1(186.7,180.88) 186.7,180.79 186.84,180.65 187.04,180.65 187.16,180.77 187.16,181.35 187.62,181.82 187.62,182.17 187.86,182.41 188.09,182.41 188.21,182.53 U29.K7 ; U34.M22 183.96,163.88 v1(183.56,163.49) ; U28.K7 176.34,182.67 176.07,182.41 175.82,182.41 175.22,181.81 175.22,181.53 174.99,181.3 174.85,181.3 v1(174.65,181.5)
VMA_DM0: length 23.2
  TOP w0.102: v1(203.52,163.48) 203.24,163.2 202.58,163.2 202.07,163.71 U4.E7
  IN2 w0.102: v1(203.52,163.48) 203.31,163.28 203.31,161.77 ; v1(191.02,160.96) 191.52,160.96 191.67,160.8 192.05,160.8 192.2,160.96 192.93,160.96 193.57,161.6 194.65,161.6
  IN2 w0.165: 194.65,161.6 196.84,161.6 197.92,160.52 198.9,160.52 199.07,160.35 199.07,159.9 199.24,159.74 199.56,159.74 199.72,159.9 199.72,159.92 199.89,160.09 200.05,160.09 200.22,159.92 200.22,159.85 200.38,159.69 201.12,159.69 201.29,159.85 201.29,160.05 201.45,160.22 201.92,160.22 202.24,160.54 202.31,160.54 202.32,160.55 202.63,160.55 203.06,160.12 203.42,160.12 203.59,160.29 203.59,160.87 203.43,161.03 203.2,161.03 203.03,161.2 203.03,161.49 203.31,161.77
  BOTTOM w0.102: v1(203.52,163.48) 204.93,163.48 U31.E7 ; v1(191.02,160.96) 190.63,161.34 U34.D19
VMA_DM1: length 41.1
  TOP w0.102: U5.E7 214.23,163.53 v1(215.53,163.53)
  IN2 w0.102: 215.03,160.13 215.03,160.55 214.92,160.66 214.92,163.01 215.44,163.53 v1(215.53,163.53) ; 194.2,156.46 193.89,156.76 193.89,156.89 192.73,158.05 191.67,158.05 190.99,157.38 v1(190.99,156.81)
  IN2 w0.165: 215.03,160.13 215.03,159.61 212.53,157.12 210.88,157.12 209.97,156.22 209.97,154.99 209.81,154.83 209.32,154.83 209.16,154.99 209.16,155.61 208.99,155.78 208.58,155.78 208.42,155.61 208.42,155.38 207.92,154.89 205,154.89 204.87,155.01 204.87,155.46 204.71,155.62 204.38,155.62 204.21,155.46 204.21,155.01 204.08,154.89 199.3,154.89 199.17,155.01 199.17,155.51 199.01,155.67 198.65,155.67 198.49,155.51 198.49,155.02 198.32,154.86 197.74,154.86 197.57,155.02 197.57,155.42 196.66,156.33 194.32,156.33 194.2,156.46
  BOTTOM w0.102: U34.D14 190.63,157.17 v1(190.99,156.81) ; U32.E7 216.25,163.82 215.96,163.53 v1(215.53,163.53)
VMA_DM2: length 43.4
  TOP w0.102: U5.D3 216.91,163.02 216.91,163.03 216.55,163.03 216.36,162.84 v1(215.33,162.84)
  IN1 w0.165: v1(215.33,162.84) 214.3,162.84 214.13,162.68 214.13,162.37 214.3,162.2 214.6,162.2 214.77,162.04 214.77,161.6 214.6,161.44 214.07,161.44 213.91,161.27 213.91,160.89 214.07,160.73 214.66,160.73 215.23,160.16 215.23,159.5 212.64,156.92 209.5,156.92 209.33,156.75 209.33,156.4 209.5,156.23 209.65,156.23 209.82,156.07 209.82,155.69 209.65,155.52 209.5,155.52 209.33,155.36 209.33,154.94 208.32,153.93 198.83,153.93 197.82,154.94 197.82,155.48 196.84,156.46 196.84,157.53 196.56,157.81 194.81,157.81 194.42,157.43 194.17,157.43 193.96,157.63 193.96,157.95 194.42,158.42 194.42,158.68 v1(194.21,158.9)
  BOTTOM w0.102: v1(215.33,162.84) 214.95,162.84 214.84,162.95 214.84,163.07 214.74,163.17 214.54,163.17 214.44,163.07 214.44,162.95 214.34,162.84 214.12,162.84 U32.D3
  BOTTOM w0.127: U34.C17 191.43,160 191.54,160.1 192.47,160.1 192.68,159.88 193.19,159.88 194.17,158.9 v1(194.21,158.9)
VMA_DM3: length 30.3
  TOP w0.102: v1(204,162.88) 204.15,162.88 204.28,163.01 204.28,163.33 204.4,163.45 204.63,163.45 204.76,163.33 204.76,163.15 204.89,163.02 U4.D3
  IN1 w0.102: v1(204,162.88) 203.07,162.88 202.6,163.34 202.6,163.93 201.88,164.65 200.47,164.65 200.4,164.71 199.62,164.71 199.48,164.86
  IN1 w0.165: v1(194.42,165.65) 194.35,165.65 193.95,166.05 193.32,166.05 193.1,166.26 193.1,166.94 193.27,167.1 194.21,167.1 194.38,166.94 194.38,166.42 194.69,166.11 195.15,166.11 195.52,166.47 195.52,167.66 195.75,167.89 196.02,167.89 196.35,168.22 196.66,168.22 197.04,167.84 197.31,167.84 197.47,168 197.47,168.26 197.64,168.42 197.94,168.42 198.11,168.26 198.11,168.06 198.27,167.89 200.16,167.89 200.32,167.74 200.32,167.34 200.15,167.18 199.39,167.18 199.22,167.01 199.22,165.11 199.48,164.86
  BOTTOM w0.102: U31.D3 203.86,163.02 v1(204,162.88)
  BOTTOM w0.127: v1(194.42,165.65) 194.42,165.23 193.59,164.4 192.46,164.4 192.38,164.32 191.93,164.32 U34.C22
VMA_DM4: length 22.2
  TOP w0.102: U3.E7 185.02,178.69 185.56,178.69 185.66,178.59 185.66,178.32 185.44,178.1 185.44,177.81 185.66,177.59 186.03,177.59 v1(186.17,177.72)
  IN2 w0.165: v1(186.17,177.72) 186.36,177.54 186.36,177.08 186.17,176.89 186.17,173.9 185.58,173.32 185.35,173.32 185.12,173.54 184.89,173.54 184.66,173.31 184.66,173.08 184.88,172.85 184.88,172.62 184.65,172.38 184.41,172.38 184.19,172.6 183.96,172.6 183.73,172.37 183.73,172.14 183.95,171.92 183.95,171.68 183.69,171.42 183.69,167.85 183.69,167.53 183.24,167.08 183.24,166.83 182.7,166.29 182.7,165.34 182.36,165 182.04,165 v1(181.92,165.13)
  BOTTOM w0.102: v1(186.17,177.72) 186.47,178.02 187.54,178.02 U29.E7
  BOTTOM w0.127: v1(181.92,165.13) 182.31,165.52 U34.P24
VMA_DM5: length 26.9
  TOP w0.102: v1(175.32,178.16) 173.69,178.16 173.15,178.7 U2.E7
  IN2 w0.102: 177.33,166.7 177.33,166.48 177.57,166.24 178.29,166.24 v1(178.62,165.91)
  IN2 w0.165: v1(175.32,178.16) 175.35,178.13 175.35,175.16 174.98,174.78 174.98,174.55 175.13,174.39 175.13,174.16 174.9,173.93 174.67,173.93 174.51,174.08 174.28,174.08 173.92,173.73 173.18,173.73 173.01,173.56 173.01,172.99 173.24,172.76 173.57,172.76 173.77,172.96 174.12,172.96 174.31,172.76 174.31,172.53 174.25,172.47 174.25,172.46 173.97,172.18 173.97,172.03 174.14,171.86 174.93,171.86 175.09,172.03 175.09,172.92 175.28,173.11 175.6,173.11 176.07,172.65 176.07,171.03 175.96,170.92 175.96,170.8 175.96,170.8 175.96,169.88 175.77,169.7 175.77,168.25 177.33,166.7
  BOTTOM w0.102: U28.E7 175.87,179.16 175.59,179.16 175.43,179 175.43,178.76 175.67,178.52 175.67,178.26 175.57,178.16 v1(175.32,178.16) ; v1(178.62,165.91) 178.23,165.52 U34.W24
VMA_DM6: length 22.9
  TOP w0.102: U2.D3 176.19,177.74 v1(174.74,177.74)
  IN1 w0.165: v1(174.74,177.74) 174.95,177.54 174.99,177.54 175.55,176.98 175.55,175.58 174.77,174.8 174.77,173.96 174.6,173.8 174.28,173.8 174.12,173.63 174.12,173.25 173.86,173 172.14,173 171.97,172.83 171.97,172.47 172.14,172.31 174.73,172.31 174.89,172.14 174.89,171.81 174.73,171.65 174.23,171.65 174.06,171.48 174.06,171.17 174.23,171 174.6,171 174.76,170.84 v1(174.76,170.79)
  BOTTOM w0.102: U28.D3 173.29,177.74 v1(174.74,177.74)
  BOTTOM w0.127: U34.AA25 176.13,166.73 176.13,168.06 175.82,168.38 175.82,170.52 175.55,170.79 v1(174.76,170.79)
VMA_DM7: length 21.8
  TOP w0.102: v1(186.85,177.52) 186.85,177.27 187.11,177.01 187.49,177.01 188.21,177.73 U3.D3
  IN1 w0.165: v1(179.82,168.37) 179.96,168.37 180.93,169.34 180.93,170.4 181.38,170.84 181.38,171.24 182.24,172.1 185.46,172.1 186.34,172.99 186.34,174.23 185.33,175.24 185.33,176.31 186.06,177.03 186.35,177.03 186.83,177.52 v1(186.85,177.52)
  BOTTOM w0.102: v1(186.85,177.52) 186.62,177.29 185.62,177.29 U29.D3
  BOTTOM w0.127: U34.U25 179.4,166.78 179.4,167.95 v1(179.82,168.37)
VMA_DQ0: length 22.9
  TOP w0.102: U4.F2 206.07,164.62 v1(205.67,164.22)
  IN2 w0.102: v1(205.67,164.22) 205.67,164.12 205.26,163.72 205.26,161.65 205.35,161.56 205.35,159.92
  IN2 w0.165: v1(190.24,160.14) 190.59,160.14 190.73,160.28 193.41,160.28 194.01,160.87 196.15,160.87 198.17,158.85 204.28,158.85 205.35,159.92
  BOTTOM w0.102: U34.E18 190.24,160.14 v1(190.24,160.14) ; v1(205.67,164.22) 206.07,164.62 U4.F2
VMA_DQ1: length 23.4
  TOP w0.102: U4.E3 205.24,163.82 204.84,164.22 v1(204.83,164.22)
  IN2 w0.102: 199.73,160.46 200.1,160.46 200.25,160.61 201.84,160.61 202.09,160.87 202.09,161.64 202.37,161.92 202.81,161.92 203.06,162.17 203.06,163.6 203.44,163.98 203.95,163.98 204.08,163.85 204.47,163.85 v1(204.83,164.22) ; 194.65,161.97 193.59,161.97 192.9,161.29 191.55,161.29 191.48,161.36 190.72,161.36 190.18,160.83 189.87,160.83 189.56,160.52 188.96,160.52 v1(188.56,160.12)
  IN2 w0.165: 199.73,160.46 199.49,160.46 199.33,160.62 199.33,161.32 199.16,161.49 198.83,161.49 198.67,161.32 198.67,161.18 198.41,160.93 198.09,160.93 197.05,161.97 194.65,161.97
  BOTTOM w0.102: U31.F7 205.24,164.62 v1(204.83,164.22) ; U34.F18 188.98,160.54 v1(188.56,160.12)
VMA_DQ2: length 25.1
  TOP w0.102: U4.G2 v1(206.47,165.82)
  IN2 w0.102: 205.72,159.92 205.72,160.84 206.08,161.21 206.08,165.43 v1(206.47,165.82)
  IN2 w0.165: 205.72,159.92 205.72,159.77 204.43,158.48 197.99,158.48 196.7,159.77 195.19,159.77 195.15,159.73 192.62,159.73 192.35,160.01 190.96,160.01 v1(190.23,159.28)
  BOTTOM w0.102: v1(190.23,159.28) 190.23,159.26 U34.E16 ; U31.H8 v1(206.47,165.82)
VMA_DQ3: length 24.3
  TOP w0.102: v1(204.82,165.81) 205.23,166.22 U4.H3
  IN2 w0.102: v1(204.82,165.81) 204.82,164.81 205.24,164.38 205.24,164.03 204.91,163.7 204.91,161.84 204.66,161.59 204.66,160.96 203.97,160.27 ; 192.67,160.63 192.59,160.55 189.89,160.55 v1(189.41,160.07)
  IN2 w0.165: 192.67,160.63 193.08,160.63 193.69,161.24 196.68,161.24 198.62,159.3 203.01,159.3 203.97,160.27
  BOTTOM w0.102: v1(189.41,160.07) 189.04,159.7 U34.F17 ; v1(204.82,165.81) 205.23,166.22 U4.H3
VMA_DQ4: length 20.4
  TOP w0.102: U4.F7 202.07,164.61 v1(201.67,164.22)
  IN2 w0.102: v1(201.67,164.22) 201.5,164.22 201.28,164 201.28,163.25 200.95,162.93
  IN2 w0.165: 200.95,162.93 199.69,162.93 199.53,163.1 199.53,163.32 199.36,163.49 199.06,163.49 198.89,163.32 198.89,162.95 198.73,162.78 198.46,162.78 198.29,162.96 198.29,163.32 198.12,163.49 197.38,163.49 197.17,163.7 195.99,163.7 195.82,163.86 195.82,163.94 195.66,164.11 195.17,164.11 195.01,163.94 195.01,163.86 194.84,163.7 194.04,163.7 193.89,163.55 193.56,163.55 192.76,164.34 192.53,164.34 192.29,164.11 192.29,163.87 192.97,163.19 192.97,162.96 192.7,162.69 192.47,162.69 191.94,163.22 191.74,163.22 191.58,163.05 191.58,162.52 191.41,162.35 191.08,162.35 190.92,162.52 190.92,162.85 190.75,163.01 190.4,163.01 190.24,162.85 v1(190.24,162.58)
  BOTTOM w0.102: v1(201.67,164.22) 202.07,163.82 U31.E3 ; U34.D20 v1(190.24,162.58)
VMA_DQ5: length 18.2
  TOP w0.102: v1(200.87,164.19) 201.27,164.6 U4.F8
  IN2 w0.102: v1(200.87,164.19) 200.5,163.83 200.24,163.83 200.24,163.83 199.83,163.83
  IN2 w0.165: 199.83,163.83 199.48,164.18 199.3,164.18 199.02,163.9 198.72,163.9 198.46,164.16 198.46,164.36 198.73,164.62 198.73,164.86 198.5,165.08 198.19,165.08 197.93,164.82 197.93,164.63 197.76,164.46 197.28,164.46 196.89,164.07 196.62,164.07 196.48,164.2 196.48,164.62 196.63,164.77 196.81,164.77 196.96,164.92 196.96,165.08 196.8,165.25 196.2,165.25 196,165.45 195.42,165.45 195.4,165.44 195.24,165.44 195.08,165.29 195.08,165.24 194.92,165.07 194.41,165.07 194.25,164.91 194.25,164.71 194.49,164.48 194.49,164.24 194.31,164.07 194.04,164.07 193.74,164.37 193.25,164.37 192.83,164.79 192.52,164.79 191.99,164.26 191.68,164.26 191.49,164.07 191.49,163.56 191.36,163.43 v1(191.03,163.43)
  BOTTOM w0.102: U4.F8 201.27,164.6 v1(200.87,164.19) ; v1(191.03,163.43) 191.03,163.42 U34.D21
VMA_DQ6: length 21.8
  TOP w0.102: U4.H7 202.5,165.79 v1(202.53,165.79)
  IN2 w0.102: v1(188.58,162.59) 188.58,162.78 188.79,162.99 189.67,162.99 189.82,163.14 189.82,163.59 190.06,163.83 190.39,163.83 190.57,164.01 190.57,164.39 190.84,164.66 191.92,164.66 ; v1(202.53,165.79) 202.63,165.69 202.63,165.29 202.36,165.02 201.58,165.02 201.21,164.65 200.7,164.65 200.52,164.83 199.26,164.83 199.22,164.87
  IN2 w0.165: 199.22,164.87 199.05,165.05 199.05,165.65 198.88,165.82 197.5,165.82 197.36,165.68 196.58,165.68 196.2,166.06 196.2,166.66 196.04,166.82 195.66,166.82 195.49,166.66 195.49,166.05 195.25,165.81 194.96,165.81 194.63,166.14 194.53,166.14 194.25,166.42 193.95,166.42 193.27,165.74 193.27,165.42 193.1,165.25 192.51,165.25 191.92,164.66
  BOTTOM w0.102: U34.F20 188.99,162.18 v1(188.58,162.59) ; v1(202.53,165.79) 202.5,165.79 U4.H7
VMA_DQ7: length 20.7
  TOP w0.102: U4.H8 v1(200.87,165.82)
  IN2 w0.102: 192.09,165.38 191.58,165.38 191.46,165.5 190.87,165.5 190.61,165.25 190.61,164.98 190.3,164.67 189.99,164.67 189.75,164.43 189.75,163.91 189.38,163.53 v1(189.38,163.42) ; 199.73,166.14 199.88,166.28 200.55,166.28 200.87,165.97 v1(200.87,165.82)
  IN2 w0.165: 192.09,165.38 192.11,165.38 192.39,165.65 192.67,165.65 193.89,166.87 194.23,166.87 194.23,166.88 194.29,166.88 194.76,167.36 195.11,167.36 195.26,167.2 196.53,167.2 196.7,167.04 196.7,166.2 196.85,166.05 197.21,166.05 197.36,166.2 197.36,167.12 197.52,167.28 197.85,167.28 198.02,167.12 198.02,166.38 198.18,166.21 198.51,166.21 198.68,166.38 198.68,167.17 198.83,167.32 199.28,167.32 199.43,167.17 199.43,166.62 199.38,166.57 199.38,166.34 199.58,166.14 199.73,166.14
  BOTTOM w0.102: U34.E21 189.78,163.02 v1(189.38,163.42) ; U31.G2 v1(200.87,165.82)
VMA_DQ8: length 41.2
  TOP w0.102: U5.H7 v1(214.34,165.82)
  IN2 w0.102: v1(214.34,165.82) 214.34,165.18 213.93,164.78 213.93,164.05 213.97,164.01 213.97,161.6 212.99,160.63 212.99,160.35 212.77,160.13
  IN2 w0.165: 212.77,160.13 212.43,159.78 211.34,159.78 211.17,159.95 211.17,161.34 211.01,161.51 210.68,161.51 210.51,161.34 210.51,159.95 210.35,159.78 210.07,159.78 209.91,159.62 209.91,158.75 209.74,158.58 209.4,158.58 209.23,158.75 209.23,159.19 209.07,159.35 208.65,159.35 208.37,159.08 208.37,156.76 208.21,156.59 207.84,156.59 207.68,156.76 207.68,157.01 207.51,157.17 207.2,157.17 207.03,157.01 207.03,156.59 206.87,156.42 206.51,156.42 206.34,156.59 206.34,157.01 206.18,157.17 204.84,157.17 204.76,157.09 204.76,156.64 204.56,156.43 197.78,156.43 197.38,156.83 197.38,157.29 196.66,158.01 193.74,158.01 193.19,158.56 190.35,158.56 v1(190.24,158.45)
  BOTTOM w0.102: v1(190.24,158.45) 189.86,158.06 U34.E15 ; U5.H7 v1(214.34,165.82)
VMA_DQ9: length 41
  TOP w0.102: U5.H8 v1(213.54,165.82)
  IN2 w0.102: 212.3,163.12 212.3,164.59 v1(213.54,165.82)
  IN2 w0.165: v1(191.07,159.27) 191.54,159.74 192.01,159.74 192.39,159.37 195.4,159.37 195.44,159.4 196.54,159.4 198.74,157.2 203.75,157.2 205.98,159.43 207.15,159.43 208.31,160.59 208.31,162.11 208.07,162.35 206.6,162.35 206.44,162.52 206.44,162.8 206.6,162.97 207.47,162.97 207.77,163.26 207.77,164.09 207.93,164.26 208.23,164.26 208.4,164.09 208.4,163.18 208.56,163.01 208.94,163.01 209.1,163.18 209.1,163.71 209.27,163.88 209.63,163.88 209.8,163.71 209.8,163.18 209.96,163.01 210.42,163.01 210.58,163.18 210.58,164.06 210.75,164.22 211.14,164.22 211.31,164.06 211.31,163.1 211.47,162.94 212.12,162.94 212.3,163.12
  BOTTOM w0.102: v1(191.07,159.27) 191.02,159.23 191.02,158.45 U34.D15 ; v1(213.54,165.82) 213.14,165.42 U32.G2
VMA_DQ10: length 42.2
  TOP w0.102: v1(213.54,165.02) 213.14,164.62 U5.F8
  IN2 w0.102: 192.24,158.85 190.08,158.85 189.8,158.58 189.8,158.06 v1(189.4,157.65) ; v1(213.54,165.02) 213.15,164.63 213.15,162.91
  IN2 w0.165: 192.24,158.85 193.56,158.85 194.02,158.39 196.81,158.39 198.39,156.82 203.85,156.82 203.86,156.83 203.9,156.83 206.09,159.02 207.17,159.02 207.33,158.85 207.33,158.46 207.17,158.29 206.5,158.29 206.34,158.13 206.34,157.77 206.5,157.61 207.84,157.61 208.01,157.77 208.01,159.23 208.75,159.98 208.75,162.24 208.92,162.4 209.25,162.4 209.42,162.24 209.42,160.32 209.58,160.15 210,160.15 210.12,160.27 210.12,162.23 210.29,162.4 210.74,162.4 210.91,162.23 210.91,162.14 211.07,161.98 211.38,161.98 211.71,162.3 212.53,162.3 213.15,162.91
  BOTTOM w0.102: U34.F15 188.99,158.05 v1(189.4,157.65) ; U5.F8 213.14,164.62 v1(213.54,165.02)
VMA_DQ11: length 44.4
  TOP w0.102: U5.F7 v1(214.34,164.22)
  IN2 w0.102: v1(189.42,156.81) 189.84,157.23 190.4,157.23 191.21,158.04 191.32,158.04
  IN2 w0.165: v1(214.34,164.22) 214.45,164.11 214.45,161.25 213.88,160.68 213.88,159.94 214.25,159.57 214.25,159.39 213.93,159.08 213.75,159.08 213.45,159.38 212.99,159.38 212.86,159.25 212.86,159.05 212.74,158.92 212.41,158.92 212.28,159.05 212.28,159.25 212.15,159.38 211.8,159.38 211.65,159.23 211.65,157.72 211.48,157.55 211.15,157.55 210.99,157.72 210.99,159.23 210.86,159.36 210.4,159.36 210.27,159.23 210.27,157.04 209.97,156.74 209.65,156.74 209.49,156.9 209.49,158.01 209.32,158.18 208.95,158.18 208.78,158.01 208.78,156.4 208.62,156.24 208.36,156.24 208.18,156.05 206.08,156.05 205.96,156.18 205.96,156.66 205.83,156.79 205.4,156.79 205.27,156.66 205.27,156.18 205.14,156.05 197.52,156.05 197.02,156.56 197.02,157.09 196.48,157.63 193.61,157.63 192.95,158.29 191.57,158.29 191.32,158.04
  BOTTOM w0.102: U32.E3 213.94,163.82 v1(214.34,164.22) ; U34.F13 v1(189.42,156.81)
VMA_DQ12: length 42.4
  TOP w0.102: U5.E3 v1(217.54,164.22)
  IN2 w0.102: 218.1,160.13 218.1,160.4 217.94,160.55 217.94,162.44 217.93,162.45 217.93,162.57 217.54,162.96 v1(217.54,164.22)
  IN2 w0.165: v1(191.84,155.98) 191.84,155.84 194.22,153.46 196.6,153.46 197.16,152.9 205.8,152.9 205.96,153.07 205.96,153.22 206.13,153.38 206.46,153.38 206.62,153.22 206.62,153.07 206.79,152.9 207.12,152.9 207.29,153.07 207.29,153.22 207.45,153.38 207.78,153.38 207.95,153.22 207.95,153.07 208.11,152.9 208.44,152.9 208.61,153.07 208.61,153.22 208.77,153.38 209.1,153.38 209.27,153.22 209.27,153.07 209.43,152.9 209.76,152.9 209.93,153.07 209.93,153.22 210.09,153.38 210.42,153.38 210.59,153.22 210.59,153.07 210.75,152.9 211.65,152.9 212,153.26 212.23,153.26 212.45,153.04 212.68,153.04 212.92,153.27 212.92,153.5 212.7,153.72 212.7,153.96 212.93,154.19 213.16,154.19 213.44,153.91 213.69,153.91 213.96,154.17 213.96,154.33 213.63,154.66 213.63,154.89 215.07,156.33 215.3,156.33 215.44,156.19 215.67,156.19 215.9,156.43 215.9,156.66 215.77,156.79 215.77,157.03 216.23,157.49 216.88,157.49 217,157.62 217,158.26 218.09,159.35 218.09,160.12 218.1,160.13
  BOTTOM w0.102: v1(191.84,155.98) 191.44,156.38 U34.C13 ; U32.F7 217.14,164.62 v1(217.54,164.22)
VMA_DQ13: length 41
  TOP w0.102: U5.H3 v1(216.74,165.82)
  IN2 w0.102: 217.2,160.13 217.2,160.76 217.11,160.85 217.11,162.41 217.15,162.45 217.15,163.62 216.8,163.96 216.8,165.76 v1(216.74,165.82)
  IN2 w0.165: v1(192.63,155.98) 192.63,155.87 194.65,153.84 196.98,153.84 197.08,153.75 197.54,153.75 197.8,153.49 198.2,153.49 198.46,153.75 198.86,153.75 199.12,153.49 199.52,153.49 199.78,153.75 200.18,153.75 200.44,153.49 200.84,153.49 201.1,153.75 201.5,153.75 201.76,153.49 202.16,153.49 202.42,153.75 210.83,153.75 211.28,154.2 211.51,154.2 211.85,153.87 212.08,153.87 212.33,154.12 212.33,154.35 212,154.68 212,154.91 212.24,155.15 212.47,155.15 212.77,154.85 213.07,154.85 213.52,155.3 213.52,155.53 213.25,155.8 213.25,156.03 213.49,156.26 213.72,156.26 213.99,156 214.22,156 214.45,156.23 214.45,156.47 214.14,156.78 214.14,157.01 214.38,157.24 214.61,157.24 214.92,156.93 215.15,156.93 217.2,158.98 217.2,160.13
  BOTTOM w0.102: U5.H3 v1(216.74,165.82) ; U34.B13 v1(192.63,155.98)
VMA_DQ14: length 43.9
  TOP w0.102: U5.G2 v1(217.54,165.82)
  IN2 w0.102: 219.1,164.72 219.09,164.72 218.81,165 218.81,165.13 218.51,165.43 217.93,165.43 v1(217.54,165.82)
  IN2 w0.165: v1(190.23,155.99) 190.67,155.55 190.89,155.55 194.32,152.12 213.08,152.12 216.43,155.46 216.43,155.86 219.7,159.13 219.7,164.27 219.28,164.69 219.13,164.69 219.1,164.72
  BOTTOM w0.102: U34.E13 v1(190.23,155.99) ; U32.H8 v1(217.54,165.82)
VMA_DQ15: length 42.6
  TOP w0.102: U5.F2 v1(217.54,165.02)
  IN2 w0.102: 218.77,160.67 218.77,162.28 218.75,162.3 218.75,163.6 218.76,163.61 218.76,164.39 218.54,164.61 217.95,164.61 v1(217.54,165.02) ; 191.78,155.25 191.78,155.42 191.44,155.76 191.44,156.16 191.2,156.4 190.67,156.4 v1(190.28,156.8)
  IN2 w0.165: 191.78,155.25 193.93,153.09 196.24,153.09 196.81,152.52 212.97,152.52 216.06,155.62 216.06,156.02 218.91,158.87 218.91,159.51 218.53,159.89 218.53,160.43 218.77,160.67
  BOTTOM w0.102: v1(190.28,156.8) 190.63,156.44 U34.D13 ; U5.F2 v1(217.54,165.02)
VMA_DQ16: length 38.9
  TOP w0.102: U5.A2 217.97,160.62 v1(218.37,161.02)
  IN1 w0.165: v1(195.29,154.35) 195.39,154.35 197.8,151.94 204.13,151.94 204.3,151.77 204.3,151.47 204.46,151.3 204.79,151.3 204.96,151.47 204.96,151.77 205.12,151.94 205.45,151.94 205.62,151.77 205.62,151.47 205.78,151.3 206.11,151.3 206.28,151.47 206.28,151.77 206.44,151.94 206.78,151.94 206.94,151.77 206.94,151.47 207.11,151.3 207.44,151.3 207.6,151.47 207.6,151.77 207.77,151.94 208.1,151.94 208.26,151.77 208.26,151.47 208.43,151.3 208.76,151.3 208.92,151.47 208.92,151.77 209.09,151.94 210.95,151.94 218.25,159.24 218.25,159.91 217.89,160.27 217.89,160.55 v1(218.37,161.02)
  BOTTOM w0.102: U32.B8 217.97,161.42 v1(218.37,161.02)
  BOTTOM w0.127: U34.B15 192.23,157.96 193.54,156.66 193.54,156.12 194.45,155.2 194.65,155.2 195.29,154.56 v1(195.29,154.35)
VMA_DQ17: length 37
  TOP w0.102: U5.C3 v1(216.74,162.62)
  IN1 w0.165: v1(194.48,155.77) 195.43,154.82 195.54,154.82 198.04,152.31 210.79,152.31 217.49,159 217.49,160.27 216.74,161.02 v1(216.74,162.62)
  BOTTOM w0.102: U32.D7 v1(216.74,162.62)
  BOTTOM w0.127: v1(194.48,155.77) 194.2,156.05 194.02,156.05 193.76,156.31 193.76,156.77 192.64,157.89 192.64,158.16 192.35,158.45 192.1,158.45 U34.C16
VMA_DQ18: length 38.4
  TOP w0.102: v1(218.37,161.82) 217.97,162.22 U5.C2
  IN1 w0.102: v1(218.37,161.82) 218.77,161.41 218.77,160.14 218.73,160.1 218.73,159.87
  IN1 w0.165: 218.73,159.87 218.73,158.95 215.78,155.99 215.78,155.33 214.62,154.17 214.11,154.17 212.54,152.6 212.54,152.09 212.3,151.86 212.07,151.86 211.85,152.08 211.61,152.08 211.38,151.85 211.38,151.61 211.6,151.39 211.6,151.16 211.34,150.9 210.38,150.9 210.21,151.06 210.21,151.41 210.05,151.57 209.72,151.57 209.55,151.41 209.55,151.06 209.39,150.9 198.16,150.9 195.34,153.72 195.16,153.72 194.65,154.22 v1(194.65,154.61)
  BOTTOM w0.102: U5.C2 217.97,162.22 v1(218.37,161.82)
  BOTTOM w0.127: U34.A13 193.03,156.3 194.65,154.68 v1(194.65,154.61)
VMA_DQ19: length 38.5
  TOP w0.102: U5.A3 v1(216.74,160.22)
  IN1 w0.165: v1(216.74,160.22) 217.03,159.93 217.03,159.1 215.14,157.21 214.91,157.21 214.77,157.35 214.53,157.35 214.3,157.12 214.3,156.88 214.44,156.74 214.44,156.51 214.21,156.28 213.97,156.28 213.83,156.42 213.6,156.42 213.36,156.18 213.36,155.95 213.5,155.81 213.5,155.58 212.76,154.84 212.53,154.84 212.16,155.21 211.92,155.21 211.69,154.98 211.69,154.74 212.06,154.37 212.06,154.14 211.83,153.9 211.6,153.9 211.18,154.32 210.95,154.32 210.72,154.08 210.72,153.85 211.13,153.43 211.13,153.2 210.6,152.68 210.31,152.68 210.15,152.84 210.15,153.63 209.98,153.79 209.64,153.79 209.46,153.61 209.46,152.84 209.3,152.68 198.41,152.68 195.31,155.77 v1(195.16,155.77)
  BOTTOM w0.102: U5.A3 v1(216.74,160.22)
  BOTTOM w0.127: v1(195.16,155.77) 195.28,155.77 195.44,155.94 195.44,156.24 195.28,156.41 194.16,156.41 193.99,156.57 193.99,157.45 193.38,158.06 U34.A15
VMA_DQ20: length 37.4
  TOP w0.102: U5.A7 v1(214.34,160.22)
  IN1 w0.165: v1(194.95,158.9) 194.95,158.43 195.16,158.21 196.71,158.21 197.21,157.72 197.21,156.61 198.19,155.63 198.19,155.32 198.97,154.54 199.21,154.3 208.1,154.3 208.74,154.94 208.95,155.15 208.95,158.34 209.36,158.75 211.43,158.75 211.59,158.58 211.59,158.23 211.43,158.06 209.83,158.06 209.66,157.9 209.66,157.45 209.83,157.29 212.42,157.29 214.34,159.21 v1(214.34,160.22)
  BOTTOM w0.102: U5.A7 v1(214.34,160.22)
  BOTTOM w0.127: U34.B18 192.53,160.54 192.86,160.21 192.87,160.21 192.89,160.19 193.21,160.19 193.94,159.46 194.34,159.46 194.91,158.9 v1(194.95,158.9)
VMA_DQ21: length 35.8
  TOP w0.102: U5.C8 v1(213.54,161.82)
  IN1 w0.165: v1(195.63,158.94) 195.63,159.06 195.8,159.23 196.29,159.23 196.46,159.06 196.46,158.8 196.62,158.63 197.08,158.63 197.57,158.14 197.57,156.84 198.56,155.86 198.56,155.48 199.34,154.69 204.29,154.69 204.46,154.86 204.46,155.15 204.62,155.32 204.93,155.32 205.09,155.15 205.09,154.86 205.26,154.69 207.67,154.69 207.67,154.69 207.97,154.69 208.58,155.3 208.58,158.49 209.27,159.18 210.06,159.18 210.22,159.34 210.22,160.14 210.4,160.32 210.74,160.32 210.91,160.16 210.91,159.34 211.07,159.18 211.84,159.18 212,159.01 212,158.91 212.17,158.75 212.5,158.75 212.66,158.91 212.66,159.01 212.83,159.18 213.68,159.18 213.97,159.47 213.97,159.87 213.25,160.6 213.25,161.53 v1(213.54,161.82)
  BOTTOM w0.102: U32.C3 v1(213.54,161.82)
  BOTTOM w0.127: v1(195.63,158.94) 194.83,159.74 194.02,159.74 193.21,160.54 U34.A18
VMA_DQ22: length 35.4
  TOP w0.102: U5.B8 v1(212.74,161.02)
  IN1 w0.165: v1(194.96,160.2) 194.87,160.2 194.7,160.03 194.7,159.71 194.88,159.53 195.34,159.53 195.52,159.71 196.52,159.71 197.94,158.29 197.94,157.13 199,156.08 199,155.62 199.56,155.06 200.08,155.06 200.24,155.23 200.24,155.66 200.41,155.82 200.71,155.82 200.87,155.67 200.87,155.23 201.04,155.06 203.84,155.06 204.01,155.23 204.01,155.69 204.14,155.82 205.31,155.82 205.47,155.66 205.47,155.23 205.64,155.06 207.82,155.06 208.22,155.46 208.22,158.66 210.79,161.24 211.19,161.24 211.37,161.06 211.37,159.75 211.53,159.58 212.62,159.58 212.78,159.74 212.78,160.13 212.62,160.3 212.47,160.3 212.31,160.46 212.31,160.85 212.47,161.02 v1(212.74,161.02)
  BOTTOM w0.102: U32.A2 v1(212.74,161.02)
  BOTTOM w0.127: v1(194.96,160.2) 193.82,161.34 U34.A19
VMA_DQ23: length 36.5
  TOP w0.102: U5.D7 v1(213.54,162.62)
  IN1 w0.165: v1(213.54,162.62) 213.54,162.44 213.37,162.28 212.95,162.28 212.79,162.44 212.79,162.8 212.62,162.96 212.37,162.96 212.2,162.8 212.2,162.57 212.04,162.4 211.44,162.4 210.88,161.84 210.64,161.84 210.24,162.24 210.01,162.24 209.75,161.98 209.75,161.8 210.18,161.37 210.18,161.14 209.94,160.9 209.71,160.9 209.03,161.58 208.79,161.58 208.56,161.35 208.56,161.12 209.24,160.44 209.24,160.2 209.08,160.04 208.47,160.04 208.34,159.91 208.34,159.3 207.63,158.59 207.63,158.39 207.8,158.22 207.8,157.87 207.64,157.7 207.46,157.7 207.3,157.54 207.3,157.11 207.46,156.94 207.62,156.94 207.78,156.78 207.78,156.35 207.66,156.22 199.37,156.22 198.31,157.29 198.31,158.45 196.02,160.73 194.43,160.73 194.21,160.51 v1(194.21,160.2)
  BOTTOM w0.102: U32.C2 v1(213.54,162.62)
  BOTTOM w0.127: v1(194.21,160.2) 193.45,160.96 191.82,160.96 U34.C19
VMA_DQ24: length 23.2
  TOP w0.102: U4.C2 v1(205.67,162.62)
  IN1 w0.102: v1(205.67,162.62) 205.26,163.03 205.26,166.12 204.76,166.62 203.97,166.62 203.83,166.76
  IN1 w0.165: 203.83,166.76 203.43,167.15 203.31,167.15 202.51,167.95 202.51,168.06 201.07,169.51 200.5,169.51 200.17,169.84 199.89,170.11 199.51,170.11 199.25,169.85 198.23,169.85 197.68,170.4 196.89,170.4 196.3,169.82 195.01,169.82 193.97,168.78 193.97,168.04 v1(194.04,167.97)
  BOTTOM w0.102: v1(205.67,162.62) 205.27,163.02 U31.D7
  BOTTOM w0.127: U34.B24 192.26,165.52 192.67,165.93 193.18,165.93 194.04,166.8 v1(194.04,167.97)
VMA_DQ25: length 24.1
  TOP w0.102: U4.D7 202.16,163.02 v1(202.63,162.55)
  IN1 w0.102: 199.28,163.64 199.93,162.99 202.19,162.99 v1(202.63,162.55)
  IN1 w0.165: 199.28,163.64 198.86,164.06 198.86,167.31 198.74,167.42 196,167.42 195.88,167.31 195.88,165.97 195.69,165.78 195.35,165.78 194.74,165.17 194.08,165.17 193.92,165.01 193.92,164.32 193.75,164.16 192.79,164.16 192.62,164.32 192.62,164.49 192.77,164.64 192.77,164.89 192.25,165.41 192.25,165.64 192.49,165.88 192.73,165.88 193.23,165.38 193.57,165.38 v1(193.74,165.55)
  BOTTOM w0.102: v1(202.63,162.55) 202.3,162.22 U31.C3
  BOTTOM w0.127: U34.C23 191.93,165.17 193.18,165.17 193.57,165.55 v1(193.74,165.55)
VMA_DQ26: length 20.9
  TOP w0.102: U4.C3 v1(205.67,161.82)
  IN1 w0.102: 202.8,166.76 202.8,166.32 202.98,166.14 202.98,164.59 203.44,164.14 203.72,164.14 205.07,162.79 205.07,162.51 205.67,161.9 v1(205.67,161.82)
  IN1 w0.165: 202.8,166.76 202.8,167.08 201.31,168.58 200.68,168.58 200.58,168.68 198.84,168.68 198.23,169.29 197.45,169.29 197.35,169.38 195.18,169.38 194.53,168.73 194.53,167.76 194.25,167.48 193.64,167.48 v1(193.49,167.64)
  BOTTOM w0.102: v1(205.67,161.82) 206.07,162.22 U31.C8
  BOTTOM w0.127: U34.A25 193.49,166.78 v1(193.49,167.64)
VMA_DQ27: length 22.4
  TOP w0.102: U4.A2 v1(206.47,161.02)
  IN1 w0.102: v1(206.47,161.02) 205.82,161.02 204.86,161.97 204.86,162.71 203.64,163.93 203.35,163.93 202.1,165.18 202.1,165.96 202.13,165.98 202.13,166.76
  IN1 w0.165: v1(194.88,166.57) 194.88,167.29 194.94,167.35 194.94,168.63 195.33,169.01 197.2,169.01 197.29,168.92 198.08,168.92 198.69,168.31 200.43,168.31 200.53,168.21 201.15,168.21 201.43,167.93 201.43,167.32 201.6,167.15 201.94,167.15 202.13,166.96 202.13,166.76
  BOTTOM w0.102: U31.B8 v1(206.47,161.02)
  BOTTOM w0.127: U34.A24 193.1,165.52 194.09,166.52 194.83,166.52 v1(194.88,166.57)
VMA_DQ28: length 23.7
  TOP w0.102: v1(201.69,161.04) 201.31,161.42 U4.B8
  IN1 w0.165: v1(201.69,161.04) 202.1,161.45 203.23,161.45 203.39,161.29 203.39,160.83 203.8,160.42 204.18,160.42 204.41,160.19 204.41,160.03 204.59,159.85 204.59,159.61 204.39,159.42 203.99,159.42 202.87,160.54 201.69,160.54 201.38,160.23 201.38,159.93 201.52,159.79 201.52,158.83 201.37,158.68 200.95,158.68 200.8,158.83 200.8,159.42 200.63,159.58 200.38,159.58 200.22,159.75 200.22,160.29 199.98,160.53 199.74,160.53 199.39,160.18 199.1,160.18 198.33,160.95 198.33,161.18 198.51,161.36 198.51,162.05 197.9,162.66 197.09,162.66 196.48,163.27 196.11,163.27 195.39,162.55 v1(195.39,162.53)
  BOTTOM w0.102: U31.A2 v1(201.69,161.04)
  BOTTOM w0.127: U34.A21 194.9,163.02 v1(195.39,162.53)
VMA_DQ29: length 24
  TOP w0.102: U4.A3 v1(204.87,160.22)
  IN1 w0.165: v1(204.87,160.22) 204.87,160.47 204.57,160.76 204.57,161 204.81,161.23 205.04,161.23 205.75,160.52 206.31,160.52 206.69,160.14 206.69,159.69 206.17,159.16 206.17,157.66 205.88,157.37 200.62,157.37 200.27,157.73 200.27,158.03 199.64,158.66 199.55,158.66 196.42,161.79 194.74,161.79 v1(194.12,162.4)
  BOTTOM w0.102: U4.A3 v1(204.87,160.22)
  BOTTOM w0.127: U34.B21 192.46,163.02 193.08,162.4 v1(194.12,162.4)
VMA_DQ30: length 25.7
  TOP w0.102: U4.C8 v1(201.67,161.82)
  IN1 w0.102: 199.61,161.23 199.78,161.41 200.26,161.41 200.29,161.44 201.3,161.44 v1(201.67,161.82)
  IN1 w0.165: v1(194.75,162.45) 194.3,162.91 193.7,162.91 193.54,162.75 193.54,162.11 193.37,161.95 193.08,161.95 192.9,162.12 192.9,162.75 192.74,162.91 192.56,162.91 192.39,163.08 192.39,163.51 192.56,163.67 193.98,163.67 194.14,163.84 194.14,163.99 194.31,164.16 194.67,164.16 194.83,163.99 194.83,163.31 195,163.14 195.33,163.14 195.49,163.31 195.49,163.66 195.66,163.83 195.97,163.83 196.84,164.7 197.11,164.7 197.3,164.5 197.3,164.27 196.9,163.86 196.9,163.66 197.29,163.27 197.85,163.27 198.72,162.4 199.28,162.4 199.45,162.23 199.45,161.83 199.29,161.67 199.09,161.67 198.92,161.5 198.92,161.02 199.09,160.85 199.44,160.85 199.61,161.02 199.61,161.23
  BOTTOM w0.102: U4.C8 v1(201.67,161.82)
  BOTTOM w0.127: U34.C20 191.79,162.54 192.47,162.54 193.03,161.97 194.27,161.97 194.28,161.98 194.29,161.98 194.54,162.23 194.54,162.24 v1(194.75,162.45)
VMA_DQ31: length 25.8
  TOP w0.102: v1(202.42,160.1) 202.07,160.45 U4.A7
  IN1 w0.165: v1(202.42,160.1) 202.7,160.1 203.29,159.52 203.29,159.22 203.45,159.05 204.24,159.05 204.88,159.05 205.04,159.22 205.04,159.6 205.21,159.76 205.59,159.76 205.75,159.6 205.75,158.71 205.35,158.3 202.68,158.3 202.53,158.45 202.53,159.37 202.36,159.53 202.06,159.53 201.89,159.37 201.89,158.47 201.74,158.31 200.73,158.31 199.85,159.19 199.85,159.68 199.72,159.81 198.92,159.81 196.58,162.16 196.4,162.16 v1(196.02,162.53)
  BOTTOM w0.102: v1(202.42,160.1) 202.07,160.45 U4.A7
  BOTTOM w0.127: v1(196.02,162.53) 195.18,163.38 191.87,163.38 191.51,163.02 U34.C21
VMA_DQ32: length 23.5
  TOP w0.102: U3.F7 v1(185.41,179.1)
  IN2 w0.102: v1(181.1,163.49) 181.51,163.9 181.51,164.96 181.51,164.96 181.51,165.71 181.5,165.72 181.5,166.33 181.47,166.37 ; 182.73,177.03 182.8,177.1 183.18,177.1 183.19,177.09 183.95,177.09 184.19,177.33 184.19,177.76 184.34,177.92 184.83,177.92 185.18,178.27 185.18,178.87 v1(185.41,179.1)
  IN2 w0.165: 182.73,177.03 182.5,176.81 182.5,174.68 182.66,174.52 183.76,174.52 183.92,174.35 183.92,174.05 183.76,173.89 182.53,173.89 182.36,173.72 182.36,171.98 181.8,171.42 181.8,170.15 182.01,169.94 182.01,168.72 181.84,168.56 181.61,168.56 181.44,168.39 181.44,168.07 181.61,167.9 181.76,167.9 181.92,167.73 181.92,167.46 181.76,167.29 181.61,167.29 181.44,167.13 181.44,166.39 181.47,166.37
  BOTTOM w0.127: U29.E3 v1(185.41,179.1) ; U34.R22 v1(181.1,163.49)
VMA_DQ33: length 18.6
  TOP w0.102: U3.H7 185.01,181.07 v1(185.44,180.65)
  IN2 w0.102: v1(185.44,180.65) 185.44,179.77 183,177.34 182.56,177.34
  IN2 w0.165: 182.56,177.34 182,176.77 182,172.74 181.18,171.93 181.18,170.36 181.09,170.27 v1(181.09,165.9)
  BOTTOM w0.127: v1(185.44,180.65) 185.01,181.07 U3.H7 ; U34.R24 181.47,165.52 v1(181.09,165.9)
VMA_DQ34: length 18.8
  TOP w0.102: U3.F8 184.21,179.48 183.81,179.08 v1(183.8,179.08)
  IN2 w0.102: 181.16,177.01 182.11,177.96 183.01,177.96 183.8,178.75 v1(183.8,179.08)
  IN2 w0.165: 181.16,177.01 181.09,176.94 181.09,175.96 180.4,175.27 180.4,171.43 180.32,171.34 180.32,166.95 180.39,166.87 180.39,164.99 v1(181.11,164.28)
  BOTTOM w0.127: U3.F8 v1(183.8,179.08) ; U34.T22 181.08,164.27 181.08,164.28 v1(181.11,164.28)
VMA_DQ35: length 21
  TOP w0.102: U3.H8 184.21,181.07 v1(184.61,180.67)
  IN2 w0.102: v1(184.61,180.67) 184.23,180.29 184.23,178.89 182.96,177.62 182.43,177.62
  IN2 w0.165: v1(181.1,165.13) 180.66,165.58 180.66,166.08 180.71,166.13 180.71,170.57 180.81,170.67 180.81,172.09 181.58,172.86 181.58,173.23 181.42,173.39 180.96,173.39 180.8,173.56 180.8,173.89 180.96,174.05 181.42,174.05 181.58,174.22 181.58,174.56 181.42,174.73 181.34,174.73 181.17,174.89 181.17,175.27 181.34,175.43 181.42,175.43 181.58,175.6 181.58,176.77 182.43,177.62
  BOTTOM w0.127: v1(181.1,165.13) 181.49,164.74 U34.R23 ; v1(184.61,180.67) 184.24,180.3 U29.G2
VMA_DQ36: length 24.5
  TOP w0.114: U3.H3 v1(187.81,180.7)
  IN2 w0.165: v1(184.15,170.24) 184.49,170.58 184.49,170.85 184.28,171.06 184.28,171.3 184.53,171.55 184.76,171.55 185.02,171.29 185.2,171.29 185.4,171.49 185.4,172.35 186.79,173.73 187.32,173.73 187.49,173.9 187.49,174.19 187.32,174.35 186.91,174.35 186.74,174.52 186.74,174.84 186.91,175.01 187.12,175.01 187.29,175.17 187.29,180.52 187.47,180.7 v1(187.81,180.7)
  BOTTOM w0.127: v1(184.15,170.24) 185.35,171.44 185.35,171.67 185.17,171.84 184.94,171.84 183.17,170.07 183.17,168.47 182.82,168.12 182.82,166.9 183.17,166.54 U34.N25 ; U3.H3 v1(187.81,180.7)
VMA_DQ37: length 22.1
  TOP w0.114: U3.G2 v1(188.61,180.7)
  IN2 w0.165: v1(184.19,168.93) 184.46,169.2 184.46,169.22 184.65,169.41 184.65,170.02 186.07,171.44 186.07,171.67 185.78,171.96 185.78,172.19 186.02,172.42 186.25,172.42 186.53,172.14 186.77,172.14 187,172.37 187,172.61 186.72,172.89 186.72,173.12 186.95,173.36 187.18,173.36 187.47,173.07 187.7,173.07 187.96,173.34 187.96,174.6 188.12,174.76 188.12,175.18 187.95,175.34 187.83,175.34 187.66,175.51 187.66,176.13 187.83,176.3 187.95,176.3 188.12,176.46 188.12,177.01 187.95,177.18 187.86,177.18 187.7,177.34 187.7,177.77 187.86,177.94 188.7,177.94 188.86,178.1 188.86,178.43 188.7,178.6 187.79,178.6 187.65,178.74 187.65,179.23 187.82,179.4 187.95,179.4 188.11,179.56 188.11,180.2 v1(188.61,180.7)
  BOTTOM w0.127: U34.N26 183.17,167.31 183.62,167.75 183.62,168.07 184.09,168.54 184.09,168.83 v1(184.19,168.93) ; U29.H8 v1(188.61,180.7)
VMA_DQ38: length 23.1
  TOP w0.114: U3.F2 v1(189.41,179.9)
  IN2 w0.102: 190.5,178.74 190.48,178.72 190.06,178.72 189.84,178.94 189.84,179.54 189.48,179.9 v1(189.41,179.9) ; v1(183.58,164.31) 182.95,164.94 182.95,166.2 183.48,166.73 183.48,166.99 183.92,167.43 183.92,167.75 184.84,168.67 184.84,169.08 184.9,169.14
  IN2 w0.165: 184.9,169.14 185.02,169.26 185.02,169.86 188.68,173.52 188.68,173.75 188.35,174.07 188.35,174.3 188.59,174.54 188.82,174.54 189.14,174.22 189.38,174.22 190.95,175.79 190.95,177.16 190.76,177.35 190.76,178.58 190.6,178.74 190.5,178.74
  BOTTOM w0.127: v1(183.58,164.31) 183.17,164.71 U34.N23 ; U3.F2 v1(189.41,179.9)
VMA_DQ39: length 23.7
  TOP w0.114: U3.E3 v1(188.61,179.1)
  IN2 w0.102: 190.84,180.01 190.55,180.31 189.25,180.31 189,180.07 189,179.25 188.85,179.1 v1(188.61,179.1) ; 184.29,167.6 184.29,167.51 183.68,166.9 183.68,166.65 183.15,166.12 183.15,165.55 v1(183.58,165.12)
  IN2 w0.165: 190.84,180.01 191.32,179.54 191.32,175.53 185.39,169.59 185.39,168.7 184.29,167.6
  BOTTOM w0.127: v1(183.58,165.12) 183.58,165.12 U34.N24 ; U29.F7 v1(188.61,179.1)
VMA_DQ40: length 24.3
  TOP w0.102: v1(176.75,179.9) 177.14,179.51 U2.F2
  IN2 w0.165: v1(176.75,179.9) 176.35,179.9 176.24,179.79 176.24,178.75 176.4,178.58 176.82,178.58 176.98,178.42 176.98,178.11 176.84,177.97 176.43,177.97 176.24,177.78 176.24,174.93 176.43,174.73 176.43,173.36 176.6,173.2 176.85,173.2 177.01,173.36 177.01,173.87 177.18,174.03 177.59,174.03 178.23,173.39 178.23,172.91 178.07,172.75 177.38,172.75 177.21,172.58 177.21,172.34 177.49,172.06 178.11,172.06 178.28,171.89 178.28,171.58 178.11,171.42 178.03,171.42 177.87,171.25 177.87,170.92 178.03,170.76 178.11,170.76 178.28,170.59 178.28,170.26 178.11,170.1 178.03,170.1 177.87,169.93 177.87,169.6 178.03,169.44 178.11,169.44 178.28,169.27 178.28,168.94 178.11,168.78 178.03,168.78 177.87,168.61 177.87,168.31 178.03,168.14 178.12,168.14 178.29,167.98 178.29,167.49 179.43,166.35 v1(179.43,165.14)
  BOTTOM w0.102: v1(176.75,179.9) 177.14,179.51 U2.F2 ; U34.V23 179.01,164.73 v1(179.43,165.14)
VMA_DQ41: length 26.4
  TOP w0.114: U2.H3 v1(175.94,181.5)
  IN2 w0.102: 178.98,165.66 178.98,164.48 179.01,164.45 179.01,163.93 v1(179.48,163.46)
  IN2 w0.165: v1(175.94,181.5) 175.72,181.5 175.55,181.33 175.55,181.04 175.72,180.88 176.09,180.88 176.25,180.71 176.25,180.4 176.09,180.23 175.48,180.23 175.31,180.07 175.31,179.57 175.48,179.4 175.7,179.4 175.87,179.24 175.87,174.77 176.06,174.58 176.06,174.38 175.9,174.21 175.7,174.21 175.53,174.05 175.53,173.74 175.7,173.57 175.9,173.57 176.06,173.41 176.06,173.17 176.63,172.6 176.63,171.87 176.8,171.7 177.34,171.7 177.5,171.53 177.5,171.11 177.34,170.94 177.3,170.94 177.13,170.78 177.13,170.45 177.3,170.28 177.34,170.28 177.5,170.12 177.5,169.79 177.34,169.62 177.19,169.62 177.02,169.46 177.02,169.13 177.19,168.96 177.34,168.96 177.5,168.8 177.5,168.53 177.34,168.37 176.94,168.37 176.77,168.2 176.77,167.78 177.12,167.42 177.77,167.42 179.06,166.14 179.06,165.73 178.98,165.66
  BOTTOM w0.102: U2.H3 v1(175.94,181.5) ; U34.V22 179.44,163.46 v1(179.48,163.46)
VMA_DQ42: length 25.4
  TOP w0.114: v1(177.53,180.72) 177.14,180.32 U2.G2
  IN2 w0.165: v1(177.53,180.72) 178.1,180.15 179.71,180.15 179.87,179.99 179.87,179.65 179.71,179.49 179.16,179.49 178.99,179.32 178.99,178.99 179.16,178.82 179.78,178.82 179.94,178.66 179.94,178.31 179.78,178.15 179.54,178.15 179.37,177.98 179.37,177.57 179.54,177.41 180.44,177.41 180.61,177.24 180.61,176.9 180.44,176.73 179.54,176.73 179.37,176.57 179.37,176.16 179.54,176 179.87,176 180.04,175.83 180.04,172.71 179.87,172.55 179.42,172.55 179.25,172.38 179.25,167.57 180.12,166.7 180.12,164.51 v1(180.28,164.35)
  BOTTOM w0.102: U34.T23 180.66,164.72 v1(180.28,164.35) ; v1(177.53,180.72) 177.15,181.1 U28.H8
VMA_DQ43: length 25.9
  TOP w0.102: U2.E3 176.35,178.7 v1(176.73,179.07)
  IN2 w0.102: v1(176.73,179.07) 176.95,179.07 177.34,178.68 178.58,178.68 ; 179.84,165.54 179.84,163.95 180.25,163.55 v1(180.25,163.49)
  IN2 w0.165: 179.84,165.54 179.84,166.46 178.81,167.49 178.81,172.05 178.52,172.33 178.52,172.51 178.81,172.79 178.81,173.15 178.97,173.32 179.49,173.32 179.65,173.48 179.65,173.81 179.49,173.98 178.17,173.98 177.92,174.22 177.92,174.53 178.01,174.62 179.49,174.62 179.65,174.78 179.65,175.3 179.51,175.44 178.95,175.44 178.81,175.58 178.81,176.27 178.68,176.4 178.14,176.4 178.02,176.53 178.02,176.83 178.14,176.96 178.86,176.96 179.01,177.1 179.01,178.43 178.75,178.68 178.58,178.68
  BOTTOM w0.102: U28.F7 176.34,179.46 v1(176.73,179.07) ; U34.U22 v1(180.25,163.49)
VMA_DQ44: length 24.5
  TOP w0.102: U2.F7 173.11,179.5 v1(172.73,179.11)
  IN2 w0.165: v1(177.78,165.12) 177.44,165.12 176.6,165.95 176.6,166.1 176.26,166.44 176.11,166.44 174.06,168.49 174.06,168.87 173.82,169.1 173.36,169.1 173.2,169.26 173.2,169.74 173.36,169.9 173.58,169.9 173.74,170.06 173.74,170.57 173.58,170.73 173.39,170.73 173.22,170.89 173.22,171.26 173.06,171.43 172.53,171.43 172.03,170.92 172.03,169.99 171.86,169.82 171.5,169.82 171.16,170.16 171.16,170.98 171.84,171.66 171.84,174.24 172.46,174.86 172.46,175.72 173.22,176.48 173.22,178.62 v1(172.73,179.11)
  BOTTOM w0.102: v1(172.73,179.11) 172.73,179.11 U28.E3 ; U34.Y24 v1(177.78,165.12)
VMA_DQ45: length 23.9
  TOP w0.102: U2.F8 v1(172.74,179.9)
  IN2 w0.102: 170.69,178.67 170.7,178.68 171.53,178.68 v1(172.74,179.9)
  IN2 w0.165: 170.69,178.67 170.62,178.6 170.62,178.01 170.8,177.83 171.27,177.83 171.42,177.68 171.42,177.33 171.26,177.17 170.79,177.17 170.62,177 170.62,174.51 170.78,174.34 171.16,174.34 171.32,174.18 171.32,173.14 171.16,172.97 170.79,172.97 170.63,172.8 170.63,172.47 170.79,172.3 171.23,172.3 171.39,172.14 171.39,171.81 171.23,171.65 170.79,171.65 170.63,171.48 170.63,170.05 171.23,169.44 171.9,169.44 172.06,169.28 172.06,168.61 172.29,168.38 173.65,168.38 v1(176.11,165.92)
  BOTTOM w0.102: U34.AA24 176.51,165.52 v1(176.11,165.92) ; U2.F8 v1(172.74,179.9)
VMA_DQ46: length 23.9
  TOP w0.102: U2.H8 v1(171.94,180.7)
  IN2 w0.102: 170.69,180.27 170.75,180.33 171.22,180.33 171.58,180.7 v1(171.94,180.7)
  IN2 w0.165: 170.69,180.27 169.68,179.26 169.68,174.1 169.88,173.91 169.88,169.7 176.13,163.45 v1(177.02,163.45)
  BOTTOM w0.076: U28.G2 v1(171.94,180.7)
  BOTTOM w0.102: U34.Y22 177.02,163.53 v1(177.02,163.45)
VMA_DQ47: length 25.7
  TOP w0.114: U2.H7 v1(173.54,180.7)
  IN2 w0.102: v1(173.54,180.7) 173.16,180.32 172.43,180.32 172.4,180.29 171.75,180.29 171.49,180.03 171.49,179.69 171.32,179.52 170.88,179.52 170.86,179.5
  IN2 w0.165: 170.86,179.5 170.5,179.5 170.05,179.05 170.05,174.34 170.42,173.97 170.78,173.97 170.95,173.81 170.95,173.52 170.78,173.36 170.41,173.36 170.25,173.19 170.25,169.9 172.14,168.01 173.44,168.01 173.69,167.76 173.69,167.51 173.29,167.11 173.29,166.87 173.52,166.64 173.75,166.64 174.08,166.96 174.44,166.96 175.37,166.04 175.37,165.76 175.98,165.15 v1(176.14,165.15)
  BOTTOM w0.102: U2.H7 v1(173.54,180.7) ; U34.AA23 176.53,164.75 v1(176.14,165.15)
VMA_DQ48: length 17.2
  TOP w0.102: v1(171.93,175.89) 171.93,175.89 U2.B8
  IN1 w0.102: 170.8,175.48 171.3,175.48 171.71,175.89 v1(171.93,175.89)
  IN1 w0.165: v1(172.73,169.59) 172.4,169.26 170.63,169.26 169.15,170.74 169.15,175.85 169.32,176.01 169.69,176.01 169.86,175.85 169.86,175.02 170.02,174.86 170.29,174.86 170.45,175.02 170.45,175.34 170.6,175.48 170.8,175.48
  BOTTOM w0.076: U28.A2 172.33,175.5 v1(171.93,175.89)
  BOTTOM w0.127: v1(172.73,169.59) 173.09,169.24 173.09,169.2 174.03,168.25 U34.AD27
VMA_DQ49: length 20.9
  TOP w0.114: U2.A7 v1(173.54,175.1)
  IN1 w0.165: v1(173.54,175.1) 172.59,174.15 170.23,174.15 170.07,173.99 170.07,173.66 170.24,173.48 170.62,173.48 170.8,173.3 170.8,172.97 170.62,172.79 170.24,172.79 170.07,172.61 170.07,172.26 170.24,172.08 170.7,172.08 170.88,171.9 170.88,171.57 170.7,171.4 170.24,171.4 170.07,171.22 170.07,170.95 170.49,170.53 170.68,170.53 171.03,170.89 171.36,170.89 171.54,170.71 171.54,170.25 171.72,170.07 172.01,170.07 172.2,170.27 172.2,170.79 172.38,170.96 v1(172.73,170.96)
  BOTTOM w0.102: U2.A7 v1(173.54,175.1)
  BOTTOM w0.127: U34.AB25 175.31,166.75 175.31,167.25 175.09,167.47 175.09,168.8 174.81,169.08 174.08,169.08 173.55,169.62 173.55,170.14 v1(172.73,170.96)
VMA_DQ50: length 18.8
  TOP w0.114: U2.C8 v1(172.74,176.7)
  IN1 w0.102: 170.59,176.3 172.35,176.3 v1(172.74,176.7)
  IN1 w0.165: 170.59,176.3 170.41,176.48 170.41,176.88 170.21,177.08 169.79,177.08 168.74,176.03 168.74,170.55 170.42,168.88 v1(172.76,168.88)
  BOTTOM w0.102: U2.C8 v1(172.74,176.7)
  BOTTOM w0.127: U34.AD26 173.75,167.41 173.75,167.43 173.65,167.52 173.65,168.1 172.88,168.88 v1(172.76,168.88)
VMA_DQ51: length 20.1
  TOP w0.102: U2.D7 173.13,177.9 v1(172.73,177.5)
  IN1 w0.165: v1(172.73,170.28) 172.1,169.64 170.85,169.64 169.63,170.86 169.63,174.1 170.06,174.52 172.35,174.52 172.82,174.99 172.82,175.83 173.53,176.54 173.53,177.27 173.31,177.5 v1(172.73,177.5)
  BOTTOM w0.102: U28.C3 173.13,177.1 v1(172.73,177.5)
  BOTTOM w0.127: v1(172.73,170.28) 173.32,169.69 173.32,169.3 174.43,168.18 174.43,166.95 174.88,166.5 U34.AC25
VMA_DQ52: length 19.2
  TOP w0.102: 176.34,177.13 v1(176.72,177.51)
  TOP w0.114: U2.C3 176.34,177.13
  IN1 w0.165: v1(176.47,168.83) 177.03,168.27 177.03,167.61 176.51,167.09 173.77,167.09 173.52,167.34 173.52,168.15 174.43,169.06 174.75,169.06 174.92,169.22 174.92,170.28 175.48,170.84 175.48,172.44 175.29,172.63 175.29,174.68 176.06,175.46 176.06,176.93 176.64,177.51 v1(176.72,177.51)
  BOTTOM w0.102: v1(176.72,177.51) 176.34,177.89 U28.D7
  BOTTOM w0.127: U34.AA27 176.53,168.76 v1(176.47,168.83)
VMA_DQ53: length 19.6
  TOP w0.114: U2.A3 176.34,175.5 v1(176.74,175.1)
  IN1 w0.165: v1(176.74,175.1) 176.28,175.1 175.84,174.66 175.84,173.13 176.14,172.83 176.14,172.56 175.84,172.27 175.84,171.27 176.13,170.98 176.13,170.45 175.29,169.6 175.29,168.25 175.12,168.09 174.05,168.09 173.89,167.92 173.89,167.63 174.05,167.46 176.36,167.46 176.56,167.67 176.56,167.97 176.4,168.13 176.06,168.13 175.9,168.3 175.9,169.35 176.06,169.52 v1(176.54,169.52)
  BOTTOM w0.102: U2.A3 176.34,175.5 v1(176.74,175.1)
  BOTTOM w0.127: U34.AA26 176.53,167.34 176.92,167.73 176.92,169.14 v1(176.54,169.52)
VMA_DQ54: length 21.5
  TOP w0.114: U2.C2 177.14,177.1 v1(176.74,176.7)
  IN1 w0.102: 177.17,174.82 177.17,175.41 177.13,175.45 177.13,176.47 176.9,176.7 v1(176.74,176.7)
  IN1 w0.165: v1(176.67,170.96) 176.92,170.71 177.48,170.71 177.65,170.88 177.65,171.38 177.48,171.54 176.43,171.54 176.27,171.71 176.27,172.06 176.43,172.22 177.48,172.22 177.64,172.39 177.64,172.74 177.48,172.9 176.66,172.9 176.29,173.28 176.29,174.32 176.46,174.49 176.82,174.49 176.99,174.32 176.99,174.03 177.15,173.87 178.02,173.87 178.19,174.03 178.19,174.15 178.27,174.23 178.27,174.45 178.11,174.61 177.3,174.61 177.17,174.73 177.17,174.82
  BOTTOM w0.102: U2.C2 177.14,177.1 v1(176.74,176.7)
  BOTTOM w0.127: U34.W26 178.19,167.15 177.97,167.15 177.51,167.61 177.51,170.2 177.71,170.4 177.98,170.4 178.14,170.57 178.14,170.8 177.98,170.96 v1(176.67,170.96)
VMA_DQ55: length 21.6
  TOP w0.102: U2.A2 177.15,175.5 v1(177.55,175.9)
  IN1 w0.165: v1(176.59,170.25) 177.12,170.25 177.32,170.05 177.32,169.23 177.49,169.07 177.85,169.07 178.01,169.23 178.01,172.54 178.58,173.11 178.58,173.98 179.16,174.56 179.16,176.01 178.94,176.24 178.94,176.47 179.22,176.76 179.46,176.76 179.64,176.58 179.87,176.58 180.08,176.79 180.08,177.54 179.82,177.8 179.45,177.8 177.55,175.9 v1(177.55,175.9)
  BOTTOM w0.102: v1(177.55,175.9) 177.54,175.9 U28.B8
  BOTTOM w0.127: U34.Y25 177.37,166.35 176.95,166.77 176.95,167.36 177.15,167.56 177.15,169.95 176.85,170.25 v1(176.59,170.25)
VMA_DQ56: length 22.7
  TOP w0.114: U3.A2 v1(189.41,175.9)
  IN1 w0.165: v1(182.64,168.8) 183.44,168 189.12,168 190.98,169.87 190.98,170.79 191.37,171.17 191.71,171.17 191.87,171.34 191.87,171.67 191.71,171.83 191.08,171.83 190.91,172 190.91,172.33 191.08,172.5 191.94,172.5 192.11,172.66 192.11,172.99 191.94,173.16 191.15,173.16 190.93,173.37 190.93,174.38 v1(189.41,175.9)
  BOTTOM w0.102: U29.B8 v1(189.41,175.9)
  BOTTOM w0.127: v1(182.64,168.8) 182.64,168.73 181.91,168 181.91,167.54 U34.R26

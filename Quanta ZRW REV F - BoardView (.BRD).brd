# Allegro board Quanta ZRW REV F - BoardView (.BRD).brd (continued)
## Copper pours and planes (outline as drawn) (continued)
GND on TOP (solid shape): 133.57,124.68 133.57,117.29 133.84,117.02 133.84,116.66 133.74,116.57 133.25,116.57 133,116.82 133,117.83 132.67,118.16 131.25,118.16 131.24,118.14 130.81,118.14 130.77,118.11 130.77,117.85 130.62,117.7 130.6,117.7 129.87,117.7 129.87,117.7 128.05,117.7 127.34,118.41 127.34,118.82 127.47,118.94 130.49,118.94 130.7,119.15 130.7,120.82 131.28,121.41 131.28,122.55 131.11,122.72 131.11,123.35 131.33,123.57 131.74,123.57 131.89,123.72 131.89,124.15 132.47,124.74 133.52,124.74
GND on TOP (solid shape): 186.83,153.49 186.83,151.68 186.52,151.38 186.52,150.77 186.93,150.37 186.96,150.38 187.06,150.28 187.06,150.26 187.11,149.98 187.31,149.77 187.31,144.62 187.59,144.34 187.59,143.76 187.49,143.66 187.08,143.66 187.05,143.63 186.07,143.63 185.79,143.91 185.79,144.85 186.27,145.33 186.27,149.55 185.61,150.21 185.61,152.8 186.4,153.59 186.73,153.59
GND on TOP (solid shape): 38.32,96.52 38.32,92.45 36.92,91.05 36.66,91.05 36.54,91.18 36.54,91.44 36.92,91.82 36.92,92.58 36.66,92.83 36.54,92.83 36.28,93.09 36.28,93.72 36.41,93.85 37.55,93.85 37.81,94.1 37.81,95.75 37.68,95.88 36.03,95.88 35.65,95.5 35.65,94.99 35.01,94.36 34.12,94.36 33.74,93.98 33.74,92.71 34.11,92.34 34.37,92.34 34.51,92.2 34.51,91.69 34.63,91.56 35.14,91.56 35.27,91.44 35.27,91.31 35.14,91.18 34.38,91.18 34.18,91.38 34.18,91.41 33.11,92.47 33.11,96.26 33.62,96.77 38.06,96.77
GND on TOP (solid shape): 13.1,22.9 13.03,22.22 12.81,21.58 12.53,21.58 12.41,21.46 0.51,21.46 0.51,22.39 9.09,22.39 10.28,21.87 11.07,22.9 11.07,24 13.1,24
GND on TOP (solid shape): 10.24,76.83 10.25,76.83 10.49,76.16 10.57,75.45 10.57,73.76 8.54,73.76 8.54,75.45 7.75,76.47 6.56,75.96 0.9,75.96 0.9,77.98 1.7,77.98 1.7,79.18 7.9,79.18
GND on TOP (solid shape): 228.09,46.6 228.09,45.95 228.16,45.31 228.74,45.04 229.31,45.04 229.39,44.95 229.39,38.56 229.32,38.46 229.21,38.49 228.64,38.73 228.12,38.4 227.51,38.4 227.36,38.55 227.36,46.68 228.01,46.68
GND on TOP (solid shape): 5.7,106.8 5.7,103.93 4.03,102.26 4.03,101.61 2.75,99.4 4.03,97.19 4.03,96.43 7.75,96.43 8.29,95.88 8.29,94.34 1.7,94.34 1.7,95.59 0.9,95.59 0.9,102.04 2.3,102.04 2.3,104.29 3.1,104.29 4,104.85 3.9,105.9 3.9,107.94 4.04,108.07 4.43,108.07
GND on TOP (solid shape): outline of 81 points within 137.4,115.11 141.95,131.26
GND on TOP (solid shape): 13.1,40.9 12.87,39.71 12.18,38.7 12.87,37.69 13.1,36.5 13.1,35.35 11.07,35.35 11.07,36.5 10.28,37.52 9.09,37.01 0.9,37.01 0.9,40.39 9.09,40.39 10.28,39.87 11.07,40.9 11.07,42.03 13.1,42.03
GND on TOP (solid shape): outline of 108 points within 60.57,43.22 73.13,50.93
GND on TOP (solid shape): 10.57,59.82 10.17,58.5 9.23,57.49 11.9,56.95 13.1,54.5 13.1,53.03 11.07,53.03 11.07,54.5 10.28,55.52 9.09,55.01 0.9,55.01 0.9,59.44 6.62,59.44 7.75,59.02 8.54,59.91 8.54,61.68 10.57,61.68
GND on TOP (solid shape): outline of 160 points within 176.36,191.26 183.92,193.08
GND on TOP (solid shape): outline of 174 points within 178.27,156.28 188.25,163.09
GND on TOP (solid shape): outline of 107 points within 165.87,156.54 178.22,178.53
GND on TOP (solid shape): outline of 235 points within 177.66,140.92 188.05,157.15
GND on TOP (solid shape): outline of 393 points within 189.01,156.38 192.85,159.79
GND on TOP (solid shape): outline of 574 points within 166.92,145.89 173.7,164.09
GND on TOP (solid shape): outline of 177 points within 2.76,0.51 229.39,32.29
GND on TOP (solid shape): outline of 1389 points within 2.3,58.75 234.1,203.87
GND on BOTTOM (solid shape): 160.87,90.55 159.09,90.55 158.84,90.8 158.84,93.98 160.87,93.98
GND on BOTTOM (solid shape): 30.85,98.07 30.85,96.01 30.49,95.65 26.56,95.65 26.35,95.86 26.35,98.42 26.56,98.62 30.29,98.62
GND on BOTTOM (solid shape): 38.32,96.52 38.32,93.47 37.55,92.71 34,92.71 33.11,93.59 33.11,96.26 33.62,96.77 38.06,96.77
GND on BOTTOM (solid shape): 58.33,60.67 58.33,55.56 57.27,54.5 56.18,54.5 55.1,55.58 55.1,60.21 55.79,60.91 58.09,60.91
GND on BOTTOM (solid shape): 61.96,40.07 61.96,39.5 60,37.54 57.44,37.54 57.32,37.66 57.32,41.86 57.41,41.95 60.08,41.95
GND on BOTTOM (solid shape): 71.93,41.09 71.93,39.61 71.63,39.32 69.65,39.32 69.52,39.44 69.52,40.98 69.76,41.22 71.79,41.22
GND on BOTTOM (solid shape): 72.42,23.31 72.42,22.31 72.18,22.08 68.49,22.08 68.24,22.33 68.24,23.43 68.48,23.67 72.06,23.67
GND on BOTTOM (solid shape): 138.77,183.38 138.77,179.95 138.52,179.7 130.64,179.7 130.01,180.34 130.01,183.38 130.39,183.76 138.39,183.76
GND on BOTTOM (solid shape): 167.35,78.27 167.35,74.42 167.22,74.29 162.52,74.29 162.14,74.67 162.14,78.1 162.48,78.44 167.17,78.44
GND on BOTTOM (solid shape): 178.78,41.78 178.78,38.86 178.52,38.6 175.22,38.6 174.84,38.98 174.84,42.03 175.09,42.29 178.27,42.29
GND on BOTTOM (solid shape): 204.08,152.57 204.08,151.53 203.62,151.08 199.68,151.08 198.74,152.01 198.74,152.6 198.77,152.62 204.03,152.62
GND on BOTTOM (solid shape): 210.45,127.86 210.45,126.74 210.4,126.69 208.42,126.69 208.17,126.95 208.17,127.81 208.37,128.01 210.3,128.01
GND on BOTTOM (solid shape): 217.51,198.24 217.51,190.5 217.39,190.37 213.58,190.37 212.56,191.38 212.56,198.62 212.94,199 216.75,199
GND on BOTTOM (solid shape): 224.37,108.96 224.37,106.17 223.99,105.79 221.96,105.79 221.83,105.91 221.83,109.22 221.96,109.34 223.99,109.34
GND on BOTTOM (solid shape): 224.5,170.94 224.5,169.03 223.99,168.52 222.08,168.52 221.7,168.91 221.7,170.81 222.08,171.19 224.24,171.19
GND on BOTTOM (solid shape): 185.51,128.52 185.51,124.58 184.75,123.82 182.59,123.82 182.21,124.2 182.21,128.52 182.59,128.9 185.13,128.9
GND on BOTTOM (solid shape): 194.27,78.23 194.27,76.96 193.38,76.07 192.62,76.07 192.37,76.32 192.37,78.74 192.62,78.99 193.51,78.99
GND on BOTTOM (solid shape): 196.96,138.4 196.43,137.87 194.98,137.87 194.49,138.36 193.04,138.36 192.95,138.45 192.95,138.86 193.08,138.98 196.96,138.98
GND on BOTTOM (solid shape): 37.3,88.39 37.3,85.97 37.05,85.72 34.25,85.72 33.62,86.36 33.62,88.13 34.25,88.77 36.92,88.77
GND on BOTTOM (solid shape): 87.87,117.24 87.87,111.96 86.65,110.74 82.59,110.74 82.08,111.25 82.08,113.84 83.81,115.57 83.81,116.94 84.32,117.45 87.67,117.45
GND on BOTTOM (solid shape): 116,109 116.26,109 116.8,108.45 116.8,108.2 116.67,108.07 115.53,108.07 115.28,108.33 115.28,108.61 115.67,109 116,109
GND on BOTTOM (solid shape): 156.81,197.86 156.81,193.29 156.68,193.16 154.01,193.16 153.12,194.05 153.12,198.24 153.25,198.37 156.3,198.37
GND on BOTTOM (solid shape): 207.38,126.39 209.49,126.39 209.77,126.11 209.77,123.06 209.45,122.74 204.5,122.74 204.18,123.06 204.18,126.36 204.43,126.61 207.15,126.61
GND on BOTTOM (solid shape): 219.54,156.46 220.05,156.46 220.31,156.21 220.31,154.94 218.68,153.31 213.09,153.31 211.06,155.34 211.06,156.46 211.26,156.66 219.34,156.66
GND on BOTTOM (solid shape): 180.17,195.32 180.17,194.43 179.92,194.18 177.79,194.18 177,193.39 176.26,193.39 175.86,193.8 175.86,194.94 176.36,195.45 180.05,195.45
GND on BOTTOM (solid shape): 211.52,136.9 211.52,135.33 210.05,133.85 210.05,131.62 209.64,131.21 208.37,131.21 208.17,131.42 208.17,136.65 208.72,137.21 211.21,137.21
GND on BOTTOM (solid shape): 221.7,126.74 221.7,125.6 221.58,125.47 220.05,125.47 219.7,125.83 218.22,125.83 217.92,126.13 217.92,127.1 218.12,127.3 221.15,127.3
GND on BOTTOM (solid shape): 24.32,110.61 24.32,106.27 24.24,106.19 20.76,106.19 20.13,105.56 19.67,105.56 19.57,105.66 19.57,110.59 20.54,111.55 23.38,111.55
GND on BOTTOM (solid shape): 152.11,183.64 152.11,182.11 151.73,181.73 151.73,179.83 151.6,179.7 150.84,179.7 150.71,179.57 148.3,179.57 147.66,180.21 147.66,183.51 148.17,184.02 151.73,184.02
GND on BOTTOM (solid shape): 208.42,156.38 208.42,155.93 207.58,155.09 198.97,155.09 198.29,155.77 198.29,156.49 198.41,156.61 203.31,156.61 203.54,156.38 205.22,156.38 205.47,156.64 208.17,156.64
GND on BOTTOM (solid shape): 215.1,28.22 215.1,26.25 214.87,26.02 212.79,26.02 212.59,26.22 212.59,28.1 212.59,28.1 212.59,28.23 212.76,28.4 214.92,28.4
GND on BOTTOM (solid shape): 84.49,46.05 84.49,42.87 84.11,42.49 80.64,42.49 80.34,42.79 80.34,46 80.68,46.34 84.2,46.34
GND on BOTTOM (solid shape): 102.93,78.13 102.93,75.03 102.07,74.16 97.37,74.16 96.23,73.02 94.96,73.02 94.7,73.27 94.7,74.16 95.08,74.54 95.08,76.78 96.91,78.61 102.45,78.61
GND on BOTTOM (solid shape): 120.61,153.54 120.61,149.22 120.23,148.84 120.23,145.39 119.98,145.13 118.76,145.13 118.5,144.88 118.3,144.88 118.02,145.15 118.02,149.71 118.16,149.84 118.16,152.52 119.31,153.67 120.48,153.67
GND on BOTTOM (solid shape): 123.29,162.92 123.41,162.92 123.79,162.54 123.79,160.78 123.77,160.77 123.77,160.69 123.48,160.4 120.36,160.4 120.1,160.65 120.1,162.81 120.23,162.94 123.28,162.94
GND on BOTTOM (solid shape): 198.42,198.67 198.42,197.87 198.24,197.69 198.24,196.2 198.06,196.03 194.23,196.03 194.2,196.04 194.18,196.08 194.18,198.68 194.6,199.1 197.98,199.1
GND on BOTTOM (solid shape): 182.56,72.28 182.56,72 181.29,70.73 181.29,70.48 180.53,69.72 179.97,69.72 179.82,69.57 179.82,68.8 179.79,68.78 179.69,68.78 179.64,68.83 179.64,69.68 180.37,70.4 180.37,72.63 180.51,72.77 182.08,72.77
GND on BOTTOM (solid shape): 192.37,64.4 192.37,63.11 192.2,62.94 189.55,62.94 187.69,61.08 187.69,58.8 187.55,58.66 186.03,58.66 185.64,59.05 185.64,61.57 187.35,63.28 188.14,63.28 188.46,63.6 188.46,64.26 188.76,64.57 192.2,64.57
GND on BOTTOM (solid shape): 199.61,134.36 199.61,133.85 199.35,133.6 197.07,133.6 196.56,133.09 187.79,133.09 187.67,133.22 187.67,134.23 187.79,134.36 194.14,134.36 194.27,134.49 197.57,134.49 197.95,134.87 199.1,134.87
GND on BOTTOM (solid shape): 227.67,110.36 227.67,105.66 226.53,104.52 226.53,102.61 226.28,102.36 224.12,102.36 223.74,102.74 223.74,104.77 224.75,105.79 224.75,107.56 226.15,108.96 226.53,108.96 226.78,109.22 226.78,110.23 227.04,110.49 227.55,110.49
GND on BOTTOM (solid shape): 213.27,22.12 213.27,21.51 213.72,21.06 213.72,19.71 213.53,19.51 213.07,19.51 212.32,18.76 211.6,18.76 211.34,19.02 211.34,22.14 211.54,22.34 213.05,22.34
GND on BOTTOM (solid shape): 196.49,115.91 196.49,114.38 196.73,114.14 198.56,114.14 198.75,114.33 198.75,115.34 202.52,115.34 202.95,114.92 202.95,110.73 202.7,110.47 191.08,110.47 190.18,111.37 190.18,114.84 190.41,115.08 191.9,115.08 192.11,115.29 192.11,116.1 192.29,116.27 196.13,116.27
GND on BOTTOM (solid shape): 109.44,129.54 109.44,128.65 109.56,128.52 110.96,128.52 111.21,128.27 111.21,127.22 111.57,126.87 112.48,126.87 112.61,126.74 112.61,125.85 112.48,125.73 108.42,125.73 108.17,125.98 108.17,127.12 108.55,127.5 108.55,129.54 108.8,129.79 109.18,129.79
GND on BOTTOM (solid shape): 215.03,118.42 215.03,117.23 215.19,117.07 215.19,117.07 215.4,116.85 215.4,113.27 216.14,112.53 216.14,109.32 215.76,108.94 213.6,108.94 213.07,109.47 213.07,116.58 213.98,117.49 213.98,117.96 214.44,118.42 215.02,118.42
GND on BOTTOM (solid shape): 165.96,46.25 165.96,45.94 167.65,44.25 167.65,36.88 167.68,36.85 167.64,36.78 162.9,36.78 162.67,37 162.67,42.72 162.99,43.04 164.63,43.04 164.93,43.35 164.93,45.72 165.62,46.4 165.81,46.4
GND on BOTTOM (solid shape): 211.02,184.59 211.02,181.95 210.3,181.22 209.64,181.22 209.51,181.1 209.35,181 209.26,180.84 209,180.59 209,179.95 208.75,179.7 207.99,179.7 207.73,179.95 207.73,185.19 208.04,185.49 210.12,185.49
GND on BOTTOM (solid shape): 219.71,133.28 219.38,131.49 219.65,129.69 219.54,129.59 218.73,129.59 217.97,130.35 217.97,134.11 218.12,134.26 218.73,134.26
GND on BOTTOM (solid shape): 184.92,61.67 184.92,59.27 184.78,59.13 183.97,59.13 183.55,58.71 182.28,58.71 182.19,58.62 182.19,58.62 182.08,58.51 182.09,58.51 182.09,57.9 182.07,57.86 182.04,57.84 179.35,57.84 179,58.19 179,58.87 178.64,59.24 178.64,60 178.96,60.33 178.96,61.75 179.19,61.98 184.61,61.98
GND on BOTTOM (solid shape): 56.34,85.15 56.34,84.14 56.69,83.79 57.66,83.79 57.82,83.63 57.82,83.35 57.81,83.32 57.77,83.3 56.32,83.3 56.03,83.01 54.82,83.01 54.7,83.14 53.28,83.14 52.97,83.44 52.97,84.39 53.16,84.58 53.16,85.63 53.17,85.64 53.17,85.71 53.19,85.75 53.23,85.76 55.73,85.76
GND on BOTTOM (solid shape): 219.1,18.8 219.1,16.92 218,15.82 218,15.2 217.82,15.03 215.72,15.03 215.56,15.2 215.56,16.1 216.87,16.1 216.87,16.3 215.56,16.3 215.56,16.6 216.88,16.6 216.88,16.8 215.56,16.8 215.56,17.08 215.57,17.1 216.96,17.1 217.08,17.22 217.08,18.15 216.93,18.3 215.57,18.3 215.57,18.52 215.58,18.52 215.58,18.6 216.96,18.6 217.46,19.1 218.8,19.1
GND on BOTTOM (solid shape): 151.86,164.21 151.86,158.92 151.87,158.92 151.87,158.49 151.44,158.07 148.63,158.07 148.3,158.4 148.3,162.84 147.73,163.4 144.56,163.4 144.56,162.97 144.54,162.94 144.51,162.92 144.03,162.92 144.03,162.92 144.03,164.02 144.04,164.03 145.55,164.03 145.55,164.03 145.55,165.22 145.57,165.26 145.61,165.27 150.8,165.27
GND on BOTTOM (solid shape): 81.01,124.1 81.01,121.2 80.91,121.1 77.61,121.1 77.36,120.85 77.36,120.19 76.85,119.68 74,119.68 73.85,119.83 73.85,122.22 74.06,122.43 75.57,122.75 76.99,123.37 78.37,124.16 79.74,124.96 80.15,124.96
GND on BOTTOM (solid shape): 161.91,165.07 161.91,162.41 161.23,161.72 160.21,161.72 158.53,163.4 155.35,163.4 155.35,163.4 155.35,162.98 155.34,162.94 155.3,162.92 154.88,162.92 154.84,162.94 154.83,162.98 154.83,164.02 154.83,164.03 156.35,164.03 156.35,165.22 156.37,165.26 156.4,165.27 161.71,165.27
GND on BOTTOM (solid shape): 141.69,151.89 141.69,148.71 139.92,146.93 139.92,145.66 136.87,142.62 136.87,134.11 136.74,133.98 136.65,133.98 136.16,134.47 135.51,135.12 133.72,135.12 133.59,135.25 133.59,135.66 134.85,136.91 135.97,136.91 136.23,137.17 136.23,138.3 135.85,138.68 135.6,138.68 134.96,139.31 133.31,139.31 133.18,139.44 133.18,140.71 130.68,143.21 130.7,143.23 130.7,143.7 130.37,144.03 129.9,144.03 129.63,143.76 127.85,143.76 127.72,143.89 127.72,148.59 128.36,149.22 133.44,149.22 135.09,150.87 139.53,150.87 140.68,152.01 141.57,152.01
GND on BOTTOM (solid shape): 183.38,138.96 189.24,138.96 189.34,138.86 189.34,137.94 189.17,137.77 188.68,137.77 188.61,137.84 188.61,138.27 188.46,138.43 188.33,138.43 188.26,138.44 188.2,138.44 188.08,138.45 187.96,138.43 187.41,138.43 187.27,138.44 187.14,138.39 187.03,138.31 186.96,138.18 186.96,138.17 186.58,137.79 182.31,137.79 181.9,138.2 181.9,138.93 182.05,139.09 183.25,139.09
GND on BOTTOM (solid shape): 75.08,53.5 75.08,50.99 74.63,50.53 73.66,50.53 73.06,49.93 71.22,49.93 70.95,49.65 70.95,49.2 71.31,48.84 71.96,48.84 71.97,48.85 72.77,48.85 73.05,48.57 73.05,45.86 72.67,45.49 70.56,45.49 70.19,45.87 68.86,45.87 67.66,47.07 65,47.07 64.87,46.94 64.87,46.33 64.72,46.19 62.76,46.19 62.16,45.59 61.69,45.59 61.42,45.85 61.42,46.72 60,48.14 60,50.15 60.74,50.89 63.96,50.89 65.52,49.33 69.05,49.33 71.29,51.56 71.95,51.56 72.48,52.09 72.48,52.33 73.86,53.71 74.88,53.71
GND on BOTTOM (solid shape): 13.1,22.9 13,22.1 12.69,21.35 0.51,21.35 0.51,22.39 9.09,22.39 10.28,21.87 11.07,22.9 11.07,24.79 13.1,24.79
GND on BOTTOM (solid shape): 99.15,134.36 99.15,129.54 99.66,129.03 103.97,129.03 104.61,129.66 104.61,131.06 104.74,131.19 105.37,131.19 105.5,131.06 105.5,127.5 106.01,127 106.01,123.31 106.39,122.93 106.39,117.85 106.64,117.6 107.66,117.6 107.91,117.85 107.91,118.99 108.8,119.88 113.12,119.88 113.25,119.76 113.25,119.25 113.12,119.12 111.98,119.12 111.85,118.99 111.85,118.61 110.83,117.6 109.44,117.6 107.91,116.07 105.12,116.07 104.61,116.58 104.61,122.68 104.36,122.93 102.2,122.93 101.18,121.92 99.15,121.92 98.54,121.31 96.56,121.31 96.46,121.41 96.46,127.45 96.1,127.81 96.1,132.2 98.39,134.49 99.02,134.49
GND on BOTTOM (solid shape): 133.92,114.23 133.96,114.23 134.02,114.2 134.04,114.2 134.12,114.18 134.18,114.12 134.18,113.79 134.05,113.66 133.84,113.66 133.66,113.49 133.47,113.49 133.18,113.2 133.02,113.2 132.92,113.31 132.92,113.57 133.01,113.76 132.96,113.97 132.96,114.12 133.03,114.19 133.33,114.19 133.62,114.06 133.89,114.21
GND on BOTTOM (solid shape): 10.24,76.83 10.25,76.83 10.49,76.16 10.57,75.45 10.57,73.76 8.54,73.76 8.54,75.45 7.75,76.47 6.56,75.96 0.9,75.96 0.9,77.98 1.7,77.98 1.7,79.18 7.9,79.18
GND on BOTTOM (solid shape): 131.38,166.16 132.12,166.16 132.93,165.35 132.93,164.32 133.1,164.16 134.64,164.16 134.64,165.34 134.65,165.38 134.69,165.4 140.5,165.4 140.64,165.25 140.64,165.21 141.33,164.52 141.33,161.91 141.1,161.68 138.65,161.68 136.8,163.53 133.63,163.53 133.63,163.53 133.63,163.06 133.41,162.84 133.41,160.59 132.94,160.11 130.27,160.11 129.56,160.82 129.56,162.79 129.29,163.06 129.28,163.07 127.55,164.8 124.37,164.8 124.36,164.79 124.36,164.32 124.36,164.32 123.89,164.32 123.86,164.33 123.84,164.37 123.84,165.42 123.84,165.42 125.36,165.42 125.36,166.62 125.38,166.65 125.41,166.67 130.88,166.67
GND on BOTTOM (solid shape): 158.97,151.76 158.97,148.14 158.92,148.06 158.83,148.05 158.34,147.7 158.83,147.35 158.92,147.33 158.97,147.25 158.97,146.17 158.2,145.41 147.27,145.41 144.59,142.73 144.59,140.74 143.6,139.75 143.6,135.77 143.6,135.76 143.6,133.98 143.47,133.85 142.2,133.85 142.07,133.98 142.07,135.76 142.2,135.89 142.2,139.44 142.84,140.08 142.84,143.89 143.34,144.39 143.34,145.54 145.57,147.76 148.36,147.76 148.55,147.95 148.55,150.36 148.93,150.74 152.11,150.74 152.49,150.36 152.49,147.57 153.12,146.93 157.57,146.93 157.95,147.32 157.95,151.76 158.08,151.89 158.84,151.89
GND on BOTTOM (solid shape): 5.7,106.83 5.7,103.88 4.03,102.21 4.03,102 4.03,102 4.03,101.61 4,101.59 2.75,99.38 4.03,97.19 4.03,96.43 7.75,96.43 8.29,95.88 8.29,94.34 1.7,94.34 1.7,95.59 0.9,95.59 0.9,102.04 2.3,102.04 2.3,104.29 3.1,104.29 4,104.85 3.9,105.9 3.9,107.9 4.63,107.9
GND on BOTTOM (solid shape): 13.1,40.9 12.87,39.71 12.18,38.7 12.87,37.69 13.1,36.5 13.1,35.35 11.07,35.35 11.07,36.5 10.28,37.52 9.09,37.01 0.9,37.01 0.9,40.39 9.09,40.39 10.28,39.87 11.07,40.9 11.07,42.07 13.1,42.07
GND on BOTTOM (solid shape): 10.57,59.82 10.17,58.5 9.23,57.49 10.73,57.51 12.07,56.81 12.48,55.9 13.05,55.08 13.09,54.79 13.1,54.5 13.1,53.33 11.07,53.33 11.07,54.5 10.28,55.52 9.09,55.01 0.9,55.01 0.9,59.44 6.62,59.44 7.75,59.02 8.54,59.91 8.54,61.68 10.57,61.68
GND on BOTTOM (solid shape): outline of 167 points within 176.34,191.31 199.99,194.03
GND on BOTTOM (solid shape): outline of 265 points within 170.75,154.56 174.26,157.38
GND on BOTTOM (solid shape): outline of 274 points within 176.97,151.89 187.79,162.35
GND on BOTTOM (solid shape): outline of 2488 points within 2.3,0.51 234.1,203.87
GND on SVCC (solid shape): 159.91,183.78 159.91,181.25 159.14,180.76 158.54,180.08 152.62,180.08 152.62,183.94 152.72,184.04 159.64,184.04
GND on SVCC (solid shape): 191.12,193.8 195.94,193.8 199.37,190.37 201.91,190.37 202.53,189.76 202.53,187.6 204.33,185.8 209.41,185.8 210.91,184.29 210.91,181.63 215.38,177.16 215.88,177.16 218.66,174.39 218.66,168.93 219.42,168.17 219.42,166.73 218.91,166.22 218.91,161.82 219.29,161.43 219.29,159.11 215.99,155.8 215.99,155.04 211.69,150.74 197.93,150.74 192.11,156.57 192.11,158.34 190.46,159.99 190.46,161.65 190.33,161.77 190.33,163.37 189.5,164.21 186.47,164.21 186.14,163.88 171.54,163.88 171.54,163.93 168.49,166.98 168.49,176.04 169.74,177.29 171.11,177.29 171.79,177.97 171.79,180.31 171.41,180.7 171.41,183.02 171.92,183.53 171.92,189.37 172.43,189.88 172.43,190.88 172.55,190.88 172.55,192.95 174.84,195.24 174.84,195.45 189.47,195.45
GND on SVCC (solid shape): outline of 202 points within 108.28,170.56 151.85,203.87
GND on SVCC (solid shape): outline of 378 points within 67.65,44.95 171.67,120.21
GND on SVCC (solid shape): outline of 1755 points within 0.51,0.51 234.1,134.89
GND on IN1 (solid shape): 160.87,90.55 158.84,90.55 158.84,93.79 160.87,93.79
GND on IN1 (solid shape): 38.44,96.26 38.44,93.98 37.55,93.09 37.55,92.71 34,92.71 34,93.09 33.11,93.98 33.11,96.01 33.74,96.64 38.06,96.64
GND on IN1 (solid shape): 13.1,22.9 13.03,22.25 12.83,21.63 12.79,21.59 0.51,21.59 0.51,22.39 9.09,22.39 10.28,21.87 11.07,22.9 11.07,24.79 13.1,24.79
GND on IN1 (solid shape): 13.1,40.9 12.87,39.71 12.18,38.7 12.87,37.69 13.1,36.5 13.1,35.35 11.07,35.35 11.07,36.5 10.28,37.52 9.09,37.01 0.9,37.01 0.9,40.39 9.09,40.39 10.28,39.87 11.07,40.9 11.07,42.03 13.1,42.03
GND on IN1 (solid shape): 5.63,106.38 5.6,104.14 4.03,102.52 4.03,101.61 2.75,99.4 4.03,97.19 4.03,96.43 7.75,96.43 8.29,95.88 8.29,94.34 1.7,94.34 1.7,95.59 0.9,95.59 0.9,102.04 2.3,102.04 2.3,104.29 3.1,104.29 4,104.85 3.9,105.9 3.9,107.8 5.63,107.8
GND on IN1 (solid shape): 10.57,59.82 10.17,58.5 9.23,57.49 11.9,56.95 13.1,54.5 13.1,53.03 11.07,53.03 11.07,54.5 10.28,55.52 9.09,55.01 0.9,55.01 0.9,59.44 6.62,59.44 7.75,59.02 8.54,59.91 8.54,61.68 10.57,61.68
GND on IN1 (solid shape): outline of 1834 points within 128.74,172.59 156.34,189.29
GND on IN1 (solid shape): outline of 2550 points within 2.3,0.51 234.1,203.87
GND on IN2 (solid shape): 160.87,90.55 159.22,90.55 158.97,90.8 158.97,94.23 160.87,94.23
GND on IN2 (solid shape): 38.32,96.26 38.32,93.59 37.43,92.71 34,92.71 33.24,93.47 33.24,94.48 33.62,94.86 33.62,96.39 33.87,96.64 37.93,96.64
GND on IN2 (solid shape): 132.46,139.7 132.5,139.68 132.51,139.65 132.51,137.12 132.3,136.9 130.59,136.9 130.3,137.19 129.46,137.19 128.99,137.66 128.99,139.65 129.01,139.68 129.04,139.7
GND on IN2 (solid shape): 13.1,22.9 13.03,22.21 12.8,21.56 0.51,21.56 0.51,22.39 9.09,22.39 10.28,21.87 11.07,22.9 11.07,24.79 13.1,24.79
GND on IN2 (solid shape): 13.1,40.9 12.87,39.71 12.18,38.7 12.87,37.69 13.1,36.5 13.1,35.35 11.07,35.35 11.07,36.5 10.28,37.52 9.09,37.01 0.9,37.01 0.9,40.39 9.09,40.39 10.28,39.87 11.07,40.9 11.07,42.03 13.1,42.03
GND on IN2 (solid shape): 5.63,106.38 5.6,104.14 4.03,102.52 4.03,101.61 2.75,99.4 4.03,97.19 4.03,96.43 7.75,96.43 8.29,95.88 8.29,94.34 1.7,94.34 1.7,95.59 0.9,95.59 0.9,102.04 2.3,102.04 2.3,104.29 3.1,104.29 4,104.85 3.9,105.9 3.9,107.8 5.63,107.8
GND on IN2 (solid shape): 10.57,59.82 10.17,58.5 9.23,57.49 11.9,56.95 13.1,54.5 13.1,53.03 11.07,53.03 11.07,54.5 10.28,55.52 9.09,55.01 0.9,55.01 0.9,59.44 6.62,59.44 7.75,59.02 8.54,59.91 8.54,61.68 10.57,61.68
GND on IN2 (solid shape): outline of 2492 points within 2.3,0.51 234.1,203.87
GND on SGND (solid shape): outline of 3393 points within 0.88,0.51 234.1,203.87
VCC_XD on TOP (solid shape): 57.14,26.06 57.14,25.58 57.15,25.58 57.15,24.59 56.84,24.59 56.84,25.69 56.07,26.46 56.4,26.79
VDD10 on TOP (solid shape): 34,91.31 34,91.05 33.87,90.93 32.73,90.93 32.09,91.56 32.09,92.32 32.22,92.45 32.85,92.45
VDD10 on TOP (solid shape): 40.98,95.96 40.98,94.1 40.78,93.9 39.38,93.9 39.28,94 39.28,95.81 39.78,96.31 40.63,96.31
VDD10 on TOP (solid shape): 34.3,85.64 33.59,84.93 33.03,84.93 32.96,85.01 32.96,85.51 33.26,85.82 34.3,85.82
VDD10 on TOP (solid shape): 39.43,87.63 39.43,87.32 39.31,87.19 39.1,87.19 38.68,87.62 37.51,87.62 37.51,87.82 39.24,87.82
VDD10 on BOTTOM (solid shape): outline of 160 points within 31.99,84.45 40.78,96.39
VIN on TOP (solid shape): 128.87,196.23 128.87,195.01 128.1,194.24 128.1,193.78 127.93,193.61 127.7,193.61 126.83,192.74 126.83,190.37 126.73,190.26 125.41,190.26 125.41,190.24 124.96,190.24 124.96,190.26 123.64,190.26 123.41,190.5 123.41,192.41 127.45,196.46 128.64,196.46
VIN on TOP (solid shape): 126.8,169.31 126.88,169.27 126.89,169.18 127.24,168.69 127.59,169.18 127.6,169.27 127.69,169.31 130.76,169.31 130.9,169.17 130.9,166.99 130.77,166.87 123.92,166.87 123.53,167.25 123.53,169.29 123.56,169.31
VIN on TOP (solid shape): 161.78,167.31 161.78,165.4 155.97,165.4 155.39,165.98 155.39,167.89 158.22,167.89 158.22,167.84 158.23,167.78 158.25,167.73 158.28,167.69 158.31,167.64 158.35,167.61 158.39,167.57 158.44,167.55 158.49,167.53 158.54,167.52 158.6,167.52 158.65,167.53 158.7,167.54 158.75,167.56 158.8,167.59 158.84,167.62 158.88,167.66 158.91,167.71 158.93,167.76 158.95,167.81 158.95,167.86 158.95,167.92 158.95,167.97 158.93,168.02 158.91,168.07 158.88,168.12 158.84,168.16 158.8,168.19 158.75,168.22 158.7,168.24 158.65,168.25 158.6,168.26 158.54,168.26 158.49,168.25 158.44,168.23 158.39,168.21 158.35,168.17 158.31,168.14 158.28,168.09 158.25,168.05 158.23,168 158.22,167.94 158.22,167.89 155.39,167.89 155.39,168.25 155.76,168.62 160.46,168.62
VIN on TOP (solid shape): 140.32,169.26 140.32,165.89 140.03,165.6 133.57,165.6 132.68,166.49 132.68,168.02 136.24,168.02 136.25,167.96 136.26,167.91 136.28,167.86 136.31,167.81 136.34,167.77 136.38,167.73 136.42,167.7 136.47,167.68 136.52,167.66 136.57,167.65 136.63,167.65 136.68,167.65 136.73,167.67 136.78,167.69 136.83,167.72 136.87,167.75 136.91,167.79 136.94,167.84 136.96,167.89 136.97,167.94 136.98,167.99 136.98,168.04 136.97,168.1 136.96,168.15 136.94,168.2 136.91,168.24 136.87,168.28 136.83,168.32 136.78,168.35 136.73,168.37 136.68,168.38 136.63,168.39 136.57,168.38 136.52,168.37 136.47,168.36 136.42,168.33 136.38,168.3 136.34,168.26 136.31,168.22 136.28,168.17 136.26,168.12 136.25,168.07 136.24,168.02 132.68,168.02 132.68,168.78 133.32,169.43 140.16,169.43
VIN on TOP (solid shape): 147.3,168.26 147.33,168.17 147.27,168.09 147.17,167.5 147.77,167.6 147.84,167.66 147.93,167.63 148.68,166.88 151.6,166.88 151.85,166.62 151.85,165.73 151.59,165.46 144.37,165.46 143.85,165.98 143.85,169.03 143.99,169.17 146.38,169.17
VIN on TOP (solid shape): 175.79,201.11 175.79,196.02 175.6,195.83 168.04,195.83 167.09,196.78 167.09,200.66 170.41,200.66 170.41,200.63 170.42,200.58 170.43,200.52 170.45,200.48 170.48,200.43 170.52,200.39 170.56,200.36 170.61,200.33 170.66,200.31 170.71,200.29 170.76,200.29 170.82,200.29 170.87,200.3 170.92,200.32 170.97,200.34 171.01,200.37 171.05,200.41 171.08,200.45 171.11,200.5 171.13,200.55 171.14,200.6 171.15,200.66 171.14,200.71 171.13,200.76 171.11,200.81 171.08,200.86 171.05,200.9 171.01,200.94 170.97,200.97 170.92,201 170.87,201.01 170.82,201.02 170.76,201.02 170.71,201.02 170.66,201.01 170.61,200.98 170.56,200.96 170.52,200.92 170.48,200.88 170.45,200.84 170.43,200.79 170.42,200.74 170.41,200.68 170.41,200.66 167.09,200.66 167.09,201.04 167.47,201.42 171.03,201.42 171.16,201.54 175.35,201.54
VIN on TOP (solid shape): outline of 397 points within 185.64,108.86 224.48,179.7
VIN on BOTTOM (solid shape): 225.26,176.78 225.26,171.83 224.88,171.45 221.7,171.45 221.32,171.83 221.32,174.72 220.51,175.54 220.51,176.83 220.99,177.32 224.72,177.32
VIN on BOTTOM (solid shape): 77.05,119.12 77.05,118.49 78.07,117.47 80.99,117.47 81.24,117.22 81.24,115.82 80.99,115.57 74.64,115.57 74,116.2 74,119.12 74.26,119.38 76.8,119.38
VIN on BOTTOM (solid shape): 198.84,202.05 198.84,200.77 198.47,200.4 198.47,199.5 198.28,199.31 192.77,199.31 192.59,199.49 192.59,202.29 192.6,202.33 192.64,202.34 198.55,202.34
VIN on BOTTOM (solid shape): 60.18,74.68 60.18,73.84 59.98,73.64 58.26,73.64 56.86,72.25 52.99,72.25 52.81,72.43 52.81,74.2 53.04,74.42 57.04,74.42 57.53,74.9 59.96,74.9
VIN on BOTTOM (solid shape): 75.35,56.59 77.73,56.59 77.82,56.58 77.91,56.59 80.18,56.59 81.45,55.32 81.45,51.83 81.47,51.81 81.47,48.03 81.1,47.66 76.64,47.66 76.09,48.21 76.09,50.24 75.29,51.04 75.29,53.58 75.29,53.59 74.96,53.92 72.13,53.92 71.73,54.32 71.73,55.27 71.92,55.46 71.92,56.2 72.68,56.97 74.97,56.97
VIN on BOTTOM (solid shape): 177.02,63.81 177.02,63.08 177.18,62.92 177.18,62.47 177.18,62.47 177.18,61.91 177.29,61.8 178.39,61.8 178.39,61.8 178.59,61.8 178.71,61.68 178.71,60.34 178.48,60.11 178.47,60.1 178.47,59.07 178.65,58.89 178.65,56.38 178.47,56.2 175.38,56.2 175.19,56.38 175.19,58.35 173.96,59.58 173.96,63.04 175.1,64.18 176.64,64.18
VIN on BOTTOM (solid shape): 152.41,170.61 152.41,169.01 152.39,168.99 152.39,167.53 151.86,167 151.86,165.9 151.44,165.47 144.82,165.47 144.78,165.49 144.77,165.53 144.77,165.97 144.77,165.97 144.08,165.97 144.04,165.99 144.03,166.02 144.03,166.17 144.04,166.21 144.08,166.22 144.59,166.22 144.59,166.23 144.77,166.23 144.78,166.24 144.78,166.94 144.79,166.95 147.74,166.95 148.21,167.42 148.21,169.05 148.36,169.2 148.36,170.65 148.39,170.68 152.34,170.68
VIN on BOTTOM (solid shape): 162.87,170.55 163.04,170.55 163.54,170.05 163.54,168.91 163.51,168.88 163.51,168.11 162.78,167.37 162.2,167.37 161.95,167.12 161.95,165.76 161.66,165.48 155.62,165.48 155.58,165.49 155.56,165.53 155.56,165.97 154.88,165.97 154.84,165.98 154.83,166.02 154.83,166.17 154.84,166.21 154.88,166.22 155.38,166.22 155.38,166.22 155.56,166.22 155.56,166.95 155.56,166.95 158.54,166.95 159.1,167.51 159.1,169.04 159.11,169.05 159.11,170.5 159.12,170.54 159.16,170.55 162.87,170.55
VIN on BOTTOM (solid shape): 189.76,120.7 189.76,115.26 190.02,114.99 190.02,111.3 191.04,110.28 202.89,110.28 203.15,110.55 203.15,115.84 203.56,116.25 203.56,118.44 203.97,118.85 208.7,118.85 209.12,118.43 209.12,116.15 209.7,115.57 211.92,115.57 212.18,115.31 212.18,109.09 212.64,108.63 216.16,108.63 216.55,109.01 216.55,112.47 215.56,113.46 215.56,116.86 215.52,116.9 215.52,118.41 215.54,118.42 215.8,118.42 216.24,117.98 216.24,117.85 218.02,116.07 218.02,115.18 218.55,114.66 218.55,114.23 218.86,113.91 219.53,113.91 220.56,114.94 224.15,114.94 224.94,114.15 224.94,110.95 223.96,109.97 221.6,109.97 221.19,109.55 221.19,104.22 220.97,104 211.55,104 209.77,105.79 209.77,107.41 208.34,108.84 208.05,108.84 208.05,108.84 188.34,108.84 188.24,108.94 188.25,108.98 188.25,109.18 188.15,109.36 188.11,109.44 188.13,109.52 188.14,109.9 187.81,110.09 187.76,110.09 187.71,110.08 187.1,110.08 185.36,111.82 185.3,111.9 185.22,111.96 185,112.18 185,115.81 184.21,116.6 184.21,120.95 184.39,121.14 189.32,121.14
VIN on BOTTOM (solid shape): 59.55,53.59 59.55,50.59 59.57,50.59 59.82,50.33 59.82,48.14 61.23,46.73 61.23,45.74 61.62,45.36 61.62,44.7 61.25,44.33 53.54,44.33 53,44.88 53,49.13 53.08,49.25 53.22,49.22 53.73,49.2 53.76,49.71 53.73,49.79 53.76,49.87 53.85,50.11 53.76,50.35 53.73,50.43 53.76,50.51 53.73,51.02 53.22,51 53.08,50.97 53,51.09 53,53.29 53,53.29 53,53.62 53.22,53.85 59.29,53.85
VIN on BOTTOM (solid shape): outline of 287 points within 119.98,165.6 140.45,192.78
VIN on SVCC (solid shape): outline of 605 points within 58.76,46.73 231.96,202.34
VIN on IN1 (solid shape): outline of 1225 points within 73.29,114.5 115.6,169.75
VIN on IN1 (solid shape): outline of 1739 points within 194.65,172.33 225.33,201.54
VIN on IN2 (solid shape): 148.04,166.57 148.04,165.53 147.78,165.27 147.35,165.27 147.35,165.28 147.23,165.29 147.12,165.28 147.11,165.27 146.11,165.27 146.1,165.28 145.98,165.29 145.87,165.28 145.86,165.27 143.88,165.27 143.66,165.49 143.66,169.2 143.92,169.46 145.15,169.46
VIN on IN2 (solid shape): outline of 118 points within 154.5,165.14 160.31,168.87
VIN on IN2 (solid shape): outline of 305 points within 124.54,165.48 140.64,169.44
VIN on IN2 (solid shape): outline of 297 points within 167.73,195.96 198.84,201.23
554LX_0.95V on BOTTOM (solid shape): 191.12,68.31 191.12,66.21 191.12,66.21 191.12,64.85 190.82,64.85 190.82,65.85 190.62,65.85 190.62,64.85 190.32,64.85 190.32,65.85 190.12,65.85 190.12,64.85 189.62,64.85 188.3,64.85 188.16,65 188.16,66.03 188.02,66.16 186.94,66.16 186.21,66.89 186.21,68.57 186.51,68.87 190.57,68.87
1658R-BOOT1 on TOP (solid shape): 200.47,104.23 201.24,104.23 201.24,104.02 200.25,104.02 200.09,104.19 198.28,104.19 198.24,104.22 198.24,104.92 198.34,105.01 199.68,105.01
1658R-BOOT2 on TOP (solid shape): 206.4,104.96 206.4,104.25 206.35,104.2 204.63,104.2 204.44,104.02 203.45,104.02 203.45,104.22 203.45,104.22 204.12,104.22 204.12,104.23 204.88,104.99 206.37,104.99
1658R-LGATE1 on TOP (solid shape): 202.05,106.18 202.05,105.42 202.05,105.42 202.05,104.43 201.85,104.43 201.85,105.53 201.68,105.7 200.93,105.7 200.72,105.91 200.72,106.19 200.89,106.36 201.42,106.36 201.43,106.37 201.85,106.37
1658R-LGATE1 on BOTTOM (solid shape): 191.6,116.79 191.6,116.27 191.61,116.27 191.61,115.41 191.47,115.28 190.09,115.28 189.94,115.43 189.94,116.84 190.06,116.96 191.44,116.96
1658R-LGATE2 on TOP (solid shape): 203.92,106.29 203.92,105.96 203.72,105.76 203.32,105.76 203.18,105.62 202.92,105.62 202.85,105.55 202.85,104.43 202.65,104.43 202.65,106.09 202.93,106.37 203.85,106.37
1658R-LGATE2 on BOTTOM (solid shape): 198.26,114.35 198.25,114.34 196.81,114.34 196.66,114.49 196.66,115.17 196.81,115.33 198.26,115.33
1658R-PHASE1 on TOP (solid shape): 200.76,105.42 201.64,105.42 201.65,105.42 201.65,104.43 200.66,104.43 199.61,105.48 199.49,105.48 199.48,105.48 198.32,105.48 198.3,105.5 198.3,106.18 198.37,106.24 199.95,106.24
1658R-PHASE1 on BOTTOM (solid shape): 196.1,124.02 196.1,117.67 195.67,117.24 190.45,117.24 190,117.69 190,121.99 190.16,122.15 190.16,122.17 190.31,122.31 190.31,122.78 189.8,123.3 188.25,123.3 188.25,123.24 188.07,123.06 188.07,122.14 188.03,122.1 184.76,122.1 184.68,122.19 184.68,123.41 187.38,126.1 194.02,126.1
1658R-PHASE2 on TOP (solid shape): 206.41,106.2 206.41,105.53 206.36,105.48 204.8,105.48 203.75,104.43 203.05,104.43 203.05,105.42 203.76,105.42 204.59,106.25 206.36,106.25
1658R-PHASE2 on BOTTOM (solid shape): 203.42,124.33 203.42,123.06 204.22,122.25 206.25,122.25 207.35,121.15 207.35,119.82 203.78,119.82 203.21,119.24 203.21,116.77 202.75,116.32 197.37,116.32 196.66,117.02 196.66,124.14 197.49,124.96 202.78,124.96
1658R-UGATE1 on TOP (solid shape): 200.22,103.82 201.24,103.82 201.24,103.62 199.86,103.62 199.56,103.32 199.25,103.32 199.06,103.5 199.06,103.81 199.25,104 200.05,104
1658R-UGATE1 on BOTTOM (solid shape): 190.13,122.76 190.13,122.43 189.8,122.1 188.68,122.1 188.57,122.21 188.57,122.96 188.7,123.1 189.8,123.1
1658R-UGATE2 on TOP (solid shape): 205.58,103.84 205.58,103.52 205.45,103.39 204.98,103.39 204.75,103.62 204.44,103.62 203.45,103.62 203.45,103.82 204.52,103.82 204.65,103.96 205.46,103.96
1658R-UGATE2 on BOTTOM (solid shape): 208.88,121.51 208.88,119.76 208.62,119.5 207.73,119.5 207.61,119.63 207.61,121.28 206.84,122.04 206.84,122.3 207.1,122.55 207.84,122.55
8002LX1.05V on BOTTOM (solid shape): 78.3,23.39 78.3,21.43 78.14,21.28 77.15,21.28 77,21.13 77,20.44 76.75,20.19 75.25,20.19 75.04,20.39 75.04,23.24 75.4,23.59 78.09,23.59
24780_DH on BOTTOM (solid shape): 202.78,196.24 203.05,196.24 203.05,196.24 203.65,196.24 203.69,196.23 203.71,196.19 203.71,196.04 203.7,196.04 202.79,196.04 202.65,195.91 202.16,195.91 201.95,196.11 201.95,196.39 202.1,196.54 202.49,196.54
24780_DL on BOTTOM (solid shape): 195.92,194.92 195.92,194.46 195.83,194.37 194.49,194.37 194.18,194.68 194.18,195.81 194.18,195.81 195.03,195.81
24780_DL on BOTTOM (solid shape): 203.05,195.04 203.66,195.04 203.69,195.03 203.71,194.99 203.71,194.89 203.69,194.86 203.66,194.84 202.94,194.84 202.78,194.69 202.78,194.18 202.65,194.05 202.27,194.05 202.02,194.3 202.02,194.53 202.04,194.55 202.05,194.56 202.17,194.64 202.24,194.77 202.24,194.78 202.51,195.05 203.05,195.05
24780_LX on BOTTOM (solid shape): 190.61,201.58 190.82,201.53 191.02,201.58 191.29,201.58 191.89,201.58 191.93,201.57 191.95,201.53 191.95,199.25 192.24,198.96 193.04,198.96 193.54,198.46 193.54,194.99 193.39,194.84 191.76,194.84 191.21,195.39 190.66,195.39 187.71,198.33 187.71,201.05 188.24,201.58
24780_LX on BOTTOM (solid shape): 201.79,197.73 202.53,197.73 202.69,197.58 202.69,197.02 203.03,196.68 203.03,196.64 203.05,196.64 203.65,196.64 203.69,196.62 203.71,196.59 203.71,196.44 203.7,196.44 203.05,196.44 202.86,196.44 202.61,196.69 201.6,196.69 201.5,196.8 201.5,197.11 201.44,197.18 200.72,197.18 200.19,197.71 200.19,198.52 200.29,198.62 200.9,198.62
24780_VCC on TOP (solid shape): 202.02,198.62 202.02,197.99 201.64,197.61 199.73,197.61 199.61,197.73 199.61,198.75 199.61,198.77 199.63,198.79 199.74,198.94 199.77,199.14 199.77,199.15 199.77,199.17 199.99,199.39 201.26,199.39
51216_DRVH on BOTTOM (solid shape): 179.04,66.53 179.04,65.27 178.95,65.18 178.95,64.83 178.84,64.72 177.96,64.72 177.84,64.84 177.84,65.32 177.95,65.44 178.73,65.44 178.84,65.54 178.84,66.49 178.85,66.52 178.88,66.53 179.03,66.53
51216_DRVH on BOTTOM (solid shape): 176.16,55.56 176.16,54.74 176.27,54.63 176.27,54.12 176.27,54.12 176.27,53.85 175.83,53.41 175.09,53.41 175.02,53.49 175.02,54.1 175.53,54.61 175.59,54.61 175.73,54.74 175.73,55.51 175.74,55.55 175.78,55.56 176.16,55.56
51216_DRVL on BOTTOM (solid shape): 181.06,66.42 181.06,65.86 181.14,65.78 181.14,65.38 181.06,65.3 180.91,65.3 180.47,65.74 180.04,65.74 180.04,66.53 180.95,66.53
51216_SW on BOTTOM (solid shape): 179.44,66.53 179.44,65.55 179.91,65.08 179.91,63.76 179.79,63.64 179.12,63.64 179.06,63.7 179.06,65.08 179.24,65.25 179.24,66.51 179.25,66.53 179.28,66.54 179.43,66.54
51216_SW on BOTTOM (solid shape): 183.27,57.03 183.27,56.32 183.51,56.08 184.7,56.08 184.88,55.91 184.88,51.31 184.49,50.92 176.89,50.92 176.38,51.43 176.38,55.51 176.4,55.54 176.43,55.56 178.6,55.56 179.03,55.99 179.03,56.88 179.35,57.21 183.1,57.21
51216_VBST on BOTTOM (solid shape): 178.63,66.44 178.63,65.83 178.55,65.76 177.89,65.76 177.66,65.53 177.66,64.64 177.79,64.51 178.5,64.51 178.57,64.44 178.57,63.75 178.47,63.65 177.48,63.65 177.18,63.95 177.18,65.86 177.84,66.52 178.55,66.52
51225_DH1 on BOTTOM (solid shape): 58.98,43.95 58.98,43.23 59.35,42.87 59.35,42.57 59.15,42.37 58.58,42.37 58.33,42.62 58.33,43.89 58.51,44.07 58.87,44.07
51225_DH1 on BOTTOM (solid shape): 64.67,53.16 64.67,52.9 63.25,51.48 63.13,51.48 62.93,51.68 62.93,51.87 63.33,52.27 63.33,52.72 63.83,53.22 64.6,53.22
51225_DH2 on BOTTOM (solid shape): 77.64,47.04 77.64,46.3 77.51,46.17 76.81,46.17 76.05,46.94 76.05,47.35 76.17,47.48 77.19,47.48
51225_DH2 on BOTTOM (solid shape): 68.08,52.82 68.08,52.8 68.24,52.64 68.24,51.74 68.16,51.66 67.83,51.66 67.63,51.86 67.63,52.21 66.89,52.95 66.89,53.2 66.91,53.22 67.68,53.22
51225_DL1 on BOTTOM (solid shape): 66.32,46.71 66.32,46.25 66.14,46.07 65.15,46.07 65.02,46.2 65.02,46.85 65.11,46.95 66.08,46.95
51225_DL1 on BOTTOM (solid shape): 65.06,52.62 65.06,52.03 64.7,51.66 64.7,51.19 64.6,51.1 64.22,51.1 64.07,51.25 64.07,52.12 64.76,52.81 64.87,52.81
51225_DL2 on BOTTOM (solid shape): 67.48,52.16 67.48,51.86 67.33,51.7 66.78,51.7 66.48,52.01 66.48,52.78 66.5,52.81 66.83,52.81
51225_DL2 on BOTTOM (solid shape): 72.76,49.68 72.76,49.17 72.65,49.06 71.27,49.06 71.09,49.24 71.09,49.6 71.29,49.81 72.63,49.81
51225_SW1 on BOTTOM (solid shape): 66.24,45.42 66.24,44.72 66.71,44.25 68.13,44.25 68.44,43.94 68.44,40.01 68.13,39.7 62.85,39.7 59.22,43.32 59.22,43.81 59.44,44.02 61.21,44.02 61.38,44.19 61.92,44.19 62.07,44.34 62.07,45.12 62.52,45.57 66.09,45.57
51225_SW1 on BOTTOM (solid shape): 63.88,54.02 64.62,54.02 64.65,53.98 64.65,53.86 64.61,53.82 63.88,53.82 63.85,53.79 63.22,53.79 62.01,52.58 61.31,52.58 61.19,52.7 61.19,53.37 61.25,53.44 61.82,53.44 62.38,53.99 62.6,53.95 62.8,54.05 63.85,54.05
51225_SW2 on BOTTOM (solid shape): 69.36,53.77 70.36,53.77 70.4,53.73 70.4,53.08 70.34,53.02 69.19,53.02 68.43,53.79 67.7,53.79 67.67,53.82 66.97,53.82 66.9,53.88 66.9,53.99 66.93,54.02 67.67,54.02 67.69,54.05 69.09,54.05
51225_SW2 on BOTTOM (solid shape): 75.83,50.03 75.83,46.46 76.24,46.05 77.64,46.05 77.84,46.25 77.84,46.95 77.94,47.05 79.59,47.05 79.72,46.91 79.72,46.11 79.68,46.02 79.59,45.98 79.2,45.61 79.59,45.25 79.68,45.21 79.72,45.12 79.72,42.66 79.25,42.19 70.71,42.19 70.59,42.32 70.59,43.89 70.63,43.93 72.85,43.93 73.29,44.36 73.29,49.87 73.8,50.39 75.47,50.39
51225_VBST1 on BOTTOM (solid shape): 63.88,53.63 63.88,53.62 64.63,53.62 64.65,53.59 64.65,53.45 64.62,53.42 63.88,53.42 63.87,53.4 63.78,53.4 63.09,52.71 63.09,52.47 63.09,52.47 63.09,52.25 62.21,51.37 61.25,51.37 61.23,51.39 61.23,52.12 61.32,52.21 61.93,52.21 63.37,53.66 63.86,53.66
51225_VBST2 on BOTTOM (solid shape): 68.99,52.97 69,52.97 69.4,52.57 70.29,52.57 70.39,52.46 70.39,51.78 70.36,51.75 69.49,51.75 67.86,53.38 67.7,53.38 67.66,53.42 66.94,53.42 66.91,53.46 66.91,53.58 66.94,53.62 67.67,53.62 67.69,53.64 68.32,53.64
51225_VIN on TOP (solid shape): 66.66,52.02 66.66,51.71 67.43,50.94 67.43,50.04 67.32,49.93 66.52,49.93 66.25,50.2 66.25,51.11 66.25,51.28 66.24,51.28 66.24,51.3 65.9,51.64 65.9,52.09 66.01,52.2 66.48,52.2
+AZA_VDD on TOP (solid shape): 37.3,30.35 37.3,29.97 37.17,29.84 36.69,29.84 36.22,30.31 34.7,30.31 34.7,31.3 35.7,31.3 35.76,31.36 36.28,31.36
+AZA_VDD on TOP (solid shape): 40.73,41.02 40.73,40.13 40.22,39.62 40.22,39.11 40.09,38.98 39.59,38.98 38.95,38.35 38.67,38.35 38.51,38.28 38.45,38.12 38.45,37.85 37.93,37.33 37.45,37.33 36.94,37.79 36.55,37.22 36.16,36.83 35.9,36.83 35.59,36.51 34.7,36.51 34.7,37.5 34.79,37.6 35.3,37.6 36.06,38.35 37.55,38.35 37.81,38.6 37.81,39.75 37.43,40.13 37.43,40.38 37.55,40.51 39.46,40.51 40.09,41.14 40.6,41.14
+FB_PLLAVDD on IN2 (solid shape): outline of 299 points within 179.57,158.85 188.82,163.74
+SMDDR_VREF_DIMM on TOP (solid shape): outline of 242 points within 140.75,42.57 144.41,60.07
+SMDDR_VREF_DQ0 on TOP (solid shape): 103.44,60.68 103.68,60.68 103.68,60.68 104.18,60.68 104.47,60.4 104.47,57.52 102.57,55.62 100.55,55.62 99.54,54.62 92,54.62 91.81,54.81 91.81,55.64 91.85,55.67 93.02,55.67 93.07,55.65 93.1,55.63 98.14,55.63 99.53,57.02 101.52,57.02 102.75,58.24 102.75,59.22 102.37,59.6 102.37,60.72 102.6,60.95 103.18,60.95
+SMDDR_VREF_DQ1 on TOP (solid shape): 97.88,70.15 99.48,70.15 99.56,70.23 100.8,70.23 100.93,70.1 100.93,69.72 100.37,69.16 98.29,69.16 97.65,68.53 95.95,68.53 95.31,69.16 93.59,69.16 93.51,69.24 93.51,70.08 93.71,70.28 97.75,70.28
+TPVDD on BOTTOM (solid shape): 207.61,26.28 207.61,25.4 207.48,25.27 206.21,25.27 205.96,25.52 204.23,25.52 204.08,25.36 204.08,24.1 203.88,23.9 203.88,23 203.8,22.92 203.8,21.84 202.27,20.32 202.27,18.85 201.63,18.2 200.96,18.2 200.24,18.92 200.24,21.08 200.37,21.2 202.27,21.2 203.03,21.97 203.03,22.09 203.29,22.35 203.29,24 202.76,24.52 202.76,25.5 202.79,25.52 202.79,25.84 202.92,25.97 203.74,25.97 203.92,26.16 206.08,26.16 206.34,26.41 207.48,26.41
+VGPU_CORE on TOP (solid shape): 187.03,154.94 187.03,154.43 186.26,153.65 186.25,153.65 185.59,153 185.47,152.88 185.47,152.61 185,152.14 184.75,152.14 184.37,152.52 184.37,153.67 184.62,153.92 185.64,153.92 186.78,155.06 186.91,155.06
+VGPU_CORE on TOP (solid shape): 191.48,133.73 191.49,133.73 191.49,133.24 191.88,132.85 196.32,132.85 196.81,133.35 197.32,133.35 198.94,131.73 204.18,131.73 206.34,129.58 206.34,127.5 206.03,127.19 204.62,127.19 204.61,127.19 192.69,127.19 192.49,127 191.22,127 191.1,127.12 191.1,128.14 190.83,128.41 184.99,128.41 184.49,128.9 184.49,130.57 188.28,134.36 190.84,134.36
+VGPU_CORE on TOP (solid shape): outline of 147 points within 177.58,140.94 181.06,154.05
+VGPU_CORE on TOP (solid shape): outline of 158 points within 177,153.28 187.29,160.73
+VGPU_CORE on BOTTOM (solid shape): 186.72,132.84 196.68,132.84 197.07,133.22 200.66,133.22 202.79,132.17 205.14,132.5 207.03,132.5 207.76,131.77 207.76,128.41 206.49,127.14 188.48,127.14 188.46,127.15 187.35,127.15 185.38,129.12 183.25,129.12 182.97,129.41 182.97,133.85 183.38,134.27 185.29,134.27
+VGPU_CORE on BOTTOM (solid shape): 180.64,153.17 180.64,152.46 180.53,152.35 180.36,152.35 180.29,152.42 180.29,152.92 179.54,153.67 179.1,153.67 178.83,153.4 178.83,153.1 179.66,152.26 179.66,152.09 180.18,151.57 180.18,151.18 180.06,151.06 179.73,151.06 179.31,151.49 179.3,151.51 179.27,151.55 179.24,151.59 179.2,151.62 179.16,151.65 179.14,151.66 178.86,151.93 178.31,151.93 177.45,152.79 177.45,154 177.39,154.06 177.39,154.8 177.51,154.8 177.51,154.75 177.52,154.7 177.53,154.64 177.56,154.6 177.57,154.57 177.57,154.54 178.2,153.91 178.47,153.91 178.65,154.09 178.65,154.36 178.27,154.74 178.27,154.77 178.27,154.82 178.26,154.88 178.24,154.93 178.22,154.98 178.19,155.02 178.15,155.06 178.11,155.1 178.06,155.12 178.01,155.14 177.96,155.16 177.91,155.17 177.85,155.16 177.8,155.16 177.75,155.14 177.7,155.12 177.65,155.08 177.61,155.05 177.58,155.01 177.55,154.96 177.53,154.91 177.51,154.86 177.51,154.8 177.39,154.8 177.39,155.91 177.55,156.07 177.75,156.07
+VGPU_CORE on BOTTOM (solid shape): outline of 106 points within 177.63,152.98 187.29,161.51
+VGPU_CORE on SVCC (solid shape): outline of 170 points within 177.25,123.95 210.15,161.03
+VGPU_CORE on IN1 (solid shape): outline of 3241 points within 176.21,127.12 206.08,161.03
+VGPU_CORE on IN2 (solid shape): outline of 3279 points within 177.63,127 205.83,161.16
+WL_VDD on TOP (solid shape): 185.89,104.52 187.67,104.52 188.05,104.14 188.84,104.14 189.04,103.93 190.18,103.93 190.33,103.78 190.33,102.61 189.4,101.68 188.98,101.6 188.91,101.19 188.43,100.71 188.43,98.93 188.18,98.67 186.65,98.67 186.41,98.43 186.41,97.06 186.37,97.02 186.17,97.02 186.14,97.05 186.14,98.34 186.07,98.42 184.75,98.42 184.37,98.04 184.24,98.04 183.98,98.29 183.98,99.06 184.37,99.44 185.76,99.44 186.14,99.82 186.14,101.85 185.76,102.23 183.86,102.23 183.73,102.36 183.73,104.77 184.11,105.15 185.25,105.15
+WL_VDD on BOTTOM (solid shape): 191.73,90.17 191.73,88.77 191.48,88.51 190.97,88.51 190.54,88.95 190.54,88.97 190.55,89.03 190.55,89.09 190.54,89.14 190.52,89.19 190.5,89.24 190.46,89.29 190.42,89.33 190.38,89.36 190.33,89.39 190.28,89.41 190.22,89.42 190.16,89.42 190.11,89.41 190.08,89.4 189.7,89.78 186.65,89.78 186.52,89.91 186.52,90.63 188.44,90.63 188.44,90.82 186.89,90.82 186.89,90.63 186.52,90.63 186.52,90.93 186.72,91.13 190.77,91.13
+WL_VDD on BOTTOM (solid shape): 190.84,108.33 190.84,103.5 190.72,103.37 188.94,103.37 188.73,103.58 188.73,105.44 189.33,105.44 189.34,105.39 189.35,105.34 189.37,105.29 189.4,105.24 189.43,105.2 189.47,105.16 189.52,105.13 189.57,105.11 189.62,105.1 189.67,105.09 189.73,105.09 189.78,105.1 189.83,105.11 189.88,105.13 189.93,105.16 189.97,105.2 190,105.24 190.03,105.29 190.05,105.34 190.06,105.39 190.07,105.44 190.07,105.5 190.06,105.55 190.04,105.6 190.02,105.65 189.98,105.69 189.95,105.73 189.9,105.76 189.86,105.79 189.81,105.81 189.75,105.82 189.7,105.83 189.65,105.82 189.59,105.81 189.54,105.79 189.5,105.76 189.45,105.73 189.42,105.69 189.38,105.65 189.36,105.6 189.34,105.55 189.33,105.5 189.33,105.44 188.73,105.44 188.73,107.64 188.55,107.82 186.78,107.82 186.65,107.95 186.65,108.13 188.44,108.13 188.44,108.32 186.89,108.32 186.89,108.13 186.65,108.13 186.65,108.56 186.8,108.71 190.46,108.71
+WL_VDD on IN1 (solid shape): outline of 199 points within 189.19,89.15 193,103.93
ADOGND on TOP (solid shape): 15.63,19.35 15.63,19 15.46,18.82 15.46,18.16 15.58,18.03 15.58,17.27 15.46,17.14 14.19,17.14 14.06,17.27 14.06,18.79 14.19,18.92 14.69,18.92 15.2,19.43 15.56,19.43
ADOGND on TOP (solid shape): 13.28,15.64 13.28,15.36 12.28,14.36 12.28,10.79 12.15,10.66 11.72,10.66 11.63,10.76 11.63,11.07 11.72,11.82 11.25,12.42 11.25,16.7 12.23,16.7
ADOGND on TOP (solid shape): 0.89,10.54 1,10.48 1,10.35 1.01,9.69 1.59,9.35 2.5,9.35 3.08,9.69 3.09,10.48 3.2,10.54 8.69,10.54 8.8,10.48 8.8,10.35 8.72,9.97 8.86,9.6 8.88,9.59 8.88,9.41 6.39,9.41 5.16,9.24 4.03,8.71 0.71,8.71 0.71,10.54
ADOGND on BOTTOM (solid shape): 13.25,18.79 14.57,18.79 14.77,18.59 14.77,16.66 15.18,16.25 15.18,11.88 13.25,9.95 11.82,9.95 11.63,10.15 11.63,11.07 11.72,11.82 11.25,12.42 11.25,16.35 11.62,16.72 11.62,17.47 11.82,17.67 11.82,18.59 11.21,19.2 8.88,19.2 8.78,19.3 8.78,19.71 9.08,20.01 12.03,20.01
ADOGND on SVCC (solid shape): 29.81,36.21 29.81,31.64 30.46,30.98 33.64,30.98 33.74,30.88 33.74,29.61 34.25,29.1 34.25,28.59 34.65,28.19 37.79,28.19 38.82,29.23 38.82,30.33 38.29,30.86 37.53,30.86 36.52,31.87 35.5,31.87 35.27,32.11 35.27,32.78 35.37,32.89 36.81,32.89 36.94,32.76 44.43,32.76 44.67,32.53 44.67,28.04 44.31,27.68 39.99,27.68 39.35,27.05 37.83,27.05 37.45,26.67 34.53,26.67 32.88,25.01 20.68,25.01 18.88,23.22 18.88,20.34 20.03,19.19 20.03,11.91 17.76,9.65 14.21,9.65 13.7,9.14 11.79,9.14 11.29,8.63 1.34,8.63 0.71,9.26 0.71,10.54 10.74,10.54 11.72,11.29 11.25,12.42 11.25,17.23 11.72,18.36 10.74,19.11 0.51,19.11 0.51,20.25 1.2,20.82 14.16,20.82 14.69,21.35 14.69,26.18 14.93,26.41 16.96,26.41 19.24,28.7 23.31,28.7 24.45,29.84 25.21,29.84 25.87,30.5 25.87,31.64 26.12,31.89 26.12,35.2 26.63,35.7 26.63,37.74 26.74,37.84 28.18,37.84
ADOGND on IN1 (solid shape): 13.86,18.69 13.86,12.62 13.27,12.04 11.87,12.04 11.42,12.49 11.42,17.06 11.82,17.47 11.82,18.59 11.9,18.66 11.9,18.79 12.19,19.08 13.46,19.08
ADOGND on SGND (solid shape): outline of 127 points within 0.51,8.63 44.67,37.84
APW8824_1.8V on BOTTOM (solid shape): 101.31,139.29 101.31,138.4 103.21,136.5 103.21,135.73 102.86,135.38 102.3,135.38 100.57,137.11 99.05,137.11 99.05,138.17 99.66,138.78 100.42,138.78 100.57,138.93 100.57,139.37 100.7,139.49 101.1,139.49
BAT-V on BOTTOM (solid shape): 178.4,201.42 178.4,197.73 178.89,197.24 179.55,197.24 180.3,196.49 180.3,195.83 180.17,195.7 176.24,195.7 172.81,192.27 170.14,192.27 169.89,192.02 169.89,190.75 169.63,190.5 168.49,190.5 167.98,191 167.98,191.51 167.73,191.77 165.82,191.77 165.32,192.27 165.32,200.66 167.98,200.66 167.98,198.88 168.36,198.5 170.27,198.5 170.4,198.37 170.4,197.86 170.65,197.61 172.05,197.61 172.17,197.73 172.17,200.15 171.28,201.04 168.36,201.04 167.98,200.66 165.32,200.66 165.32,200.91 165.95,201.54 178.27,201.54
CCD_PWR on TOP (solid shape): 131.2,192.63 131.2,192.17 130.77,191.74 130.77,191.45 130.4,191.08 130.77,190.71 130.77,189.35 130.64,189.23 129.76,189.23 129.58,189.4 129.58,191.77 129.5,191.84 129.5,192.78 129.63,192.91 130.92,192.91
CCD_PWR on BOTTOM (solid shape): 130.78,190.36 130.78,189.75 130.8,189.73 130.8,188.67 131.04,188.32 131.69,187.39 131.69,187.38 131.49,187.24 131.49,187.24 131.12,187.77 130.84,188.17 130.83,188.17 130.64,188.04 130.64,188.02 131.28,187.11 131.28,187.09 131.09,186.96 131.07,186.96 130.43,187.89 129.63,189.03 129.63,190.24 129.88,190.5 130.64,190.5
CRTVDD5 on TOP (solid shape): 5.15,114.93 5.29,114.92 5.44,114.93 5.45,114.93 5.59,114.92 5.74,114.93 6.85,114.93 7.58,114.19 7.58,113.94 7.73,113.79 9.51,113.79 10.15,113.15 12.07,113.15 12.07,113.15 12.54,113.15 12.66,113.03 12.66,111.91 12.66,111.85 12.66,111.35 12.56,111.25 11.8,111.25 11.75,111.25 10.1,111.25 9.46,111.88 7.33,111.88 6.72,112.49 6.72,112.84 6.72,112.84 7.02,113.32 6.49,113.53 6.49,113.53 6.31,113.53 6.1,113.74 6.07,113.78 6.04,113.81 5.68,114.17 4.03,114.17 3.92,114.27 3.92,114.82 4.04,114.93
CRTVDD5 on BOTTOM (solid shape): 12.64,113.14 12.64,112.57 12.59,112.52 11.9,112.52 11.26,113.15 11.26,113.43 11.28,113.47 11.32,113.49 12.29,113.49

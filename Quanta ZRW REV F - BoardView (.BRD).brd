# Allegro board Quanta ZRW REV F - BoardView (.BRD).brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
SATA_RXN1_C: length 4.4
  BOTTOM w0.114: CN9.5 231.46,99.7 230.69,99.7 229.82,98.83 228.63,98.83 C744.1
SATA_RXP0: length 167.7
  TOP w0.114: C504.2 221.72,36.3 v1(222.08,35.94)
  IN2 w0.127: v1(222.08,35.94) 221.88,36.14 221.88,36.47 220.94,37.41 219.78,37.41 219.2,37.98 211.6,45.59 207.48,45.59 206.49,46.58 199.94,46.58 198.8,47.72 197.73,47.72 197.09,48.36 197.09,49.6 196.63,50.06 196.63,51.08 195.34,52.37 195.34,58.29 195.62,58.56 195.62,62.86 196.18,63.42 196.18,70.1 196.33,70.25 196.33,89.28 195.41,90.19 195.41,91.54 194.22,92.73 193.89,92.73 186.78,99.84 186.78,106.3 186.07,107.01 184.98,107.01 183.93,108.05 183.93,111.25 180.25,114.93 180.25,117.14 179.74,117.65 179.74,118.89 179.54,119.1 179.54,119.5 178.23,120.81 178.23,121.93 178.14,122.02 178.1,122.06 177.31,122.85 177.05,123.11 177.05,128.09 175.93,129.21 175.93,131.01 174.65,132.29 174.65,133.74 172.68,135.71 172.1,135.71 170.62,137.18 170.62,137.79 167.33,141.09 166.95,141.09 166.51,141.52 163.31,141.52 159.8,138.02 159.8,137.23 158.03,135.45 153.42,135.45 150.33,132.36 148.55,132.36 146.14,129.95 146.14,128.72 145.66,128.23 145.66,128.12 v2(145.46,127.92)
  BOTTOM w0.114: v2(145.46,127.92) 145.76,128.22 U35.E20
SATA_RXP0_C: length 8.3
  TOP w0.114: CN14.6 228.2,37.58 226.21,37.58 v3(225.39,38.4) 224.54,37.56 224.22,37.56 223.96,37.3 223.96,36.63 223.36,36.03 223.04,36.03 C504.1
SATA_RXP1: length 137
  IN2 w0.127: v1(225.53,97.64) 225.93,98.05 225.93,98.32 225.09,99.16 218.62,99.16 214.8,95.34 194.76,95.34 193,97.1 193,98.34 194.02,99.36 194.02,104.16 191.29,106.89 191.29,108.28 187.17,112.39 186.75,112.39 182.66,116.48 182.66,120.46 182.52,120.61 182.09,120.61 181.24,121.45 181.24,121.58 180.73,122.09 180.73,122.88 180.25,123.36 180.25,124.12 180.14,124.24 180.14,127.51 179.54,128.11 179.54,129.05 178.83,129.76 178.83,132.08 179.13,132.38 179.13,133.49 178.55,134.08 178.32,134.08 177.36,135.04 177.36,135.48 173.57,139.26 173.57,139.5 171.78,141.3 171.32,141.3 168.4,144.22 165.77,144.22 165.52,143.96 162.29,143.96 156.63,138.3 149.04,138.3 146.61,135.87 145.36,135.87 141.82,132.33 141.82,130.42 142.46,129.79 142.46,129.28 143.75,127.99 144.17,127.99 144.26,127.9 v2(144.55,127.9)
  BOTTOM w0.114: C743.2 227.46,99.12 227.03,98.69 226.2,98.69 225.94,98.43 225.94,98.06 v1(225.53,97.64) ; U35.F21 145.01,127.81 144.92,127.9 v2(144.55,127.9)
SATA_RXP1_C: length 4.5
  BOTTOM w0.114: C743.1 228.63,99.07 229.72,99.07 230.59,99.94 231.42,99.94 CN9.6
SATA_TXN0: length 171.5
  TOP w0.114: v1(221.04,32.89) 221.31,33.16 C513.2
  IN2 w0.127: v1(144.39,131.97) 145.43,133.02 148,133.02 151.35,136.37 158,136.37 159.17,137.54 159.17,138.3 163.03,142.16 167.48,142.16 170.01,139.62 170.01,139.43 171.32,138.12 171.32,137.96 175.29,134 175.29,132.69 176.57,131.41 176.57,129.48 177.69,128.36 177.69,123.39 178.89,122.18 178.89,121.06 180.17,119.78 180.17,119.43 180.89,118.72 180.89,115.21 181.77,114.32 182.14,114.32 186.47,109.99 186.47,108.96 187.57,107.87 187.57,99.97 194.09,93.44 194.65,93.44 196.08,92.02 196.08,90.92 196.96,90.04 196.96,69.98 196.81,69.82 196.81,62.59 196.25,62.03 196.25,52.72 197.55,51.42 197.55,50.04 199.48,48.12 207.01,48.12 208.9,46.22 211.87,46.22 215.51,42.59 216.83,42.59 222.62,36.8 222.62,34.92 221.42,33.73 221.42,33.27 v1(221.04,32.89)
  BOTTOM w0.114: v1(144.39,131.97) 144.61,131.75 144.61,131.31 144.34,131.04 144.34,130.4 144.44,130.29 U35.B21
SATA_TXN0_C: length 8
  TOP w0.114: C513.1 222.34,33.52 222.85,33.02 223.14,33.02 223.9,33.77 224.82,33.77 v3(225.64,34.59) 226.49,33.75 228.18,33.75 CN14.3
SATA_TXN1: length 131.4
  IN2 w0.127: v1(144.51,128.52) 144.11,128.93 143.72,128.93 143.34,129.3 143.34,130.32 142.53,131.13 142.53,132.13 145.64,135.24 146.88,135.24 149.3,137.66 156.9,137.66 162.57,143.33 165.79,143.33 166.05,143.58 168.05,143.58 170.97,140.66 171.51,140.66 172.94,139.24 172.94,138.98 176.68,135.24 176.68,134.65 177.23,134.11 177.23,132.76 177.71,132.28 177.71,129.97 178.83,128.85 178.83,127.68 179.16,127.35 179.16,124.38 179.54,124 179.54,123.16 180.07,122.63 180.07,121.69 180.58,121.18 180.58,121 182.03,119.55 182.03,116.2 186.6,111.63 187.04,111.63 190.46,108.21 190.46,107.18 190.46,107.18 190.46,106.82 193.38,103.9 193.38,99.64 192.37,98.62 192.37,96.84 194.5,94.71 215.07,94.71 217.64,97.28 223.33,97.28 224.37,96.24 v1(225.26,96.24)
  BOTTOM w0.114: U35.D21 144.73,128.73 v1(144.51,128.52) ; v1(225.26,96.24) 227.41,96.24 C749.2
SATA_TXN1_C: length 4
  BOTTOM w0.114: C749.1 228.7,96.08 231.36,96.08 CN9.3
SATA_TXP0: length 171.5
  TOP w0.114: v1(221.68,32.89) 221.31,32.52 C522.2
  IN2 w0.127: v1(221.68,32.89) 221.68,33.63 222.87,34.82 222.87,36.9 216.93,42.84 215.61,42.84 211.98,46.48 209.01,46.48 207.12,48.37 199.58,48.37 197.8,50.15 197.8,51.53 196.51,52.83 196.51,61.92 197.07,62.48 197.07,69.72 197.22,69.87 197.22,90.14 196.33,91.03 196.33,92.12 194.75,93.7 194.2,93.7 187.82,100.08 187.82,107.97 186.73,109.06 186.73,110.09 182.25,114.58 181.88,114.58 181.14,115.31 181.14,118.82 180.43,119.53 180.43,119.88 179.14,121.17 179.14,122.29 177.94,123.49 177.94,128.47 176.82,129.59 176.82,131.52 175.54,132.8 175.54,134.11 171.58,138.07 171.58,138.23 170.27,139.53 170.27,139.73 167.58,142.41 162.92,142.41 158.92,138.4 158.92,137.64 157.9,136.62 151.24,136.62 147.89,133.27 145.33,133.27 144.66,132.6 v5(144.28,132.6)
  BOTTOM w0.114: U35.A21 144.73,131.14 144.81,131.23 144.81,132.13 144.34,132.6 v5(144.28,132.6)
SATA_TXP0_C: length 8
  TOP w0.114: CN14.2 228.18,33.5 226.46,33.5 v3(225.64,32.69) 224.8,33.53 224,33.53 223.24,32.77 222.86,32.77 222.34,32.25 C522.1
SATA_TXP1: length 131.4
  IN2 w0.127: v1(225.26,95.6) 224.88,95.98 224.27,95.98 223.23,97.02 217.74,97.02 215.17,94.45 194.39,94.45 192.11,96.73 192.11,98.73 193.13,99.75 193.13,103.8 190.21,106.72 190.21,107.07 190.2,107.08 190.2,108.1 186.93,111.37 186.5,111.37 181.78,116.1 181.78,119.45 180.33,120.9 180.33,121.07 179.82,121.58 179.82,122.52 179.29,123.06 179.29,123.89 178.9,124.27 178.9,127.25 178.57,127.58 178.57,128.74 177.46,129.86 177.46,132.17 176.97,132.66 176.97,134 176.43,134.55 176.43,135.13 172.68,138.88 172.68,139.13 171.41,140.41 170.87,140.41 167.94,143.33 166.15,143.33 165.9,143.07 162.67,143.07 157.01,137.41 149.41,137.41 146.98,134.98 145.75,134.98 142.79,132.03 142.79,131.24 143.6,130.42 143.6,129.41 143.83,129.18 144.11,129.18 144.26,129.33 v5(144.26,129.43)
  BOTTOM w0.114: U35.C21 144.73,129.78 144.61,129.89 144.44,129.89 144.26,129.71 v5(144.26,129.43) ; C751.2 227.59,95.71 227.3,96 225.65,96 v1(225.26,95.6)
SATA_TXP1_C: length 4
  BOTTOM w0.114: CN9.2 231.52,95.84 228.81,95.84 C751.1
SATAGP0: length 24.5
  BOTTOM w0.076: 159.85,128.42 159.6,128.42 159.54,128.49 158.57,128.49 157.08,127 156.69,127 156.54,127.05 156.44,127.05 156.25,127 U35.H2
  BOTTOM w0.114: 159.85,128.42 162.37,128.42 163.08,129.13 163.08,129.84 163.58,130.34 166,130.34 166.04,130.3 167.2,130.3 167.83,130.93 167.83,131.59 168.29,132.06 168.29,132.21 168.72,132.63 169.66,132.63 171.84,130.45 171.84,129.87 172.07,129.64 v3(172.07,128.47) R568.2 171.71,127.41 171.48,127.64 R570.2
SATAGP1: length 10.1
  BOTTOM w0.076: U35.H3 155.57,126.39 156.71,126.39 158.64,128.32 159.35,128.32 159.42,128.25 159.8,128.25 159.85,128.2
  BOTTOM w0.114: R569.1 163.42,129.15 162.47,128.2 159.85,128.2
SATAGP2: length 8.4
  BOTTOM w0.076: U35.G4 154.98,127.43 155.28,127.73 155.71,127.73 156.15,127.9 156.32,127.85 156.48,127.81 156.8,127.89 156.98,128.16 158.74,129.92 158.79,129.97 159.66,129.97 159.92,130.23
  BOTTOM w0.114: 159.92,130.23 160.25,130.57 161.07,130.57 161.51,131.01 R566.1
SD_CDZ: length 40
  TOP w0.114: CN4.10 22.83,22.87 23.06,22.64 23.86,22.64 v1(24.37,22.13) ; U26.13 56.5,20.18 56.4,20.09 55.89,20.09 55.72,20.26 v1(55.72,20.88)
  BOTTOM w0.114: v1(24.37,22.13) 25.88,22.13 25.92,22.09 29.29,22.09 30.82,23.62 45.08,23.62 45.59,23.11 52.67,23.11 52.79,23.24 55.84,23.24 56.22,22.86 56.22,21.38 v1(55.72,20.88)
SD_CLK: length 2.2
  TOP w0.114: U26.15 57.5,19.43 R413.2
SD_CLK_R: length 37.3
  TOP w0.114: CN4.5 30.76,22.15 31.97,20.95 v1(31.97,20.57) ; v1(54.06,20.8) 54.06,20.7 56.61,18.15 R413.1
  BOTTOM w0.114: v1(54.06,20.8) 45.24,20.8 43.82,22.22 37.43,22.22 36.22,21.01 35.38,21.01 35.25,20.89 35.25,19.68 35.12,19.55 34.74,19.55 34.61,19.68 34.61,20.89 34.49,21.01 34.11,21.01 33.98,20.89 33.98,19.68 33.85,19.55 33.47,19.55 33.34,19.68 33.34,20.89 33.22,21.01 32.41,21.01 v1(31.97,20.57)
SD_CMD: length 39.3
  TOP w0.114: CN4.2 v1(38.26,20.77) ; U26.18 59,20.09 v1(58.86,19.96)
  BOTTOM w0.114: v1(38.26,20.77) 41.39,20.77 43.45,18.72 43.83,18.72 43.95,18.84 43.95,19.24 44.08,19.36 44.34,19.36 44.46,19.24 44.46,18.84 44.59,18.72 44.84,18.72 44.97,18.84 44.97,19.24 45.1,19.36 45.35,19.36 45.48,19.24 45.48,18.84 45.61,18.72 45.86,18.72 45.99,18.84 45.99,19.34 46.11,19.47 46.37,19.47 46.49,19.34 46.49,18.84 46.62,18.72 46.88,18.72 47,18.84 47,19.34 47.13,19.47 47.38,19.47 47.51,19.34 47.51,18.84 47.64,18.72 47.89,18.72 48.02,18.84 48.02,19.34 48.15,19.47 48.4,19.47 48.53,19.34 48.53,18.84 48.65,18.72 48.91,18.72 49.03,18.84 49.03,19.34 49.16,19.47 49.42,19.47 49.54,19.34 49.54,18.84 49.67,18.72 49.92,18.72 50.05,18.84 50.05,19.34 50.18,19.47 50.43,19.47 50.56,19.34 50.56,18.84 50.69,18.72 50.94,18.72 51.07,18.84 51.07,19.34 51.19,19.47 51.45,19.47 51.57,19.34 51.57,18.84 51.7,18.72 51.96,18.72 52.08,18.84 52.08,19.34 52.21,19.47 52.46,19.47 52.59,19.34 52.59,18.84 52.72,18.72 52.97,18.72 53.1,18.84 53.1,19.24 53.23,19.36 53.48,19.36 53.61,19.24 53.61,18.84 53.73,18.72 53.99,18.72 54.11,18.84 54.11,19.24 54.24,19.36 54.5,19.36 54.62,19.24 54.62,18.84 54.75,18.72 55,18.72 55.13,18.84 55.13,19.24 55.26,19.36 55.51,19.36 55.64,19.24 55.64,18.84 55.77,18.72 57.62,18.72 v1(58.86,19.96)
SD_D0/MS_D6: length 39.8
  TOP w0.114: U26.11 54.86,22.23 v1(54.67,22.04) ; v1(30.7,20.57) 29.17,22.09 26.63,22.09 25.76,22.96 CN4.7
  BOTTOM w0.114: v1(54.67,22.04) 54.09,21.46 45.48,21.46 44.08,22.86 36.92,22.86 35.71,21.65 35.27,21.65 35.14,21.78 35.14,22.35 35.02,22.47 34.76,22.47 34.64,22.35 34.64,21.78 34.51,21.65 34.26,21.65 34.13,21.78 34.13,22.35 34,22.47 33.75,22.47 33.62,22.35 33.62,21.78 33.49,21.65 33.24,21.65 33.11,21.78 33.11,22.35 32.99,22.47 32.73,22.47 32.6,22.35 32.6,21.78 32.48,21.65 32.22,21.65 32.1,21.78 32.1,22.57 31.97,22.7 31.72,22.7 31.59,22.57 31.59,21.78 31.46,21.65 30.92,21.65 30.7,21.42 v1(30.7,20.57)
SD_D1/MS_D7: length 39.7
  TOP w0.114: v1(54.7,22.73) U26.10 ; CN4.8 24.13,22.96 25.41,21.69 27.93,21.69 v1(29.04,20.57)
  BOTTOM w0.114: v1(29.04,20.57) 31.71,23.24 44.24,23.24 45.64,21.84 46.02,21.84 46.15,21.97 46.15,22.22 46.27,22.35 46.53,22.35 46.65,22.22 46.65,21.97 46.78,21.84 47.04,21.84 47.16,21.97 47.16,22.22 47.29,22.35 47.54,22.35 47.67,22.22 47.67,21.97 47.8,21.84 48.05,21.84 48.18,21.97 48.18,22.22 48.31,22.35 48.56,22.35 48.69,22.22 48.69,21.97 48.81,21.84 49.07,21.84 49.19,21.97 49.19,22.22 49.32,22.35 49.58,22.35 49.7,22.22 49.7,21.97 49.83,21.84 50.08,21.84 50.21,21.97 50.21,22.22 50.34,22.35 50.59,22.35 50.72,22.22 50.72,21.97 50.85,21.84 51.1,21.84 51.23,21.97 51.23,22.22 51.35,22.35 51.61,22.35 51.73,22.22 51.73,21.97 51.86,21.84 52.93,21.84 53.94,22.86 54.58,22.86 54.7,22.73 v1(54.7,22.73)
SD_D2/MS_D5: length 38.4
  TOP w0.114: U26.21 60.57,22.73 v1(60.77,22.93) ; v1(41.62,19.4) 41.62,21.33 43.26,22.98 CN4.9
  BOTTOM w0.114: v1(41.62,19.4) 42.91,18.11 43.63,18.11 43.76,17.98 43.76,17.5 43.88,17.37 44.14,17.37 44.26,17.5 44.26,17.98 44.39,18.11 44.64,18.11 44.77,17.98 44.77,17.5 44.9,17.37 45.15,17.37 45.28,17.5 45.28,17.98 45.41,18.11 45.66,18.11 45.79,17.98 45.79,17.5 45.91,17.37 46.17,17.37 46.3,17.5 46.3,17.98 46.42,18.11 46.68,18.11 46.8,17.98 46.8,17.5 46.93,17.37 47.18,17.37 47.31,17.5 47.31,17.98 47.44,18.11 47.69,18.11 47.82,17.98 47.82,17.5 47.95,17.37 48.2,17.37 48.33,17.5 48.33,17.98 48.45,18.11 48.71,18.11 48.84,17.98 48.84,17.5 48.96,17.37 49.22,17.37 49.34,17.5 49.34,17.98 49.47,18.11 49.72,18.11 49.85,17.98 49.85,17.5 49.98,17.37 50.23,17.37 50.36,17.5 50.36,17.98 50.49,18.11 50.74,18.11 50.87,17.98 50.87,17.5 50.99,17.37 51.25,17.37 51.38,17.5 51.38,17.98 51.5,18.11 58.2,18.11 59.93,19.83 59.93,21.62 60.35,22.04 60.35,22.51 v1(60.77,22.93)
SD_D3/MS_D4: length 38.6
  TOP w0.114: CN4.1 40.76,22.89 40.36,22.49 39.19,22.49 39.08,22.37 39.08,22.14 39.19,22.03 40.36,22.03 40.47,21.92 40.47,21.69 40.36,21.57 39.19,21.57 39.08,21.46 39.08,21.23 39.19,21.12 40.36,21.12 40.47,21 40.47,20.77 40.36,20.66 39.19,20.66 39.08,20.54 39.08,20.32 39.19,20.2 40.36,20.2 40.47,20.09 40.47,19.67 v1(40.76,19.38) ; U26.20 60.78,22.23 v1(60.79,22.22)
  BOTTOM w0.114: v1(40.76,19.38) 43.15,16.99 51.74,16.99 51.89,17.14 51.89,17.55 52.04,17.7 52.25,17.7 52.4,17.55 52.4,17.14 52.55,16.99 57.62,16.99 v3(58.08,17.45) 60.31,19.68 60.31,21.31 60.79,21.79 v1(60.79,22.22)
SD_WP/MS_D1: length 39.6
  TOP w0.114: v1(23.46,21.84) 23.16,22.14 21.94,22.14 21.63,22.44 CN4.11 ; U26.8 v1(53.94,23.73)
  BOTTOM w0.114: v1(23.46,21.84) 25.62,24 26.07,24 26.19,23.87 26.19,23.62 26.32,23.49 26.57,23.49 26.7,23.62 26.7,23.87 26.83,24 27.08,24 27.21,23.87 27.21,23.62 27.34,23.49 27.59,23.49 27.72,23.62 27.72,23.87 27.84,24 28.1,24 28.23,23.87 28.23,23.62 28.35,23.49 28.61,23.49 28.73,23.62 28.73,23.87 28.86,24 29.11,24 29.24,23.87 29.24,23.62 29.37,23.49 29.62,23.49 29.75,23.62 29.75,23.87 29.88,24 45.24,24 45.74,23.5 52.3,23.5 52.54,23.73 v1(53.94,23.73)
SDREG: length 3.7
  TOP w0.114: v1(54.72,25.6) 54.72,26.03 54.96,26.27 C540.1
  TOP w0.305: U26.6 56.5,25.63 55.46,26.67 C540.1
SENSEA: length 4.3
  TOP w0.203: U23.13 28.92,36.1 28.75,36.28 28.24,36.28 28.2,36.32
  TOP w0.381: R383.2 26.89,35.31 26.77,35.43 R378.2 v3(28.16,36.32) 28.2,36.32
SIO_RCIN#: length 97.9
  IN2 w0.127: v1(206.67,42.76) 206.14,42.76 205.96,42.95 205.96,44.19 204.45,45.69 199.57,45.69 198.91,46.35 197.3,46.35 195.8,47.86 195.8,48.51 196.05,48.76 196.05,49.22 195.36,49.91 195.36,50.92 193.21,53.08 193.21,59.64 194.37,60.8 194.37,63.98 193.94,64.41 193.94,67.23 194.73,68.02 194.73,69.01 193.94,69.8 193.94,76.27 192.54,77.67 187.59,77.67 v1(181.57,83.69)
  BOTTOM w0.114: v1(206.67,42.76) 206.72,42.71 U45.4 ; v1(181.57,83.69) 181.06,83.69 180.56,84.2 180.56,84.7 179.24,86.02 172.67,86.02 171.6,87.1 167.37,87.1 165.06,89.41 165.06,89.94 163.31,91.69 163.31,92.13 162.36,93.08 162.36,94.46 161.36,95.46 159.48,95.46 158.86,96.07 v3(158.86,97.81) 158.86,98.3 157.19,99.98 157.19,101.29 156.68,101.8 R652.1
SLEEVE: length 20.4
  BOTTOM w1.016: 16.19,20.44 16.19,23.67 19.98,27.45 26.18,27.45 27.27,28.54 27.27,32.63
  vias: v1(16.57,19.4) v1(16.57,18.77) v1(27.6,34.26) v1(28.23,34.24) v3(26.91,34.54)
SLEEVE_R: length 12.3
  IN1 w0.508: CN21.4 2.39,20.52 13.25,20.52 v4(13.3,20.47)
  vias: v3(15.46,21.2)
SM_RCOMP_0: length 30.7
  IN1 w0.381: 146.01,111.25 145.76,110.99 145.76,109.72 146.52,108.96 146.98,108.96 147.66,108.28 148.88,108.28 149.57,107.59 149.57,107.18 152.68,104.07 153.7,104.07 154.27,103.5 154.27,102.71 157.14,99.84 157.14,99.43 160.28,96.28 164.42,96.28 164.84,95.87 165.53,95.87 166.08,95.32 v1(166.08,94.96)
  BOTTOM w0.305: U35.AR18 v2(147.29,113.06)
  BOTTOM w0.381: v1(166.08,94.96) 166.22,95.1 R685.2
SM_RCOMP_1: length 24.7
  IN1 w0.381: 147.92,109.98 148.5,109.4 149.44,109.4 152.43,106.41 152.86,106.41 153.42,105.85 154.74,105.85 156.52,104.07 156.92,104.07 157.25,103.74 157.25,102.24 158.92,100.58 158.92,100.17 159.73,99.36 161.02,98.06 162.85,98.06 163.05,98.1 165.15,98.1 v1(165.21,98.17)
  BOTTOM w0.305: U35.AT18 v2(147.29,112.41)
  BOTTOM w0.381: R678.2 165.37,98.01 v1(165.21,98.17)
SM_RCOMP_2: length 27.6
  IN1 w0.381: v2(147.29,111.76) 147.29,109.59 148.04,108.83 149.29,108.83 150.89,107.23 150.89,107.12 153.05,104.96 154.38,104.96 155.6,103.74 155.6,102.64 158.03,100.21 158.03,99.8 160.65,97.17 163.19,97.17 163.23,97.21 165.16,97.21 165.18,97.2 v5(165.32,97.2)
  BOTTOM w0.305: U35.AU18 v2(147.29,111.76)
  BOTTOM w0.381: R681.2 165.74,97.2 v5(165.32,97.2)
SMB1ALERT#: length 282.8
  TOP w0.114: v1(46.57,61.51) 44.41,63.67 44.41,75.81 50.13,81.53 50.13,84.3 49.8,84.63 49.8,94.78 55.97,100.95 v3(55.97,102.08) 55.97,106.92 R218.2 U12.1 ; v2(153.63,114.35) 154.14,113.84 154.14,113.28 154.39,113.03 155.61,113.03 156.43,112.2 159.15,112.2 159.6,111.75 161.64,111.75 162.5,110.89 164.53,110.89 164.73,111.1 166.48,111.1 166.94,111.55 167.81,111.55 167.93,111.43 174.54,111.43 174.97,110.99 175.99,110.99 R205.1
  IN2 w0.127: v2(153.63,114.35) 154.14,113.84 154.14,113.41 154.34,113.2 154.34,112.31 155.16,111.5 155.16,110.33 157.67,107.82 159.09,107.82 161.21,105.7 163.28,105.7 166.4,102.59 166.4,96.58 167.67,95.31 167.67,94.93 167.41,94.67 166.75,94.67 166.38,94.31 165.89,94.31 164.68,93.1 164.68,92.25 162.67,90.24 162.67,84.09 162.97,83.8 162.97,82.74 162.71,82.48 162.71,82.48 162.71,76.61 163.47,75.85 163.47,71.39 164.6,70.27 164.6,65.97 164.37,65.75 164.37,49.93 162.41,47.97 96.65,47.97 82,62.61 68.67,62.61 67.96,63.32 53.84,63.32 52.36,61.84 46.9,61.84 v1(46.57,61.51)
  BOTTOM w0.076: v2(153.63,114.35) 153.3,114.68 U35.AM7
SMB_ME1_CLK: length 20.4
  TOP w0.114: R171.2 167.12,123.38 v1(167.12,123.56)
  BOTTOM w0.076: U35.W3 155.69,120.8 156.16,121.27 156.16,121.65
  BOTTOM w0.114: v1(171.23,124.76) 171.16,124.84 170.02,124.84 169.76,124.57 169.76,123.95 169.52,123.71 168.5,123.71 168.36,123.56 v1(167.12,123.56) 167.12,122.97 165.48,121.34 164.2,121.34 163.84,120.98 162.01,120.98 161.2,121.79 160.62,121.79 160.42,121.59 158.87,121.59 158.54,121.26 157.71,121.26 157.19,121.79 156.3,121.79 156.16,121.65
SMB_ME1_DAT: length 12.1
  TOP w0.114: v1(163.53,121.51) 164.93,121.51 165.24,121.81 R175.2
  BOTTOM w0.076: U35.V3 155.34,121.47 155.84,121.97 155.84,122.35
  BOTTOM w0.114: v1(163.53,121.51) 163.32,121.31 162.01,121.31 161.28,122.04 160.49,122.04 160.27,121.82 159.01,121.82 158.41,122.42 155.92,122.42 155.84,122.35
SMBALERT#: length 8.2
  TOP w0.114: v2(151.83,122.42) 151.42,122.83 151.42,123.74 151.7,124.02 154.65,124.02 v1(155.13,124.51) 155.88,125.26 155.88,125.95 R160.1
  BOTTOM w0.127: U35.R10 151.48,122.77 v2(151.83,122.42)
SML0ALERT#: length 3.2
  BOTTOM w0.114: U35.W1 158.83,120.8 158.94,120.91 R586.2
SP2: length 2.6
  TOP w0.114: TP36.1 53.93,23.23 U26.9
SP5: length 2.4
  TOP w0.114: TP38.1 53.56,21.46 54.72,21.46 54.99,21.73 U26.12
SP7: length 1.6
  TOP w0.114: U26.14 57,19.69 TP40.1
SP9: length 4.6
  TOP w0.114: U26.16 58,19.81 58.48,19.33 58.48,17.04 TP42.1
SP11: length 2.2
  TOP w0.114: TP39.1 61.28,21.73 U26.19
SP14: length 3.2
  TOP w0.114: U26.22 60.28,23.23 60.41,23.37 61.17,23.37 61.43,23.11 62.19,23.11 TP37.1
SP_PLLVDD: length 1.4
  BOTTOM w0.381: U34.N6 U34.M6 184.41,151 v1(184.44,151)
  vias: v3(183.15,146.73)
SPI_CLK_8M: length 16.7
  BOTTOM w0.114: R684.1 176.99,95.23 R687.2 v3(175.35,94.99) 176.25,95.89 176.25,98.03 175.86,98.42 174.97,98.42 174.76,98.22 174.76,97.57 175.64,96.69 175.64,96.46 175.48,96.29 175.24,96.29 174.82,96.71 174.66,96.71 173.82,95.88 173.32,95.88 172.3,94.86 U41.6
SPI_CS0#_UR_ME: length 96.6
  IN1 w0.127: v1(194.28,49.48) 194.2,49.56 194.2,50.9 191.83,53.26 191.83,60.71 191.69,60.85 191.69,61.25 193.48,63.05 193.48,68.35 193.27,68.56 193.27,74.11 190.45,76.93 186.98,76.93 184.06,79.85 184.06,80.57 180.35,84.28 180.35,85.3 179.53,86.13 179.27,86.13 177.66,87.73 177.66,96.9 177.19,97.37 177.19,97.85 178.16,98.81 178.16,101.94 176.07,104.02 174.28,104.02 173.03,105.27 173.03,106.9 v1(173.4,107.28)
  BOTTOM w0.114: v1(173.4,107.28) 174.37,108.24 174.82,108.24 177.21,110.64 177.21,113.11 177.63,113.53 177.63,115.36 176.61,116.38 174.84,116.38 174.49,116.02 172,116.02 171.17,115.18 R591.2 170.9,115.05 170.9,114.18 R603.1 R602.1 ; v1(194.28,49.48) 194.28,48.12 195.51,46.89 U45.101
SPI_HOLD_IO3_EC: length 7
  TOP w0.114: R238.2 R232.1 175.34,100.44 v3(175.78,100.88) 175.63,101.04 175.63,102.13 v1(175.09,102.66)
  BOTTOM w0.114: v1(175.09,102.66) 174.64,103.12 173.95,103.12 173.57,103.5 U39.7
SPI_HOLD_IO3_ME: length 10.1
  TOP w0.114: R239.2 172.93,98.05 v1(172.3,98.67)
  IN1 w0.127: v1(172.3,98.67) 172.81,98.17 172.81,96.26 172.68,96.13 v1(172.68,96.01)
  BOTTOM w0.114: R698.1 171.03,91.83 U41.7 171.03,94.36 v1(172.68,96.01)
SPI_SI_8M: length 19.3
  BOTTOM w0.114: R654.2 178.88,100.85 178.88,93.27 178.14,92.53 177.55,92.53 R691.1 176.37,92.96 v1(175.98,93.34) 175.05,93.34 174.6,93.8 174.6,94.83 174.04,95.39 173.82,95.39 173.57,95.13 U41.5
SPI_SO_8M: length 18.9
  IN1 w0.127: v1(172.3,107.16) 171.85,107.61 171.85,108 172.04,108.19 172.04,109.08 172.17,109.22 172.17,112.62 v1(171.54,113.25)
  BOTTOM w0.114: v1(172.3,107.16) 171.69,106.55 171.69,105.66 170.55,104.52 v3(170.52,104.52) 170.18,104.52 169.72,104.06 169.72,103.67 170.01,103.37 170.01,102.86 R650.2 169.51,101.98 170.19,101.29 170.95,101.29 171.03,101.21 U41.2 ; v1(171.54,113.25) 171.54,113.97 171.92,114.35 171.92,114.78 172.42,115.28 R588.2
SPI_WP_IO2_EC: length 3
  BOTTOM w0.114: U39.3 174.84,113.53 R596.2 R597.2
SPI_WP_IO2_ME: length 20.8
  BOTTOM w0.114: R589.2 176.42,115.67 176.82,115.26 v1(176.82,114.83) 176.82,113.86 176.55,113.59 176.55,110.88 174.55,108.88 173.74,108.88 172.96,108.09 172.96,105.59 172.52,105.15 171.79,105.15 171.16,104.52 171.16,104.26 170.4,103.5 170.4,102.83 170.75,102.48 R649.2 171.03,102.35 171.03,101.85 171.41,101.47 172.05,101.47 172.3,101.21 U41.3
SPKR: length 224.9
  TOP w0.114: D9.2 41.87,49.02 v1(42,48.89)
  IN2 w0.127: v1(159.04,108.66) 159.04,108.25 161.34,105.95 163.39,105.95 166.65,102.69 166.65,96.71 167.92,95.44 167.92,94.83 167.51,94.42 166.89,94.42 166.52,94.05 165.99,94.05 164.93,92.99 164.93,91.99 162.93,89.98 162.93,84.19 163.22,83.9 163.22,82.64 162.97,82.38 162.97,76.71 163.73,75.95 163.73,71.49 164.85,70.37 164.85,65.87 164.62,65.64 164.62,49.83 162.51,47.71 96.54,47.71 81.92,62.33 68.57,62.33 67.91,62.99 64.6,62.99 63.03,61.41 47.31,61.41 46.95,61.06 46.39,61.06 v1(45.94,61.51)
  BOTTOM w0.076: U35.AW5 154.38,110.61 154.9,110.61 155.16,110.36 155.16,109.07 155.24,108.99 155.24,108.82 155.41,108.65 155.79,108.65 156.03,108.41 156.03,108.09 156.17,107.95 158.58,107.95 158.99,108.35 158.99,108.61 v1(159.04,108.66) 159.41,109.03 159.92,109.03 159.98,108.96 160.36,108.96
  BOTTOM w0.114: 160.36,108.96 161.07,108.96 161.4,109.29 163.26,109.29 163.46,109.09 163.46,108.9 R624.1 164.09,109.14 165.26,109.14 R625.2 ; v1(42,48.89) 42,50.16 45.94,54.1 v3(45.94,54.66) v1(45.94,61.51)
SRTC_RST#: length 177.3
  TOP w0.114: v1(84.67,75.43) 85.06,75.04 C382.1 85.31,74.67 85.7,74.28 R300.2 ; PQ6059.3 174.59,48.59 v1(170.07,53.11) ; v1(150,76.2) 150,76.27 146.55,79.73 146.55,89.89 145.38,91.05 145.38,104.57 144.92,105.02 144.92,110.74 145,110.82 145,114.42 145.02,114.45 145.02,115.21 145.25,115.44 147.51,115.44 147.76,115.18 147.76,114.65 147.45,114.33 v2(147.29,114.33)
  BOTTOM w0.114: U35.AN18 146.99,114.03 v2(147.29,114.33) ; v1(84.67,75.43) v3(86.55,75.43) 86.55,72.39 84.29,70.13 84.29,68.83 90.08,63.04 94.91,63.04 97.42,65.55 97.42,68.55 100.57,71.7 103.82,71.7 108.32,76.2 v1(150,76.2) 154.57,76.2 159.83,70.94 163.56,70.94 168.49,66.01 168.49,54.68 v1(170.07,53.11)
SSD_ID: length 90.5
  TOP w0.114: CN9.7 221.6,101.75 215.07,95.22 211.37,95.22 210.73,95.86 203.89,95.86 202.83,94.79 200.98,94.79 199.43,93.24 195.19,93.24 191.83,96.59 191.83,101.49 191.43,101.9 v3(191.43,102.97) 191.43,104.03 190.58,104.89 190.27,104.89 v1(189.7,105.46)
  IN1 w0.127: v1(189.7,105.46) 189.17,105.99 189.17,109.73 187.19,111.71 186.38,111.71 182.92,115.17 182.92,115.21 182.18,115.94 182.18,120.68 181.48,121.38 181.48,121.88 181.07,122.29 181.07,123 180.68,123.39 180.68,124.27 179.9,125.05 179.9,126.03 177.97,127.96 175.12,127.96 174.82,128.27 173.85,128.27 v1(173.65,128.47)
  BOTTOM w0.114: R568.1 172.27,126.63 172.81,127.17 172.81,127.63 v1(173.65,128.47)
STRAP0: length 10
  BOTTOM w0.114: R527.1 186.26,139.45 185.89,139.82 185.89,141.1 R507.2 186.4,141.85 188.57,144.03 189.76,144.03 190.66,144.93 190.66,146.5 U34.D1
STRAP1: length 11.7
  BOTTOM w0.114: U34.D2 190.63,147.11 190.27,146.75 190.27,146.36 190.43,146.2 190.43,145.09 189.6,144.26 188.32,144.26 187.26,143.2 187.13,143.2 v1(186.55,142.62) 185.58,141.65 R499.1 184.83,141.21 184.83,139.74 185.08,139.49 R519.1
STRAP2: length 12.6
  BOTTOM w0.114: U34.E4 189.95,148.92 190.33,148.54 190.74,148.54 191.05,148.22 191.05,148 191.32,147.72 191.55,147.72 191.8,147.47 191.8,146.36 191.35,145.92 191.35,144.97 190.08,143.7 190.08,142.62 189.07,141.61 R508.2 188.3,141.1 188.3,139.96 R528.2
STRAP3: length 13.6
  BOTTOM w0.114: R526.1 184.49,139.96 184.49,141.22 184.1,141.61 R506.1 183.98,141.93 184.8,142.74 v1(185.15,142.74) 185.54,142.74 187.32,144.52 188.35,144.52 188.94,145.11 189.87,145.11 190.2,145.44 190.2,145.98 190.04,146.13 190.04,146.92 190.15,147.03 190.15,147.76 U34.E3
STRAP4: length 11.1
  BOTTOM w0.114: U34.D3 190.63,147.96 191,147.59 191,144.94 189.86,143.8 189.31,143.8 v1(188.15,142.64) 187.55,142.04 R500.1 187.85,141.65 188.05,141.45 188.05,139.98 R520.1
SUS0#: length 125.3
  IN2 w0.127: v1(163.66,50.67) 164.1,51.1 164.1,65.83 164.34,66.08 164.34,70.16 161.87,72.63 161.87,79.22 161.75,79.35 161.75,83.1 160.65,84.2 160.65,89.48 160.06,90.06 159.22,90.06 158.66,90.62 158.66,98.21 157.84,99.04 157.84,102.84 157.96,102.96 157.96,104.4 151.75,110.61 150.71,110.61 150.48,110.84 150.48,112.02 v2(150.95,112.49) ; v1(189.34,28.19) 192.62,31.47 192.62,37.9 v1(193.43,38.71)
  BOTTOM w0.114: U45.83 v1(193.43,38.71) ; v1(189.34,28.19) 189.06,28.47 185.41,28.47 v3(185.28,28.6) 185,28.88 179.62,28.88 178.32,30.17 172.63,30.17 168.52,34.29 168.52,44.55 166.59,46.48 166.59,48.08 165.8,48.87 165.27,48.87 164.63,49.5 164.63,49.7 v1(163.66,50.67) ; v2(150.95,112.49) 150.54,112.08 U35.AT11
SUSACK#_R: length 23.1
  IN1 w0.132: v2(150.95,113.1) 151.15,113.1 151.42,112.82 151.42,111.55 151.98,110.99 151.98,110.93 152.35,110.56 152.35,109.87 153.62,108.59 155.53,108.59 156.87,107.24 160.63,107.24 160.77,107.39 162.56,107.39 162.63,107.31 165.29,107.31 167.27,109.29 v1(167.27,109.52)
  BOTTOM w0.114: U35.AP11 150.66,113.38 v2(150.95,113.1) ; v1(167.27,109.52) 167.27,109.85 167.85,110.43 R617.1
SUSB#: length 345.3
  TOP w0.114: v1(200.6,43.56) 200.46,43.42 196.11,43.42 195.2,42.51 192.76,42.51 190.63,44.64 190.63,47.72 191.03,48.12 191.03,58.36 v1(186.02,63.37) ; U50.2 49.54,13.25 48.98,12.7 v1(48.98,11.43) 48.98,9.51 49.1,9.39 U49.2 ; PQ6057.2 90.94,28.89 v1(91.39,28.44) ; v1(164.5,81.45) 163.79,82.15 163.79,82.94 162.56,84.18 160.82,84.18 160.36,84.64 160.36,87.01 161,87.65 161,89.17 162.37,90.53 163.15,90.53 163.69,91.07 163.69,91.32 164.3,91.93 164.3,94.07 163.83,94.54 163.83,94.54 162.16,96.2 159.48,96.2 157.05,98.63 154.09,98.63 151.24,101.48 151.24,103.93 150.9,104.28 150.9,104.83 151.22,105.15 151.22,108.96 150.83,109.36 150.83,109.71 149.54,110.99 149.54,112.64 v2(149.12,113.06) ; v1(173.32,77.97) 173.32,78.74 173.61,79.03 174.36,79.03 R282.2 ; U47.2 195.52,85.64 194.95,85.07 194.64,85.07 194.48,84.9 194.48,84.2 194.17,83.89 193.84,83.89 193.03,84.7 190.41,84.7 190.33,84.63 189.27,84.63 188.81,85.09 184.14,85.09 v1(184.09,85.14)
  IN1 w0.127: v1(173.32,77.97) 173.32,78.69 170.63,81.38 164.57,81.38 v1(164.5,81.45)
  IN2 w0.127: v1(200.6,43.56) 200.34,43.56 200.04,43.25 198.34,43.25 197.07,41.98 195.54,41.98 194.63,42.9 193.38,42.9 191.58,41.09 191.58,32.18 188.84,29.43 188.84,29.43 188.33,28.93 181.88,28.93 176.97,33.83 174.95,33.83 172.77,31.65 172.77,31.05 171.64,29.92 92.88,29.92 91.4,28.44 v1(91.39,28.44) 91.39,28.43 85.51,22.55 85.51,18.74 78.6,11.83 73.06,11.83 69.04,7.82 67.67,7.82 66.69,6.84 66.69,5.39 66.19,4.89 59.54,4.89 58.36,6.07 57.4,6.07 52.17,11.3 49.11,11.3 v1(48.98,11.43) ; v1(179.77,74.27) 179.77,73.7 180.57,72.89 181.59,72.89 183.34,71.14 183.34,65.39 185.36,63.37 v1(186.02,63.37)
  BOTTOM w0.114: v1(184.09,85.14) 183.81,85.14 182.56,83.89 182.56,74.21 182.21,73.86 182.21,73.86 181.55,73.2 180.35,73.2 179.77,73.78 v1(179.77,74.27) 180.99,75.48 v3(180.99,75.71) 180.99,77.16 179.16,78.99 178.07,78.99 177.88,78.8 177.88,78.16 177.35,77.64 177.35,77.24 177.05,76.94 176.26,76.94 175.22,77.97 v1(173.32,77.97) ; U45.119 202.71,44.38 201.89,43.56 v1(200.6,43.56)
  BOTTOM w0.127: v2(149.12,113.06) U35.AP15
SUSC#: length 163.9
  TOP w0.114: v1(172.52,84.16) 172.52,82.96 172.94,82.54 172.94,82.29 173.22,82.01 173.55,82.01 173.91,81.66 174.55,81.66 R274.2 ; U48.2 220.94,22.73 220.31,23.36 215.35,23.36 213.45,25.27 213.45,41.14 v1(213.96,41.65) 213.96,43.56 212.14,45.37 209.18,45.37 208.55,44.74 208.55,44.61 207.95,44.02 206.32,44.02 205.38,43.08 204.37,43.08 202.63,44.82 200.42,44.82 199.25,43.65 196.02,43.65 195.1,42.73 192.86,42.73 191.67,43.93 191.67,44.94 190.86,45.75 190.86,47.62 191.26,48.02 191.26,58.73 186.11,63.88 v1(185.48,63.88)
  IN2 w0.127: v1(185.48,63.88) 185.25,63.88 183.59,65.54 183.59,71.25 181.69,73.15 180.68,73.15 180.38,73.45 v1(180.38,74.06)
  BOTTOM w0.076: U35.BA16 147.83,109.1 147.83,107.11 148.72,106.22 149.52,106.22 149.8,105.94 150.74,105.94 150.85,105.83 151.51,105.83 151.86,105.48 152.96,105.48 153.12,105.32 153.95,105.32 154.38,104.9 154.38,103.1
  BOTTOM w0.114: U45.18 209.27,37.11 209.75,37.6 209.75,39.35 210.4,40 212.31,40 v1(213.96,41.65) ; 154.38,103.1 154.38,101.48 155.73,100.14 155.73,99.39 156.13,98.99 156.13,95.25 158.63,92.75 158.63,90.6 159.06,90.17 161.48,90.17 162.7,88.94 163.48,88.94 166.77,85.65 170.71,85.65 172.2,84.16 v1(172.52,84.16) 172.64,84.16 173.06,84.57 176.28,84.57 v3(179.84,81.01) 181.5,79.35 181.5,75.18 v1(180.38,74.06)
SUSCLK: length 93
  TOP w0.114: v1(150.38,105.38) 150.23,105.23 150.23,104.19 150.79,103.63 150.79,101.27 154.9,97.15 154.9,96.31 155.33,95.89 v1(157.37,95.89) ; v1(164.5,80.16) 164.5,77.46 167.75,74.21 169.68,74.21 170.62,73.27 171.79,73.27 171.97,73.45 176.19,73.45 176.62,73.02 v1(176.87,73.02)
  IN1 w0.127: v1(164.5,80.16) 164.25,80.16 162.7,81.71 162.21,81.71 161.44,82.48 161.44,84.13 161.89,84.58 161.89,85.87 157.98,89.78 157.98,93.19 157.37,93.8 v1(157.37,95.89)
  IN2 w0.127: v1(190.21,88.13) 189.45,87.37 182.59,87.37 179.86,84.64 179.86,82.86 177.91,80.92 176.87,80.92 175.54,79.59 175.54,77.17 177.51,75.2 177.51,73.66 v1(176.87,73.02)
  BOTTOM w0.076: U35.BA17 147.07,108.75 147.5,108.32 147.5,106.93 148.54,105.89 149.38,105.89 149.89,105.38 v1(150.38,105.38)
  BOTTOM w0.114: U43.2 193.12,84.45 193.37,84.2 R716.2 192.49,82.67 191.38,83.79 191.38,85.01 189.83,86.56 v3(189.83,87.22) 189.83,87.75 v1(190.21,88.13)
SUSD: length 153.9
  TOP w0.114: v1(157.65,137.16) 157.67,137.16 158.08,136.75 158.08,134.11 159.14,133.04 163.72,133.04 164.78,131.97 165.65,131.97 168.08,129.54 168.08,129.18 169.71,127.55 171.28,127.55 172.5,126.34 172.5,125.27 173.11,124.66 v1(173.32,124.66) ; v1(186.91,81.78) 192.21,81.78 193.74,80.26 197.95,80.26 201.64,76.58 201.64,75.56 201,74.93 PR142.2 201.64,74.57 201.73,74.66 PC101.2 202.91,74.66 203,74.57 PR143.2 v3(203.54,73.53) 202.91,72.89 PQ8.3
  IN1 w0.127: v1(173.32,124.66) 174.28,123.69 176.22,123.69 178.15,121.76 178.15,121.04 178.51,120.68 178.51,117.08 179.22,116.37 179.22,112.61 178.8,112.19 178.8,110.18 179.86,109.13 179.86,108.24 184.11,103.98 184.11,101.88 183.92,101.68 183.92,101.23 183.79,101.1 183.79,91.11 183.51,90.83 183.51,88.7 185.69,86.52 185.69,85.06 186.91,83.84 v1(186.91,81.78) ; v1(128.36,142.44) 129.22,142.44 129.76,141.91 136.87,141.91 139.56,139.21 143.6,139.21 144.08,139.7 151.32,139.7 152.97,138.04 156.76,138.04 v1(157.65,137.16) ; v1(114.08,143.71) 114.9,144.52 v1(117.59,144.52)
  BOTTOM w0.114: v1(114.08,143.71) 113.02,144.78 107.94,144.78 107.28,144.12 PQ23.2 ; v1(128.36,142.44) 127.19,143.61 121.45,143.61 120.33,144.73 118.91,144.73 118.71,144.52 v1(117.59,144.52)
SUSLED#: length 191
  TOP w0.508: R433.1 v1(60.41,10.54) R427.1
  IN1 w0.127: v1(211.7,31.31) 211.49,31.11 211.49,24.79 211.89,24.39 211.89,20.04 207.31,15.46 197.78,15.46 197.49,15.75 194.66,15.75 193.51,14.6 193.51,11.15 192.39,10.04 174.31,10.04 165.29,19.05 128.92,19.05 119.1,28.86 99.71,28.86 97.25,26.4 90.27,26.4 83.86,19.99 v1(82.21,19.99)
  IN2 w0.127: v1(60.41,10.54) 61.18,11.3 69.81,11.3 71.59,13.08 75.73,13.08 82.21,19.55 v1(82.21,19.99)
  BOTTOM w0.114: v1(211.7,31.31) 211.16,31.85 211.16,32 v1(210.99,32.18) 210.85,32.32 210.16,32.32 209.36,33.11 U45.28
SUSON: length 120.3
  TOP w0.114: v1(177.69,76.96) 178.16,76.49 181.2,76.49 182.2,77.49 190.74,77.49 192.28,79.03 194.99,79.03 196.56,77.47 196.56,73.3 v1(197.8,72.06) 198.06,71.8 PQ6.2 ; U48.4 220.62,23.38 220.46,23.54 220.46,24.46 220.76,24.76 R790.1 221.19,27.86 218.04,31 218.04,44.55 217.54,45.05 216.93,45.05 216.22,45.76 215.62,46.36 210.11,46.36 209.49,46.99 204.28,46.99 203.87,46.58 203.19,46.58 v1(202.73,47.04)
  IN1 w0.127: v1(177.69,76.96) 177.13,76.4 177.13,75.56 174.84,73.27 174.84,65.15 v1(175.22,64.77)
  BOTTOM w0.114: v1(197.8,72.06) v3(201.74,72.06) 203.49,72.06 208.05,67.5 208.05,53.78 207.4,53.13 205.8,53.13 205.04,52.37 205.04,51.56 204.18,50.69 203.47,50.69 202.81,50.03 202.73,50.03 202.48,49.78 202.48,48.23 202.73,47.98 v1(202.73,47.04) ; v1(175.22,64.77) 173.81,64.77 173.64,64.94 PR305.1
SUSON_EC: length 46.1
  TOP w0.114: v1(203.39,47.04) 203.6,47.25 210.36,47.25 210.99,46.61 215.69,46.61 216.87,45.44 217.49,45.44 218.27,44.65 218.27,31.34 221.97,27.65 R790.2 223.13,24.76 224.09,23.8 224.09,22.47 223.7,22.08 U48.1
  BOTTOM w0.114: R739.1 203.39,48.27 v1(203.39,47.04) 203.39,46.73 203.11,46.46 U45.120
SYS_HWPG: length 166.7
  TOP w0.114: v1(201.26,32.51) 201.26,34.54 201.54,34.82 D19.1
  IN1 w0.127: v1(69.94,57.96) 70.57,57.32 74.69,57.32 83.01,49.01 83.01,48.55 83.53,48.03 87.54,48.03 100.72,34.84 167.27,34.84 170.7,31.42 170.7,30.73 173.94,27.49 189.41,27.49 195.6,21.31 202.37,21.31 203.38,22.31 203.38,24 201.26,26.12 v1(201.26,32.51)
  BOTTOM w0.114: PR6283.2 69.9,55.99 69.74,56.16 69.4,56.16 69.25,56.31 v1(69.25,56.51) 69.25,57.27 v1(69.94,57.96)
SYS_PEX_RST: length 22.2
  TOP w0.114: v1(175.22,130.2) 175.31,130.28 U10.4 ; R132.2 191.94,134.55 R143.2 191.85,134.37 191.6,134.62 187.83,134.62 187.61,134.39 187.61,133.94 185.24,131.57 182.46,131.57 v1(181.52,130.63) v1(181.06,130.17)
  IN1 w0.127: v1(181.06,130.17) 179.79,128.9 176.7,128.9 175.84,129.75 175.67,129.75 v1(175.22,130.2)
SYS_PEX_RST_MON#: length 25
  TOP w0.114: R95.1 195.52,144.5 195.49,144.52 v1(195.49,144.8) 194.22,146.07 194.22,146.5 193.38,147.34 193.38,150.19 192.13,151.45 190.8,151.45 190.59,151.66 190.59,152.35 v1(190.23,152.7) ; R143.1 192.54,134.02 192.54,134.18 192.83,134.47 R142.2 193.85,134.47 194.02,134.64 U7.2 194.02,139.54 v1(193.89,139.67)
  TOP w0.127: R95.1 195.3,143.77 v1(194.93,143.4)
  IN2 w0.127: v1(194.93,143.4) 194.93,140.58 194.35,140 194.22,140 v1(193.89,139.67)
  BOTTOM w0.114: v1(190.23,152.7) 189.83,153.1 U34.E9
SYS_PWROK: length 114.2
  TOP w0.114: v1(181.95,87.88) 181.32,88.51 181.32,90.31 181.17,90.46 174.33,90.46 173.65,89.78 172.68,89.78 172.05,90.42 171.41,90.42 167.98,93.85 v1(167.09,93.85) ; v1(160.55,137.38) 160.55,138 R113.1 161.4,137.55 161.4,137.18 161.01,136.79 U8.4
  IN1 w0.127: v1(152.36,101.72) 153.89,100.2 154.27,100.2 155.36,99.11 155.36,98.52 157.49,96.4 157.58,96.4 157.87,96.1 157.87,96.01 159.39,94.49 164.44,94.49 164.75,94.8 165.13,94.8 166.08,93.85 v1(167.09,93.85) ; v1(172.38,123.24) 172.52,123.24 173.61,122.14 175.57,122.14 176.6,121.12 176.6,120.38 176.95,120.04 176.95,118.92 176.7,118.66 176.7,116.71 177.63,115.77 177.63,113.23 176.26,111.86 176.26,109.55 177.3,108.5 177.3,106.93 181.27,102.97 181.27,101.42 180.94,101.09 180.94,97.81 180.76,97.63 180.76,92.12 181.19,91.69 181.19,88.83 181.95,88.07 v1(181.95,87.88)
  BOTTOM w0.076: R643.1 152.62,103.5
  BOTTOM w0.114: v1(152.36,101.72) 152.6,101.96 152.6,103.48 152.62,103.5 ; v1(172.38,123.24) 172.07,123.24 171.72,123.59 171.72,125.01 v1(172.25,125.54) 172.35,125.64 172.35,125.9 173.29,126.84 174.43,126.84 174.71,127.12 174.71,129.03 173.95,129.79 173.77,129.79 172.8,130.76 172.8,130.84 171.44,132.2 171.44,133.32 170.7,134.06 169.58,134.06 169.33,134.31 169.33,134.98 169.1,135.21 168.14,135.21 167.78,134.84 167.3,134.84 167.21,134.76 164.82,134.76 164.12,134.06 162.45,134.06 162.34,134.17 R560.1 162.34,134.55 161.38,135.5 160.88,135.5 R556.1 160.87,136.42 v3(160.62,136.67) 160.55,136.74 v1(160.55,137.38)
SYS_PWROK_R: length 14
  TOP w0.114: v1(161.61,134.51) 161.76,134.67 163,134.67 v1(163.13,134.79) 163.31,134.97 R131.1
  BOTTOM w0.076: 157.49,132.76 157.35,132.62 155.41,132.62 154.23,131.44 154.23,130.24 U35.B6
  BOTTOM w0.114: 157.49,132.76 159.29,134.56 159.29,134.95 R555.1 159.9,135.51 160.68,134.73 R556.2 161.39,134.73 v1(161.61,134.51)
SYS_RESET#: length 102.7
  TOP w0.114: R267.2 189.18,83.71 192.7,83.71 194.5,81.91 196.38,81.91 199,84.53 199,90.98 197.24,92.73 194.98,92.73 191.27,96.44 191.27,101.09 190.84,101.52 190.84,103.91 190.36,104.39 189.62,104.39 189.22,104.8 189.22,105.71 188.83,106.1 186.96,106.1 185.94,107.12 183.6,107.12 182.72,108 182.72,108.9 182.18,109.44 182.18,112.92 181.37,113.74 181.37,115.2 181.65,115.48 181.65,120.65 180.94,121.36 180.94,122.7 180.49,123.15 180.49,127.7 178.88,129.31 178.88,130.55 178.6,130.83 178.6,132.41 178.78,132.58 178.78,133.22 v1(178.65,133.35)
  IN1 w0.127: v1(168.81,134.08) 169.42,133.47 170.14,133.47 170.54,133.87 177.95,133.87 178.47,133.35 v1(178.65,133.35)
  BOTTOM w0.114: v1(168.81,134.08) 168.01,133.29 167.04,133.29 166.96,133.37 R561.2 166.59,133.85 166.43,133.7 166.43,133.32 165.86,132.76 164.73,132.76 163.93,133.56 162.24,133.56 162.16,133.64 160.06,133.64 158.23,131.81 155.35,131.81 154.87,131.34 154.87,130.52 154.64,130.29 U35.B5
SYS_SHDN#: length 399.8
  TOP w0.114: Q5.3 163.28,157.73 163.79,158.24 164.81,158.24 165.19,157.86 165.19,156.26 v3(164.73,155.8) 164.44,155.51 164.44,154.9 160.92,151.38 160.92,151.1 159.84,150.01 159.84,148.45 160.11,148.18 160.11,146.25 162.12,144.24 162.12,139.62 164.33,137.41 164.59,137.41 168.4,133.6 169.35,133.6 170.37,132.58 171.14,132.58 172.81,130.92 172.81,130.64 173.65,129.79 174.82,129.79 177.74,126.87 v1(178.4,126.87) ; PQ14.3 66.64,61.34 v1(65.49,62.48) ; v1(103.04,23.52) 101.31,23.52 93.92,30.91 93.92,36.09 92.93,37.08 92.93,42.01 84.26,50.67 84.26,55.37 v1(82.92,56.71)
  IN1 w0.127: v1(178.4,126.87) 179.64,125.62 179.64,124.95 180.4,124.19 180.4,123.31 180.82,122.9 180.82,122.19 181.23,121.78 181.23,121.27 181.9,120.6 181.9,115.86 182.59,115.18 182.59,115.14 182.64,115.09 182.64,115.08 186.27,111.45 187.08,111.45 188.89,109.65 188.89,105.99 187.43,104.53 187.43,92.45 188.67,91.2 188.67,87.2 194.4,81.47 195.9,81.47 198.98,78.39 v1(198.98,77.59) ; v1(213.19,74.49) 212.89,74.19 212.89,72.34 216.19,69.03 216.19,67.74 218.86,65.07 218.86,62.18 220.43,60.6 220.43,52.83 218.69,51.09 218.69,44.05 216.56,41.92 216.56,33.23 212.89,29.56 212.89,25.55 214.15,24.29 214.15,17.71 209.82,13.38 195.46,13.38 195.03,12.95 195.03,10.66 192.75,8.38 173.54,8.38 166.69,15.24 130.5,15.24 122.04,23.69 103.1,23.69 103.04,23.63 v1(103.04,23.52)
  IN2 w0.127: v1(82.92,56.71) 77.69,61.95 66.03,61.95 v1(65.49,62.48)
  BOTTOM w0.114: v1(198.98,77.59) 200.38,78.99 206.59,78.99 206.72,78.86 206.72,74.93 208.62,73.02 211.72,73.02 v1(213.19,74.49)
  BOTTOM w0.203: PU6010.6 67.71,54.72 68.24,55.25 68.24,56.27 67.7,56.81 67.7,59.41 67.04,60.07 66.13,60.07 65.8,59.74 PR6280.2 64.67,58.86 PR6278.2 64.5,59.02 64.5,61.49 v1(65.49,62.48)
SYSTEM_AGND:
  vias: v1(68.34,58.24)
TEMP_MBAT: length 290.4
  TOP w0.114: v1(162.29,197.2) 162.27,197.18 PR8.2 PR9.1 ; PR12.1 210.54,195.08 210.73,195.27 v1(211.11,195.27)
  IN1 w0.127: v1(212.05,200.78) 211.29,201.54 209.89,201.54 209.26,200.91 208.5,200.91 207.86,201.54 205.32,201.54 204.69,200.91 203.03,200.91 202.36,201.58 194.59,201.58 194.37,201.37 190.36,201.37 190.13,201.6 166.69,201.6 v1(162.29,197.2)
  IN2 w0.127: v1(204.71,39.44) 205.07,39.8 213.45,39.8 221.27,31.97 222.41,31.97 223.66,33.23 223.66,39.98 223,40.64 223,44.44 218.59,48.85 218.59,56.27 219.3,56.98 219.3,87.41 223.15,91.26 228.45,91.26 230.09,92.9 230.09,108.83 226.4,112.52 223.42,112.52 219.29,116.65 219.29,125.38 218.16,126.51 218.16,131.21 217.39,131.98 217.39,146.2 220.83,149.64 221.58,149.64 221.82,149.4 223.91,149.4 224.49,149.97 224.49,178.82 215.53,187.78 215.53,190.73 212.53,193.72 212.53,194.09 211.35,195.27 v1(211.11,195.27) 210.71,195.68 210.71,200.96 210.8,201.05 211.78,201.05 v1(212.05,200.78)
  BOTTOM w0.114: U45.73 194.13,34.71 195.33,35.91 196.89,35.91 197.85,36.87 199.4,36.87 202.08,39.54 204.61,39.54 v1(204.71,39.44)
TERM9:
  vias: v1(20.15,97.79) v1(20.15,97.02) v1(20.15,96.26) v3(20.79,98.73)
TESTMODE: length 5.6
  TOP w0.114: R79.1 170.2,154.38 v1(170.29,154.48)
  BOTTOM w0.114: v1(170.29,154.48) 170.47,154.66 171.84,154.66 172.17,154.33 173.42,154.33 173.65,154.1 173.65,153.75 174.03,153.36 U34.AD9
TH_FAN_POWER: length 13.2
  TOP w0.762: 55.68,110.99 56.31,111.63 61.94,111.63 62.98,110.59 C723.2 64.32,110.49 C728.2 65.6,110.6 v4(66.38,110.6)
  BOTTOM w0.762: v4(66.38,110.6) CN8.1
THERM+: length 1.3
  TOP w0.114: v1(188.6,155.18) 188.6,155.73 TP3.1
  BOTTOM w0.102: U34.F12 188.83,155.42
  BOTTOM w0.114: 188.83,155.42 188.6,155.18 v1(188.6,155.18)
THERM-: length 3.4
  TOP w0.102: TP4.1 191.05,155.55 189.85,155.55 189.8,155.6 ; v1(189.41,155.98) 189.73,155.67
  TOP w0.114: 189.73,155.67 189.8,155.6
  BOTTOM w0.102: U34.E12 189.81,155.58 v1(189.41,155.98)
THRMTRIP#: length 70.6
  TOP w0.114: 162.27,159.51 162.27,159 162.01,158.75 162.01,156.34 v1(162.28,156.08)
  IN1 w0.127: v1(119.67,144.23) v1(119.67,155.22)
  IN2 w0.127: v1(119.67,155.22) 120.21,154.68 121.12,154.68 121.5,154.3 131.03,154.3 133.72,151.61 140.11,151.61 144.46,147.26 144.46,146.63 144.92,146.17 146.19,146.17 146.47,146.45 149.62,146.45 149.88,146.19 151.86,146.19 154.58,148.91 154.58,149.71 157.84,152.97 160.68,152.97 162.65,154.94 162.65,155.71 v1(162.28,156.08)
  BOTTOM w0.114: R488.1 v1(162.28,156.08) ; R530.1 119.32,143.88 v1(119.67,144.23)
TP_DDR0_PARITY#: length 3.2
  TOP w0.114: TP21.1 127.47,110.18 126.71,110.94 126.71,111.37 127.09,111.76 v2(127.17,111.76)
  BOTTOM w0.127: v2(127.17,111.76) U35.AT52
TP_DDR1_PARITY#: length 1.4
  TOP w0.114: TP18.1 132.68,113.29 132.68,113.78 v2(132.66,113.79)
  BOTTOM w0.114: U35.AP43 132.25,113.38 v2(132.66,113.79)
TP_INT: length 9.7
  TOP w0.114: R7.1 145.89,196.97 Q1.1 145.38,195.7 v1(145.38,195.58) 145.11,195.31 R8.2
  BOTTOM w0.114: R443.2 145.25,194.44 145.25,194.86 v3(145.25,194.86) 145.25,195.45 v1(145.38,195.58)
  BOTTOM w0.127: R443.2 144.61,196.02 CN5.1
TP_INT_PCH: length 135.5
  TOP w0.114: Q1.3 147.92,197.23 147.92,196.72 147.46,196.26 146.6,196.26 146.19,195.86 v1(146.19,195.6) 145.89,195.31 R8.1 ; v1(172.71,132.53) 176.31,132.53 177.13,133.35 177.69,133.35 178.02,133.68 178.02,134.82 178.52,135.33 178.52,136.57 v1(178.09,137)
  IN1 w0.127: v1(178.09,137) 177.9,136.81 175.33,136.81 174.42,135.9 173.89,135.9 172.25,137.54 170.32,137.54 163.83,144.02 163.83,149.18 164.38,149.73 164.38,151.03 165.62,152.27 166.58,152.27 167,152.69 167,156.97 165.32,158.66 165.32,169.69 164.3,170.7 164.3,175.84 165.16,176.7 165.16,180.76 160.36,185.55 160.36,187.19 155.85,191.7 151.87,191.7 150.6,192.97 147.32,192.97 146.19,194.1 v1(146.19,195.6)
  BOTTOM w0.076: 160.36,119.17 159.97,118.78 159,118.78 157.85,119.93 156.72,119.93 156.59,119.87 156.17,119.87 156.04,119.74 155.77,119.74 U35.AB3
  BOTTOM w0.114: v1(172.71,132.53) 172.89,132.53 174.64,130.78 174.64,130.17 175.49,129.31 175.49,122.64 173.79,120.94 173.79,120.23 173.65,120.09 171.41,120.09 v3(171.27,120.23) 170.87,120.63 169.49,120.63 169.1,120.24 169.1,119.68 168.82,119.4 168.16,119.4 168.03,119.53 168.03,120.09 167.77,120.34 166.54,120.34 166.01,120.87 165.65,120.87 165.4,120.62 165.4,120.55 164.7,119.85 161.98,119.85 161.72,119.58 161,119.58 160.97,119.6 160.79,119.6 160.36,119.17
TP_PWR:
  vias: v1(132.47,187.27) v1(133.31,187.57) v1(133.95,187.57)
TP_RST#: length 7
  BOTTOM w0.114: CN5.29 133.05,188.08 134.2,188.08 134.84,187.45 134.84,185.41 R444.1 134.63,184.65 v3(134.56,184.58)
TPCLK: length 35.4
  TOP w0.114: R411.1 v1(203.42,18.54) R415.2
  IN2 w0.127: v1(203.42,18.54) 203.67,18.79 203.67,19.3 202.97,20 201.05,20 200.01,21.04 200.01,25.69 201.14,26.82 201.14,29.37 201.93,30.16 201.93,34.61 200.53,36 200.53,38.57 199.91,39.19 199.91,40.1 v1(199.73,40.28)
  BOTTOM w0.114: v1(199.73,40.28) 199.57,40.44 194.7,40.44 193.95,41.19 193.22,41.19 193.15,41.11 U45.89
TPCLK_R: length 3.2
  TOP w0.114: R411.2 203.42,20.7 v1(203.67,20.95)
  BOTTOM w0.114: C787.2 204.18,21.46 v1(203.67,20.95) 203.04,20.33 CN17.7
TPD_EN: length 4.8
  TOP w0.114: v1(209.77,16.89) 209.77,17.78 209.63,17.91 R190.2
  BOTTOM w0.114: v1(209.77,16.89) 209.77,17.39 209.05,18.12 CN17.1
TPD_INT#: length 131.5
  TOP w0.114: v1(176.19,124.96) 176.19,124.76 176.88,124.07 R164.1 176.88,122.75 177.06,122.58 Q20.1 179.04,122.58 R349.2
  IN1 w0.127: v1(204.69,22.91) 203.89,23.71 203.89,24.21 201.8,26.29 201.8,29.32 203.35,30.87 203.35,32.5 200.43,35.42 200.43,38.82 199.16,40.09 199.16,41.24 199.85,41.92 199.85,45.65 199.56,45.94 199.56,47.14 198.41,48.28 198.41,49.35 197.68,50.08 197.68,51.3 197,51.98 196.25,51.98 195.22,53 195.22,58.86 196.67,60.31 196.67,61.85 198.02,63.2 198.02,71.21 196.33,72.9 196.33,77.69 194.33,79.69 193.51,79.69 192.16,81.05 190.96,81.05 186.62,85.38 186.62,89.99 184.76,91.85 184.76,94.22 185.59,95.04 185.59,104.19 184.53,105.24 184.53,105.84 182.68,107.69 182.68,109.33 181.19,110.82 181.19,111.49 180.11,112.57 180.11,116.74 179.4,117.45 179.4,121.09 179.04,121.45 179.04,122.13 176.51,124.66 176.5,124.66 v1(176.19,124.96)
  BOTTOM w0.114: CN17.2 208.05,21.66 206.79,22.91 v3(206.77,22.91) v1(204.69,22.91)
TPD_INT#_D: length 33.3
  TOP w0.114: R177.1 178.9,118.47 178.9,121.41 178.75,121.56 Q20.3 ; Q20.3 176.03,122.3 176.1,122.36 R164.2 ; Q20.3 176.03,120.92 175.81,120.69 v1(175.11,120.69)
  IN1 w0.127: v1(168.45,119.91) 168.9,119.91 169.24,119.58 169.84,119.58 170.36,120.1 174.12,120.1 174.56,120.54 174.96,120.54 v1(175.11,120.69)
  BOTTOM w0.076: U35.W4 155.02,120.64 155.18,120.48 155.5,120.48 155.69,120.57 155.98,120.57 156.06,120.54 156.27,120.54 156.37,120.59 156.59,120.59 156.7,120.54 158.8,120.54 159.27,120.06
  BOTTOM w0.127: v1(168.45,119.91) 168.45,120.1 167.93,120.62 166.64,120.62 166.16,121.1 165.55,121.1 165.16,120.71 165.16,120.65 164.6,120.08 161.89,120.08 161.69,119.88 160.64,119.88 160.44,119.68 159.65,119.68 159.27,120.06
TPDATA: length 36.3
  TOP w0.114: R412.1 v1(204.56,18.54) R416.2
  IN2 w0.127: v1(200.37,40.28) 200.19,40.1 200.19,39.3 200.81,38.68 200.81,36.12 202.21,34.72 202.21,30.04 201.42,29.25 201.42,26.7 200.29,25.57 200.29,21.15 201.17,20.28 203.09,20.28 203.95,19.42 203.95,19.15 v1(204.56,18.54)
  BOTTOM w0.114: U45.90 193.05,41.52 193.11,41.45 194.06,41.45 194.81,40.71 199.92,40.71 200.34,40.28 v1(200.37,40.28)
TPDATA_R: length 3.3
  TOP w0.114: R412.2 204.56,20.19 204.3,20.44 v1(204.3,20.92)
  BOTTOM w0.114: C788.2 204.48,20.92 v1(204.3,20.92) 204.04,20.66 CN17.6
TPM_BADD: length 4.4
  BOTTOM w0.114: U44.9 216.71,56.6 216.88,56.76 v1(216.88,56.99) R729.2 217.9,59.05 R726.2
TPM_CLKRUN#: length 2.3
  BOTTOM w0.114: U44.15 219.96,47.91 219.93,47.87 R743.1
TPM_LRESET#: length 13.3
  BOTTOM w0.114: R726.1 v3(220.14,57.83) 220.38,57.59 220.38,53.64 219.31,52.57 U44.16 219.31,48.02 218.78,47.49 R742.2
TPM_PP: length 4.9
  BOTTOM w0.114: R724.2 215.24,58.53 R728.2 215.53,57.82 v1(215.53,57.02) 215.53,56.43 215.41,56.31 U44.7
TS_EN: length 3.1
  BOTTOM w0.114: R751.1 142.46,192.27 142.76,192.58 v1(142.76,192.6) 143.18,193.03 R442.1 R443.1
TS_EN_C: length 217.9
  IN1 w0.127: v1(205.42,31.59) 204.17,32.85 204.17,36.24 204.37,36.44 204.37,37.21 203.87,37.71 203.87,39.69 203.97,39.79 203.97,40.71 203.68,41 203.68,44.76 206.22,47.3 206.22,48.88 206.78,49.44 206.78,51.36 208.94,53.52 208.94,64.11 205.69,67.36 205.69,69.43 200.81,74.3 200.81,78.02 199.61,79.22 199.61,80.26 196.37,83.5 194.17,83.5 191.2,86.47 191.2,87.85 192.06,88.71 192.43,88.71 192.98,88.17 193.29,88.17 193.64,88.51 193.64,96.06 193.13,96.57 193.13,98.71 193.26,98.84 193.26,107.41 192.98,107.69 192.98,107.87 192.72,108.12 192.67,108.12 192.27,108.53 192.27,108.56 190.46,110.36 190.44,110.36 187.77,113.03 186.85,113.03 184.65,115.23 184.65,115.28 183.45,116.47 183.45,123.34 182.31,124.48 182.31,124.81 181.85,125.27 181.85,126.96 182.82,127.93 182.82,132.83 179.09,136.56 177.4,136.56 177.15,136.31 175.18,136.31 174.52,135.64 173.78,135.64 172.15,137.28 170.21,137.28 163.58,143.92 163.58,149.29 164.13,149.84 164.13,151.14 165.53,152.54 166.49,152.54 166.75,152.8 166.75,156.84 165.06,158.53 165.06,169.58 164.05,170.6 164.05,175.95 164.9,176.8 164.9,180.65 160.11,185.45 160.11,187.07 155.73,191.45 151.66,191.45 150.39,192.72 146,192.72 v1(145.44,192.16)
  BOTTOM w0.114: R751.2 C800.1 143.72,190.87 144.14,191.29 144.57,191.29 v1(145.44,192.16) ; v1(205.42,31.59) 205.5,31.52 U45.32
TS_EN_R: length 2.3
  BOTTOM w0.114: R442.2 143.49,193.81 v1(142.74,194.56) 142.52,194.78 142.37,194.78 CN5.6
UART2_CTS#: length 89.5
  TOP w0.114: CN3.5 157.55,78.38 157.7,78.23 R290.1 159.01,78.66 159.68,78.66 160.74,77.59 163.07,77.59 168.03,72.64 v1(169.25,72.64)
  IN2 w0.127: v1(167.6,119.91) 168.06,120.37 168.64,120.37 168.92,120.09 168.92,119.33 170.83,117.42 170.83,116.51 170.85,116.48 170.85,116.25 171.41,115.69 171.92,115.69 172.78,114.83 172.78,112.32 177.18,107.93 177.18,104.24 177.57,103.84 177.57,99.1 176.29,97.82 176.29,92.38 172.21,88.3 170.64,88.3 167.86,85.51 167.86,84.7 168.16,84.4 168.16,83.55 167.89,83.28 167.89,78.32 168.36,77.85 168.36,76.5 169.23,75.63 169.23,74.62 168.68,74.07 168.68,72.96 169,72.64 v1(169.25,72.64)
  BOTTOM w0.076: U35.AD4 154.86,119 154.98,119.12 156.81,119.12 157.28,118.65 158.14,118.65 158.28,118.51 160.02,118.51 160.36,118.85
  BOTTOM w0.114: v1(167.6,119.91) v1(166.87,119.91) 166.51,119.91 166.4,120.01 165.19,120.01 164.79,119.62 162.08,119.62 161.81,119.35 160.86,119.35 160.36,118.85
UART2_RTS#: length 90.4
  TOP w0.114: CN3.4 157.69,79.38 157.7,79.37 R283.1 159.06,78.89 159.85,78.89 160.9,77.85 163.14,77.85 167.92,73.07 169.46,73.07 v1(169.89,72.64)
  IN2 w0.127: v1(169.71,120.09) 169.71,120.09 169.71,119.05 171.92,116.84 171.92,116.2 173.04,115.08 173.04,112.43 177.46,108.01 177.46,104.42 177.83,104.05 177.83,98.99 176.54,97.71 176.54,92.27 172.32,88.05 170.75,88.05 168.11,85.41 168.11,84.83 168.41,84.53 168.41,83.44 168.15,83.18 168.15,78.5 168.63,78.02 168.63,76.59 169.48,75.74 169.48,74.51 168.94,73.97 168.94,73.34 169.18,73.1 169.43,73.1 v1(169.89,72.64)
  BOTTOM w0.076: 160.36,118.53 160.09,118.26 159.6,118.26 159.03,117.69 158.27,117.69 157.52,118.44 155.79,118.44 U35.AD3
  BOTTOM w0.114: 160.36,118.53 160.91,119.07 161.89,119.07 162.21,119.39 164.89,119.39 165.28,119.79 166.31,119.79 166.87,119.22 167.85,119.22 168.08,119 169.41,119 v1(169.69,119.28) 169.71,119.3 169.71,120.09 v1(169.71,120.09)

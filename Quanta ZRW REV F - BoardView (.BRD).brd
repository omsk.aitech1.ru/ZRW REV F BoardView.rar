# Allegro board Quanta ZRW REV F - BoardView (.BRD).brd (continued)
## Nets (continued)
INT_HDMITX2P: C411.1 U35.F55
INT_HDMITX2P_C: CN12.1 R315.1 U18.30
INT_HDMITX2P_C_R: C411.2 U18.1
INTRUDER#: R249.1 U35.AP16
IOAC_LAN_WAKE#: R715.2 U45.87
IOAC_LANPWR#: R259.1 R260.2 U45.95
IOAC_RST#: R263.1 R680.1 U45.85
IOAC_WLAN_WAKE#: Q23.6 R243.1 R244.2 U45.16
IOAC_WLANPWR#: R230.1 R231.2 R710.1 R712.2 U45.35
IRQ_SERIRQ: R629.2 U35.AY11 U44.27 U45.5
ISEN1_B: PC18.1 PR19.1 PR188.2 PU1.9
ISEN2_B: PC17.1 PR18.2 PR189.1 PU1.10
ISL95857_COMP_A: PC24.2 PR199.1 PU1.16
ISL95857_COMP_B: PC21.2 PR195.1 PU1.4
ISL95857_COMP_C: PC37.2 PR216.1 PU1.24
ISL95857_FB_A: PR34.1 PR36.1 PR201.1 PU1.17
ISL95857_FB_B: PR23.1 PR24.1 PR194.1 PU1.5
ISL95857_FB_C: PR44.1 PR45.1 PR217.1 PU1.25
ISL95857_FCCM_A: PR42.2 PU1.21
ISL95857_FCCM_B: PR26.1 PU1.11
ISL95857_FCCM_C: PR46.2 PU1.29
ISL95857_IMON_A: PC23.1 PR202.1 PU1.14
ISL95857_IMON_B: PC22.1 PR198.1 PU1.2
ISL95857_IMON_C: PC36.1 PR207.1 PU1.23
ISL95857_ISUMN_A: PC34.2 PR211.1 PU1.20
ISL95857_ISUMN_B: PC19.1 PR192.2 PU1.8
ISL95857_ISUMN_C: PC40.2 PR220.1 PU1.28
ISL95857_NTC_A: PR235.1 PR236.1 PU1.15
ISL95857_NTC_B: PR226.1 PR227.1 PU1.3
ISL95857_PROG1: PR203.1 PU1.32
ISL95857_PROG2: PR206.1 PU1.31
ISL95857_PSYS: PR25.2 PU1.1
ISL95857_PWM1_B: PR27.1 PU1.12
ISL95857_PWM2_B: PR29.1 PU1.13
ISL95857_PWM_A: PR43.2 PU1.22
ISL95857_PWM_C: PR47.2 PU1.30
ISL95857_RTN_A: PC27.2 PC29.2 PR38.2 PR39.1 PU1.18
ISL95857_RTN_B: PC10.1 PC12.2 PR180.1 PR181.2 PU1.6
ISL95857_RTN_C: PC44.2 PC45.2 PR49.1 PR52.2 PU1.26
ISL95857_SCLK: PR35.2 PU1.37
ISL95857_SDA: PR40.1 PU1.35
ISL95857_VCC: PC32.1 PR204.2 PU1.34
ISL95857_VIN: PC35.1 PR212.2 PU1.33
ISL95857_VR_EN: PR28.1 PU1.40
ISL95857_VR_HOT: PR32.1 PU1.38
ISL95857_VR_READY: PR30.1 PU1.39
ISOLATEB: R261.1 R711.2 U15.20
ISUMN_A: PC30.2 PC31.1 PC33.1 PR41.2 PR208.1 PR211.2 PR214.1 PR243.2
ISUMN_B: PC14.1 PC17.2 PC18.2 PC20.1 PC134.2 PR17.1 PR21.1 PR22.1 PR182.1 PR192.1 PR241.1
ISUMN_C: PC38.2 PC39.1 PC43.1 PR48.2 PR219.1 PR220.2 PR221.1 PR242.2
ISUMP_A: PC30.1 PC31.2 PR205.2 PR208.2 PR215.1 PU1.19
ISUMP_B: PC20.2 PC134.1 PR20.1 PR22.2 PR190.1 PR193.2 PU1.7
ISUMP_C: PC38.1 PC39.2 PR218.2 PR219.2 PR222.1 PU1.27
IVDDO: C715.1 L20.1 L21.1 R637.2 U13.32
JTAG_TCK: R497.1 TP47.1 U34.AE5
JTAG_TDI: R489.1 TP46.1 U34.AE6
JTAG_TDO: TP45.1 U34.AF6
JTAG_TMS: R498.1 TP48.1 U34.AD6
JTAG_TRST#: R490.1 U34.AG4
KB_BL_LED: Q19.2 U45.113
KBSMI#: R567.1 R780.1 U45.15
L_SPK+: R404.2 U23.42
L_SPK+_1: C545.1 CN18.1 R404.1
L_SPK-: R406.2 U23.43
L_SPK-_1: C546.1 CN18.2 R406.1
LAN_MCT0: R251.2 U42.24
LAN_MCT1: R258.2 U42.21
LAN_MCT2: R262.2 U42.18
LAN_MCT3: R269.2 U42.15
LAN_MX0+: CN11.1 U42.23
LAN_MX0-: CN11.2 U42.22
LAN_MX1+: CN11.3 U42.20
LAN_MX1-: CN11.6 U42.19
LAN_MX2+: CN11.4 U42.17
LAN_MX2-: CN11.5 U42.16
LAN_MX3+: CN11.7 U42.14
LAN_MX3-: CN11.8 U42.13
LANVCC: C350.2 C354.1 C361.2 C365.2 C366.1 C367.2 C370.1 C377.2 Q39.2 R247.1 R248.2 R702.1 U15.11 U15.23 U15.32
LCDVCC: C29.2 C30.1 C33.2 C34.1 C35.2 R28.1 U1.1
LCDVCC_R: C580.2 C581.1 CN5.34 CN5.35 CN5.36 R28.2
LID#: D1.1 D23.2 MR1.2 R53.2 R435.1 R460.2
LINE1-L: C552.1 U23.22
LINE1-R: C549.1 U23.21
LINE1-VREFO-L: R421.2 U23.31
LINE1-VREFO-R: R418.2 U23.30
LM393_PIN2: PR146.2 PR262.2 PU4.2
LPC_LAD0: R659.2 R688.1 U44.26 U45.10
LPC_LAD0_C: CN10.64 R688.2
LPC_LAD1: R640.2 R690.1 U44.23 U45.9
LPC_LAD1_C: CN10.66 R690.2
LPC_LAD2: R653.2 R693.1 U44.20 U45.8
LPC_LAD2_C: CN10.68 R693.2
LPC_LAD3: R668.2 R696.1 U44.17 U45.7
LPC_LAD3_C: CN10.70 R696.2
LPC_LFRAME#: R699.2 U35.BA12 U44.22 U45.6
LPC_LFRAME#_C: CN10.73 R699.1
LPCPD: R744.2 U44.28
LPM_ZVM_N: PR280.1 R762.2
M_A_A0: JDIM2.98 U35.AY50
M_A_A1: JDIM2.97 U35.BB50
M_A_A2: JDIM2.96 U35.AY51
M_A_A3: JDIM2.95 U35.BA50
M_A_A4: JDIM2.92 U35.BB52
M_A_A5: JDIM2.91 U35.BA51
M_A_A6: JDIM2.90 U35.BA52
M_A_A7: JDIM2.86 U35.AW52
M_A_A8: JDIM2.89 U35.AY52
M_A_A9: JDIM2.85 U35.BB54
M_A_A10: JDIM2.107 U35.AT50
M_A_A11: JDIM2.84 U35.BA54
M_A_A12: JDIM2.83 U35.AW54
M_A_A13: JDIM2.119 U35.AU46
M_A_A14: JDIM2.80 U35.AY54
M_A_A15: JDIM2.78 U35.BA55
M_A_BS#0: JDIM2.109 U35.AU52
M_A_BS#1: JDIM2.108 U35.AT48
M_A_BS#2: JDIM2.79 U35.AY55
M_A_CAS#: JDIM2.115 U35.AU48
M_A_CKE0: JDIM2.73 U35.BA56
M_A_CKE1: JDIM2.74 U35.BB56
M_A_CLK0: JDIM2.101 U35.AT53
M_A_CLK0#: JDIM2.103 U35.AU53
M_A_CLK1: JDIM2.102 U35.AT55
M_A_CLK1#: JDIM2.104 U35.AU55
M_A_CS#0: JDIM2.114 U35.AU45
M_A_CS#1: JDIM2.121 U35.AU43
M_A_DQ0: JDIM2.5 U35.AL71
M_A_DQ1: JDIM2.4 U35.AL68
M_A_DQ2: JDIM2.18 U35.AN68
M_A_DQ3: JDIM2.16 U35.AN69
M_A_DQ4: JDIM2.7 U35.AL70
M_A_DQ5: JDIM2.6 U35.AL69
M_A_DQ6: JDIM2.15 U35.AN70
M_A_DQ7: JDIM2.17 U35.AN71
M_A_DQ8: JDIM2.23 U35.AR70
M_A_DQ9: JDIM2.22 U35.AR68
M_A_DQ10: JDIM2.33 U35.AU71
M_A_DQ11: JDIM2.36 U35.AU68
M_A_DQ12: JDIM2.21 U35.AR71
M_A_DQ13: JDIM2.24 U35.AR69
M_A_DQ14: JDIM2.35 U35.AU70
M_A_DQ15: JDIM2.34 U35.AU69
M_A_DQ16: JDIM2.42 U35.BB65
M_A_DQ17: JDIM2.39 U35.AW65
M_A_DQ18: JDIM2.53 U35.AW63
M_A_DQ19: JDIM2.52 U35.AY63
M_A_DQ20: JDIM2.40 U35.BA65
M_A_DQ21: JDIM2.41 U35.AY65
M_A_DQ22: JDIM2.51 U35.BA63
M_A_DQ23: JDIM2.50 U35.BB63
M_A_DQ24: JDIM2.59 U35.BA61
M_A_DQ25: JDIM2.56 U35.AW61
M_A_DQ26: JDIM2.70 U35.BB59
M_A_DQ27: JDIM2.68 U35.AW59
M_A_DQ28: JDIM2.57 U35.BB61
M_A_DQ29: JDIM2.58 U35.AY61
M_A_DQ30: JDIM2.67 U35.BA59
M_A_DQ31: JDIM2.69 U35.AY59
M_A_DQ32: JDIM2.130 U35.AY39
M_A_DQ33: JDIM2.131 U35.AW39
M_A_DQ34: JDIM2.140 U35.AY37
M_A_DQ35: JDIM2.142 U35.AW37
M_A_DQ36: JDIM2.129 U35.BB39
M_A_DQ37: JDIM2.132 U35.BA39
M_A_DQ38: JDIM2.141 U35.BA37
M_A_DQ39: JDIM2.143 U35.BB37
M_A_DQ40: JDIM2.146 U35.AY35
M_A_DQ41: JDIM2.148 U35.AW35
M_A_DQ42: JDIM2.158 U35.AY33
M_A_DQ43: JDIM2.160 U35.AW33
M_A_DQ44: JDIM2.147 U35.BB35
M_A_DQ45: JDIM2.149 U35.BA35
M_A_DQ46: JDIM2.157 U35.BA33
M_A_DQ47: JDIM2.159 U35.BB33
M_A_DQ48: JDIM2.163 U35.AY31
M_A_DQ49: JDIM2.166 U35.AW31
M_A_DQ50: JDIM2.176 U35.AY29
M_A_DQ51: JDIM2.174 U35.AW29
M_A_DQ52: JDIM2.165 U35.BB31
M_A_DQ53: JDIM2.164 U35.BA31
M_A_DQ54: JDIM2.177 U35.BA29
M_A_DQ55: JDIM2.175 U35.BB29
M_A_DQ56: JDIM2.191 U35.AY27
M_A_DQ57: JDIM2.193 U35.AW27
M_A_DQ58: JDIM2.183 U35.AY25
M_A_DQ59: JDIM2.181 U35.AW25
M_A_DQ60: JDIM2.192 U35.BB27
M_A_DQ61: JDIM2.194 U35.BA27
M_A_DQ62: JDIM2.180 U35.BA25
M_A_DQ63: JDIM2.182 U35.BB25
M_A_DQS0: JDIM2.12 U35.AM69
M_A_DQS1: JDIM2.29 U35.AT70
M_A_DQS2: JDIM2.47 U35.AY64
M_A_DQS3: JDIM2.64 U35.BA60
M_A_DQS4: JDIM2.137 U35.AY38
M_A_DQS5: JDIM2.154 U35.BA34
M_A_DQS6: JDIM2.171 U35.AY30
M_A_DQS7: JDIM2.188 U35.BA26
M_A_DQS#0: JDIM2.10 U35.AM70
M_A_DQS#1: JDIM2.27 U35.AT69
M_A_DQS#2: JDIM2.45 U35.BA64
M_A_DQS#3: JDIM2.62 U35.AY60
M_A_DQS#4: JDIM2.135 U35.BA38
M_A_DQS#5: JDIM2.152 U35.AY34
M_A_DQS#6: JDIM2.169 U35.BA30
M_A_DQS#7: JDIM2.186 U35.AY26
M_A_ODT0_DIMM: JDIM2.116 U35.AT45
M_A_ODT1_DIMM: JDIM2.120 U35.AT43
M_A_RAS#: JDIM2.110 U35.AU50
M_A_WE#: JDIM2.113 U35.AT46
M_B_A0: JDIM1.98 U35.BA46
M_B_A1: JDIM1.97 U35.AY46
M_B_A2: JDIM1.96 U35.AY47
M_B_A3: JDIM1.95 U35.BB46
M_B_A4: JDIM1.92 U35.BA47
M_B_A5: JDIM1.91 U35.AY48
M_B_A6: JDIM1.90 U35.BA48
M_B_A7: JDIM1.86 U35.AP48
M_B_A8: JDIM1.89 U35.BB48
M_B_A9: JDIM1.85 U35.AP50
M_B_A10: JDIM1.107 U35.AW46
M_B_A11: JDIM1.84 U35.AN48
M_B_A12: JDIM1.83 U35.AN50
M_B_A13: JDIM1.119 U35.BA43
M_B_A14: JDIM1.80 U35.AN52
M_B_A15: JDIM1.78 U35.AN53
M_B_BS#0: JDIM1.109 U35.BB44
M_B_BS#1: JDIM1.108 U35.BA44
M_B_BS#2: JDIM1.79 U35.AP52
M_B_CAS#: JDIM1.115 U35.AY43
M_B_CKE0: JDIM1.73 U35.AN56
M_B_CKE1: JDIM1.74 U35.AP55
M_B_CLK0: JDIM1.101 U35.AP45
M_B_CLK0#: JDIM1.103 U35.AN45
M_B_CLK1: JDIM1.102 U35.AP46
M_B_CLK1#: JDIM1.104 U35.AN46
M_B_CS#0: JDIM1.114 U35.BB42
M_B_CS#1: JDIM1.121 U35.AY42
M_B_DQ0: JDIM1.23 U35.AF65
M_B_DQ1: JDIM1.24 U35.AF64
M_B_DQ2: JDIM1.34 U35.AK65
M_B_DQ3: JDIM1.33 U35.AK64
M_B_DQ4: JDIM1.21 U35.AF66
M_B_DQ5: JDIM1.22 U35.AF67
M_B_DQ6: JDIM1.35 U35.AK67
M_B_DQ7: JDIM1.36 U35.AK66
M_B_DQ8: JDIM1.7 U35.AF70
M_B_DQ9: JDIM1.4 U35.AF68
M_B_DQ10: JDIM1.17 U35.AH71
M_B_DQ11: JDIM1.15 U35.AH68
M_B_DQ12: JDIM1.5 U35.AF71
M_B_DQ13: JDIM1.6 U35.AF69
M_B_DQ14: JDIM1.18 U35.AH70
M_B_DQ15: JDIM1.16 U35.AH69
M_B_DQ16: JDIM1.41 U35.AT66
M_B_DQ17: JDIM1.39 U35.AU66
M_B_DQ18: JDIM1.51 U35.AP65
M_B_DQ19: JDIM1.53 U35.AN65
M_B_DQ20: JDIM1.42 U35.AN66
M_B_DQ21: JDIM1.40 U35.AP66
M_B_DQ22: JDIM1.50 U35.AT65
M_B_DQ23: JDIM1.52 U35.AU65
M_B_DQ24: JDIM1.57 U35.AT61
M_B_DQ25: JDIM1.59 U35.AU61
M_B_DQ26: JDIM1.68 U35.AP60
M_B_DQ27: JDIM1.70 U35.AN60
M_B_DQ28: JDIM1.56 U35.AN61
M_B_DQ29: JDIM1.58 U35.AP61
M_B_DQ30: JDIM1.67 U35.AT60
M_B_DQ31: JDIM1.69 U35.AU60
M_B_DQ32: JDIM1.130 U35.AU40
M_B_DQ33: JDIM1.132 U35.AT40
M_B_DQ34: JDIM1.140 U35.AT37
M_B_DQ35: JDIM1.143 U35.AU37
M_B_DQ36: JDIM1.129 U35.AR40
M_B_DQ37: JDIM1.131 U35.AP40
M_B_DQ38: JDIM1.142 U35.AP37
M_B_DQ39: JDIM1.141 U35.AR37
M_B_DQ40: JDIM1.148 U35.AT33
M_B_DQ41: JDIM1.146 U35.AU33
M_B_DQ42: JDIM1.157 U35.AU30
M_B_DQ43: JDIM1.159 U35.AT30
M_B_DQ44: JDIM1.147 U35.AR33
M_B_DQ45: JDIM1.149 U35.AP33
M_B_DQ46: JDIM1.158 U35.AR30
M_B_DQ47: JDIM1.160 U35.AP30
M_B_DQ48: JDIM1.163 U35.AU27
M_B_DQ49: JDIM1.164 U35.AT27
M_B_DQ50: JDIM1.174 U35.AT25
M_B_DQ51: JDIM1.176 U35.AU25
M_B_DQ52: JDIM1.165 U35.AP27
M_B_DQ53: JDIM1.166 U35.AN27
M_B_DQ54: JDIM1.177 U35.AN25
M_B_DQ55: JDIM1.175 U35.AP25
M_B_DQ56: JDIM1.183 U35.AT22
M_B_DQ57: JDIM1.181 U35.AU22
M_B_DQ58: JDIM1.191 U35.AU21
M_B_DQ59: JDIM1.194 U35.AT21
M_B_DQ60: JDIM1.182 U35.AN22
M_B_DQ61: JDIM1.180 U35.AP22
M_B_DQ62: JDIM1.193 U35.AP21
M_B_DQ63: JDIM1.192 U35.AN21
M_B_DQS0: JDIM1.29 U35.AH65
M_B_DQS1: JDIM1.12 U35.AG70
M_B_DQS2: JDIM1.47 U35.AR65
M_B_DQS3: JDIM1.64 U35.AR60
M_B_DQS4: JDIM1.137 U35.AR38
M_B_DQS5: JDIM1.154 U35.AR32
M_B_DQS6: JDIM1.171 U35.AR27
M_B_DQS7: JDIM1.188 U35.AR21
M_B_DQS#0: JDIM1.27 U35.AH66
M_B_DQS#1: JDIM1.10 U35.AG69
M_B_DQS#2: JDIM1.45 U35.AR66
M_B_DQS#3: JDIM1.62 U35.AR61
M_B_DQS#4: JDIM1.135 U35.AT38
M_B_DQS#5: JDIM1.152 U35.AT32
M_B_DQS#6: JDIM1.169 U35.AR25
M_B_DQS#7: JDIM1.186 U35.AR22
M_B_ODT0_DIMM: JDIM1.116 U35.BA42
M_B_ODT1_DIMM: JDIM1.120 U35.AW42
M_B_RAS#: JDIM1.110 U35.AW44
M_B_WE#: JDIM1.113 U35.AY44
MAIND: PC103.2 PQ3.3 PQ18.4 PQ26.4 PQ38.4 PQ6058.3 PR148.2
MAINON: PQ11.2 PR147.1 PR301.1 PR326.2 R791.1 U49.4
MAINON_EC: R389.1 R791.2 U45.30 U49.1
MAINON_ON_G: PQ3.2 PQ4.2 PQ5.2 PQ10.2 PQ11.3 PR150.1 PR151.2
MBCLK: PC9.1 PD2.1 PR7.2 PR178.1 R731.1 U45.110
MBDATA: PC8.1 PD1.1 PR6.2 PR177.1 R732.1 U45.111
MDI_0+: U15.1 U42.2
MDI_0-: U15.2 U42.3
MDI_1+: U15.4 U42.5
MDI_1-: U15.5 U42.6
MDI_2+: U15.6 U42.8
MDI_2-: U15.7 U42.9
MDI_3+: U15.9 U42.11
MDI_3-: U15.10 U42.12
ME_WR#: R737.1 U45.109
MIC2-VREFO: R407.1 R424.1 U23.29
MOD_EN_5V: C752.1 Q34.3 Q37.6 R686.1
MPHY_EXT_PWR: R195.2 U35.AM10
MX0: CN20.1 CP6.1 RP1.4 U45.58
MX1: CN20.2 CP6.3 RP1.5 U45.59
MX2: CN20.3 CP6.5 RP1.3 U45.60
MX3: CN20.4 CP6.7 RP1.1 U45.61
MX4: CN20.5 CP5.1 RP1.9 U45.62
MX5: CN20.6 CP5.3 RP1.7 U45.63
MX6: CN20.7 CP5.5 RP1.8 U45.64
MX7: CN20.8 CP5.7 RP1.6 U45.65
MY0: CN20.26 CP1.7 U45.36
MY1: CN20.25 CP1.5 U45.37
MY2: CN20.24 CP1.3 U45.38
MY3: CN20.23 CP1.1 U45.39
MY4: CN20.22 CP2.7 U45.40
MY5: CN20.21 CP2.5 U45.41
MY6: CN20.20 CP2.3 U45.42
MY7: CN20.19 CP2.1 U45.43
MY8: CN20.18 CP3.7 U45.44
MY9: CN20.17 CP3.5 U45.45
MY10: CN20.16 CP3.3 U45.46
MY11: CN20.15 CP3.1 U45.51
MY12: CN20.14 CP4.7 U45.52
MY13: CN20.13 CP4.5 U45.53
MY14: CN20.12 CP4.3 U45.54
MY15: CN20.11 CP4.1 U45.55
MY16: CN20.10 U45.56
MY17: CN20.9 U45.57
N12E_SCL: R522.1 U34.C9
N12E_SDA: R503.1 U34.C8
NBSWON#: C785.2 C805.1 R265.2 R730.1 R753.1 R776.2 SW2.1 SW2.2 U45.107
NV_PLLVDD: C133.2 C154.2 L2.2 U34.L6
ODD_EN: Q37.5 R692.1 R703.1 R704.1
ODD_EN_Q: Q36.2 Q37.2 Q37.3 R695.2
ODD_POWER: R704.2 U45.71
ODD_PRSNT#: C802.1 R217.2 U35.AB2
ODD_PRSNT#_C: C330.1 CN9.8 R216.1 R217.1
PCBEEP: C476.1 U23.12
PCBEEP_EC: D10.2 U45.34
PCH _JTAG_TDO: R538.2 R539.1 U35.A56
PCH_ACPRESENT: R651.2 R676.2 U35.AY15
PCH_AZ_CODEC_BITCLK: C493.2 C739.2 R644.1 U23.6
PCH_AZ_CODEC_RST#: Q29.1 R660.1 U23.11
PCH_AZ_CODEC_SDIN0: R359.2 U35.BA21
PCH_AZ_CODEC_SDOUT: R645.1 U23.5
PCH_AZ_CODEC_SYNC: R667.1 U23.10
PCH_BATLOW#: R628.2 TP74.1 U35.AU13
PCH_BLON: R67.1 U35.R12
PCH_BLON_EC: R66.1 U45.88
PCH_BLON_R: Q3.5 R65.2 R66.2 R67.2
PCH_BRIGHT: CN5.27 R546.1 U35.R11
PCH_JTAGX: R513.1 R517.1 U35.A59
PCH_MBCLK0_R: Q32.6 R578.2 U35.R7
PCH_MBDAT0_R: Q32.3 R580.2 U35.R8
PCH_ODD_EN: R703.2 U35.N12
PCH_PWRBTN#: R677.2 U35.BA15
PCH_PWROK: R103.2 R647.2 R648.1 U45.78
PCH_RSMRST#: R642.1 R655.2 R661.2 U35.AY17
PCH_SLP_A#: R273.2 U35.AN16
PCH_SLP_LAN#: TP30.1 U35.AW15
PCH_SLP_S5#: R279.2 U35.AY16
PCH_SLP_SUS#: U35.AN15 U45.19
PCH_SLP_WLAN#: TP23.1 U35.BB17
PCH_SPI_CLK: C745.2 C747.1 R669.1 R684.2 U35.AV2
PCH_SPI_CLK_EC: R687.1 R689.1 U45.105
PCH_SPI_CLK_R: R669.2 R689.2 U39.6
PCH_SPI_CS0#: R602.2 U35.AU3 U41.1
PCH_SPI_CS1#: R603.2 U35.AU2 U39.1
PCH_SPI_IO2: R589.1 R596.1 U35.AW2
PCH_SPI_IO3: R238.1 R239.1 U35.AU4
PCH_SPI_SI: R658.1 R691.2 U35.AV3
PCH_SPI_SI_EC: R641.1 R654.1 R735.1 U45.102
PCH_SPI_SI_R: R641.2 R658.2 U39.5
PCH_SPI_SO: R604.1 R650.1 U35.AW3
PCH_SPI_SO_EC: R588.1 R594.1 R736.1 U45.103
PCH_SPI_SO_R: R594.2 R604.2 U39.2
PCH_SUSACK#: R617.2 U45.48
PCH_SUSPWRACK: R622.2 U35.AR13
PCH_SUSPWRACK_R: R622.1 U45.79
PCH_TRST#: R534.2 R549.1 U35.C61
PCH_VRALERT#: R211.2 TP19.1 U35.AM11
PCI_PLTRST#: U14.1 U14.2 U35.AN10
PCIE_CLKREQ_WLAN#: Q23.3 R224.1 R241.1 R253.1
PCIE_LAN_WAKE#: R244.1 R250.1 R713.2 U35.BB15
PCIE_LAN_WAKE#_R: Q39.1 R702.2 R709.1 U15.21
PCIE_RCOMPN: R562.2 U35.F5
PCIE_RCOMPP: R562.1 U35.E5
PCIE_REQ_LAN#_R: Q25.1 R276.1 R277.2 U15.12
PCIE_RX5+_LAN: C375.2 U35.E16
PCIE_RX5+_LAN_C: C375.1 U15.17
PCIE_RX5-_LAN: C372.2 U35.F16
PCIE_RX5-_LAN_C: C372.1 U15.18
PCIE_RX6+_WLAN: CN10.41 U35.F18
PCIE_RX6-_WLAN: CN10.43 U35.G18
PCIE_TX5+: C669.1 U35.D19
PCIE_TX5+_LAN: C669.2 U15.13
PCIE_TX5-: C668.1 U35.C19
PCIE_TX5-_LAN: C668.2 U15.14
PCIE_TX6+: C649.1 U35.C20
PCIE_TX6+_WLAN: C649.2 CN10.35
PCIE_TX6-: C648.1 U35.D20
PCIE_TX6-_WLAN: C648.2 CN10.37
PCLK_TPM: R626.1 U44.21
PD#: C494.1 D15.2 D16.2 R369.1 R372.2 U23.47
PEG_RX0: C632.1 U35.G13
PEG_RX1: C627.1 U35.F11
PEG_RX2: C626.1 U35.G16
PEG_RX3: C609.1 U35.F15
PEG_RX#0: C638.1 U35.H13
PEG_RX#1: C629.1 U35.G11
PEG_RX#2: C610.1 U35.H16
PEG_RX#3: C607.1 U35.G15
PEG_RXN0_C: C638.2 U34.AB9
PEG_RXN1_C: C629.2 U34.AC10
PEG_RXN2_C: C610.2 U34.AC11
PEG_RXN3_C: C607.2 U34.AB12
PEG_RXP0_C: C632.2 U34.AC9
PEG_RXP1_C: C627.2 U34.AB10
PEG_RXP2_C: C626.2 U34.AD11
PEG_RXP3_C: C609.2 U34.AC12
PEG_TX0: C652.1 U34.AG6
PEG_TX1: C655.1 U34.AF7
PEG_TX2: C662.1 U34.AE9
PEG_TX3: C660.1 U34.AG9
PEG_TX#0: C653.2 U34.AG7
PEG_TX#1: C656.1 U34.AE7
PEG_TX#2: C661.1 U34.AF9
PEG_TX#3: C654.1 U34.AG10
PEGX_RST#: Q16.2 R86.1 R114.2 R132.1 U7.4
PERSTB: R263.2 R264.2 U15.19
PEX_CLKREQ#: Q10.1 R91.1 R92.1 U34.AC6
PEX_PLLVDD: C80.1 C92.1 C96.2 R72.2 U34.AA14 U34.AA15
PEX_TERMP: R473.2 U34.AF25
PEX_TSTCLK: R481.2 U34.AF22
PEX_TSTCLK#: R481.1 U34.AE22
PHASE_A: PC144.2 PL4.1 PR60.1 PU8.5 PU8.13
PHASE_B1: PC142.2 PL2.1 PR57.1 PU6.5 PU6.13
PHASE_B2: PC143.2 PL3.1 PR58.1 PU7.5 PU7.13
PHASE_C: PC145.2 PL5.1 PR59.1 PU9.5 PU9.13
PIRQA#: R631.1 U35.BB11
PLTRST#: R214.1 R264.1 R671.1 R742.1 R749.1 U10.2 U14.4
PM_EXTTS#0: JDIM2.198 R347.2
PM_EXTTS#1: JDIM1.198 R324.2
PMON: PC7.2 PR25.1 PR172.1 PR342.2
PROC_PWRGD: R544.2 R554.1 U35.A68
PROCHOT_EC: Q30.2 R380.2 U45.17
PS_FB_CLAMP: R525.1 U34.F3
PTP_PWR_EN#: R754.1 U45.125
PWM1_B: PR27.2 PR228.2
PWM2_B: PR29.2 PR233.2
PWM-VID: PR123.1 U34.E7
PWM_A: PR43.1 PR237.2
PWM_C: PR47.1 PR239.2
PWRLED#: R426.1 R432.1 R436.1 U45.24
R_SPK+: R419.2 U23.45
R_SPK+_1: C551.1 CN18.4 R419.1
R_SPK-: R414.2 U23.44
R_SPK-_1: C548.1 CN18.3 R414.1
RAM_ID1: R610.2 R611.1 U35.AP2
RAM_ID2: R612.2 R613.1 U35.AP1
RAM_ID3: R614.2 R615.1 U35.AP3
REGN6V: PC122.1 PR1.1 PU5.24
REGOUT: C363.2 R246.1 U15.24
RF_EN: CN10.56 R774.2
RING2: R424.2 R425.1 U23.17
RING2_R: C554.1 CN21.3 D22.1 R425.2
ROM_CS: R93.1 U34.D12
ROM_SCLK: R492.1 R495.2 U34.C12
ROM_SI: R493.1 R496.2 U34.B12
ROM_SO: R491.1 R494.2 U34.A12
RREF: R398.1 U26.1
RSET: R701.2 U15.31
RSMRST#: R655.1 U45.112
RTC_RST#: C380.1 J1.1 PQ6060.3 R268.2 R299.2 U35.AM16
RTC_X1: C351.2 R255.1 U35.AM18 Y2.1
RTC_X2: C362.2 R255.2 U35.AM20 Y2.2
RX_AVCC: C722.1 C727.1 C736.1 L20.2 U13.21 U13.27 U13.28
RX_IVDD: C717.2 C738.2 R637.1 U13.11 U13.20 U13.37 U13.39
RX_IVDD33: C306.2 C309.2 L4.2 U13.29 U13.30
S5_ON: PQ9.2 PQ13.2 PQ35.2 PR249.2 R741.1 U45.100
S5D: PC282.2 PQ33.3 PQ34.4 PQ37.2 PR334.2 PR335.2
SATA_DEVSLP1: R574.1 U35.J2
SATA_DEVSLP2: R575.1 U35.J3
SATA_RXN0: C507.2 U35.F20
SATA_RXN0_C: C507.1 CN14.5
SATA_RXN1: C744.2 U35.G21
SATA_RXN1_C: C744.1 CN9.5
SATA_RXP0: C504.2 U35.E20
SATA_RXP0_C: C504.1 CN14.6
SATA_RXP1: C743.2 U35.F21
SATA_RXP1_C: C743.1 CN9.6
SATA_TXN0: C513.2 U35.B21
SATA_TXN0_C: C513.1 CN14.3
SATA_TXN1: C749.2 U35.D21
SATA_TXN1_C: C749.1 CN9.3
SATA_TXP0: C522.2 U35.A21
SATA_TXP0_C: C522.1 CN14.2
SATA_TXP1: C751.2 U35.C21
SATA_TXP1_C: C751.1 CN9.2
SATAGP0: R568.2 R570.2 U35.H2
SATAGP1: R569.1 U35.H3
SATAGP2: R566.1 U35.G4
SD_CDZ: CN4.10 U26.13
SD_CLK: R413.2 U26.15
SD_CLK_R: CN4.5 R413.1
SD_CMD: CN4.2 U26.18
SD_D0/MS_D6: CN4.7 U26.11
SD_D1/MS_D7: CN4.8 U26.10
SD_D2/MS_D5: CN4.9 U26.21
SD_D3/MS_D4: CN4.1 U26.20
SD_WP/MS_D1: CN4.11 U26.8
SDREG: C540.1 U26.6
SENSEA: R378.2 R383.2 U23.13
SIO_RCIN#: R652.1 U45.4
SLEEVE: R407.2 R408.1 U23.18
SLEEVE_R: C547.1 CN21.4 D21.1 R408.2
SM_RCOMP_0: R685.2 U35.AR18
SM_RCOMP_1: R678.2 U35.AT18
SM_RCOMP_2: R681.2 U35.AU18
SMB1ALERT#: R205.1 R218.2 U12.1 U35.AM7
SMB_ME1_CLK: R171.2 U35.W3
SMB_ME1_DAT: R175.2 U35.V3
SMBALERT#: R160.1 U35.R10
SML0ALERT#: R586.2 U35.W1
SP2: TP36.1 U26.9
SP5: TP38.1 U26.12
SP7: TP40.1 U26.14
SP9: TP42.1 U26.16
SP11: TP39.1 U26.19
SP14: TP37.1 U26.22
SP_PLLVDD: C129.2 C142.2 C152.2 C156.2 L3.2 U34.M6 U34.N6
SPI_CLK_8M: R684.1 R687.2 U41.6
SPI_CS0#_UR_ME: R591.2 R602.1 R603.1 U45.101
SPI_HOLD_IO3_EC: R232.1 R238.2 U39.7
SPI_HOLD_IO3_ME: R239.2 R698.1 U41.7
SPI_SI_8M: R654.2 R691.1 U41.5
SPI_SO_8M: R588.2 R650.2 U41.2
SPI_WP_IO2_EC: R596.2 R597.2 U39.3
SPI_WP_IO2_ME: R589.2 R649.2 U41.3
SPKR: D9.2 R624.1 R625.2 U35.AW5
SRTC_RST#: C382.1 PQ6059.3 R300.2 U35.AN18
SSD_ID: CN9.7 R568.1
STRAP0: R507.2 R527.1 U34.D1
STRAP1: R499.1 R519.1 U34.D2
STRAP2: R508.2 R528.2 U34.E4
STRAP3: R506.1 R526.1 U34.E3
STRAP4: R500.1 R520.1 U34.D3
SUS0#: U35.AT11 U45.83
SUSACK#_R: R617.1 U35.AP11
SUSB#: PQ6057.2 R282.2 U35.AP15 U45.119 U47.2 U49.2 U50.2
SUSC#: R274.2 U35.BA16 U45.18 U48.2
SUSCLK: R716.2 U35.BA17 U43.2
SUSD: PC101.2 PQ8.3 PQ23.2 PR142.2 PR143.2
SUSLED#: R427.1 R433.1 U45.28
SUSON: PQ6.2 PR305.1 R790.1 U48.4
SUSON_EC: R739.1 R790.2 U45.120 U48.1
SYS_HWPG: D19.1 PR6283.2
SYS_PEX_RST: R132.2 R143.2 U10.4
SYS_PEX_RST_MON#: R95.1 R142.2 R143.1 U7.2 U34.E9
SYS_PWROK: R113.1 R556.1 R560.1 R643.1 U8.4
SYS_PWROK_R: R131.1 R555.1 R556.2 U35.B6
SYS_RESET#: R267.2 R561.2 U35.B5
SYS_SHDN#: PQ14.3 PR6278.2 PR6280.2 PU6010.6 Q5.3
SYSTEM_AGND: PR6120.2 PR6121.2 PR6122.1 PR6124.2 PR6125.1
TEMP_MBAT: PR8.2 PR9.1 PR12.1 U45.73
TERM9: C746.1 R251.1 R258.1 R262.1 R269.1
TESTMODE: R79.1 U34.AD9
TH_FAN_POWER: C723.2 C728.2 CN8.1 U12.3
THERM+: TP3.1 U34.F12
THERM-: TP4.1 U34.E12
THRMTRIP#: Q5.1 R488.1 R530.1
TP_DDR0_PARITY#: TP21.1 U35.AT52
TP_DDR1_PARITY#: TP18.1 U35.AP43
TP_INT: CN5.1 Q1.1 R7.1 R8.2 R443.2
TP_INT_PCH: Q1.3 R8.1 U35.AB3
TP_PWR: C577.2 C578.2 CN5.30 CN5.31 R16.2 R19.2
TP_RST#: CN5.29 R444.1
TPCLK: R411.1 R415.2 U45.89
TPCLK_R: C787.2 CN17.7 R411.2
TPD_EN: CN17.1 R190.2
TPD_INT#: CN17.2 Q20.1 R164.1 R349.2
TPD_INT#_D: Q20.3 R164.2 R177.1 U35.W4
TPDATA: R412.1 R416.2 U45.90
TPDATA_R: C788.2 CN17.6 R412.2
TPM_BADD: R726.2 R729.2 U44.9
TPM_CLKRUN#: R743.1 U44.15
TPM_LRESET#: R726.1 R742.2 U44.16
TPM_PP: R724.2 R728.2 U44.7
TS_EN: R442.1 R443.1 R751.1
TS_EN_C: C800.1 R751.2 U45.32
TS_EN_R: CN5.6 R442.2
UART2_CTS#: CN3.5 R290.1 U35.AD4
UART2_RTS#: CN3.4 R283.1 U35.AD3
UART2_RXD: CN3.2 R275.1 U35.AD1
UART2_TXD: CN3.3 R280.1 U35.AD2
URDBG: TP24.1 U13.24
USB2_ID: R587.1 U35.AG3
USB3_RXN0: C518.2 R392.2 U35.H8
USB3_RXN0_R: CN16.5 R392.1 U24.6
USB3_RXN1: C475.2 R355.2 U35.J6
USB3_RXN1_R: CN13.5 R355.1 U21.6
USB3_RXP0: C517.2 R387.2 U35.G8
USB3_RXP0_R: CN16.6 R387.1 U24.5
USB3_RXP1: C469.2 R353.2 U35.H6
USB3_RXP1_R: CN13.6 R353.1 U21.5
USB3_TXN0: C499.1 U35.C13
USB3_TXN0_C: C499.2 R384.2
USB3_TXN0_R: C511.1 CN16.8 R384.1 U24.10
USB3_TXN1: C461.1 U35.B13
USB3_TXN1_C: C461.2 R341.2
USB3_TXN1_R: C460.1 CN13.8 R341.1 U21.1
USB3_TXP0: C498.1 U35.D13
USB3_TXP0_C: C498.2 R381.2
USB3_TXP0_R: C505.1 CN16.9 R381.1 U24.1
USB3_TXP1: C459.1 U35.A13
USB3_TXP1_C: C459.2 R340.2
USB3_TXP1_R: C458.1 CN13.9 R340.1 U21.10
USB_BC_ON: U22.4 U45.97
USB_CHARGE_ON: R364.1 U22.5 U45.96
USB_CLT1: U22.6 U45.31
USB_OC0#: R541.1 U22.13 U35.A9
USB_OC1#: R540.1 U20.3 U35.C9
USB_OC2#: R543.1 U35.D9 U46.3
USB_OC3#: R542.1 U35.B9
USBCOMP: R178.1 U35.AB6
USBON#: U20.4 U45.99 U46.4
USBP0+: U22.3 U35.AB10
USBP0+_C: R386.2 U22.10
USBP0+_R: CN16.3 R386.1 U24.7
USBP0-: U22.2 U35.AB9
USBP0-_C: R385.2 U22.11
USBP0-_R: CN16.2 R385.1 U24.4
USBP1+: R348.2 U35.AD7
USBP1+_R: CN13.3 R348.1 U21.7
USBP1-: R342.2 U35.AD6
USBP1-_R: CN13.2 R342.1 U21.4
USBP3+: CN22.8 U35.AD10
USBP3-: CN22.7 U35.AD9
USBP4+: CN10.3 U35.AJ2
USBP4-: CN10.5 U35.AJ1
USBP5+: R4.1 U35.AF7
USBP5-: R3.1 U35.AF6
USBP6+: R2.1 U35.AH2
USBP6+_R: CN5.14 R2.2
USBP6-: R1.1 U35.AH1
USBP6-_R: CN5.13 R1.2
USBP7+: U26.3 U35.AF9
USBP7-: U26.2 U35.AF8
USBPWR0: C487.1 C496.2 C497.2 C502.2 CN16.1 U22.12 U24.2
USBPWR1: C450.2 C451.2 C452.2 C462.2 CN13.1 U20.1 U21.2
USBPWR2: C782.2 C789.1 C791.2 C792.2 CN22.1 CN22.2 CN22.3 CN22.4 R755.2 U46.1
V_BLIGHT: CN5.39 CN5.40 R14.2 R15.2
VA: PC124.2 PC128.2 PD3.1 PD8.1 PD8.2 PJ2.1 PJ2.2 PR168.1
VA1: PC13.2 PC133.1 PD8.3 PQ22.5 PR5.2
VA2: PC136.1 PQ22.1 PQ22.2 PQ22.3 PR166.1 PR210.2 PR213.1
VCORE_SENSE: PR33.1 R96.2 U35.E32
VCORESS_SENSE: PR38.1 R98.1 U35.E33
VGA_MBCLK: R582.2 U35.R9
VGA_MBDATA: R585.2 U35.W2
VGA_OVT#: Q16.1 R111.1 U34.A6
VGA_RST: R206.2 U13.3
VGA_RST#: C134.1 R86.2 U34.AC7
VGA_VCCSENSE: PR61.2 R123.2 U34.F2
VGA_VSSSENSE: PR62.2 R124.1 U34.F1
VGPU_EN: PR111.1 R196.1 R220.1 U35.AN8
VL: PC6219.2 PR144.1 PR146.1 PU6010.13
VMA_CLK0: R75.1 U4.J7 U5.J7 U31.J7 U32.J7 U34.D24
VMA_CLK0#: R75.2 U4.K7 U5.K7 U31.K7 U32.K7 U34.D25
VMA_CLK1: R68.1 U2.J7 U3.J7 U28.J7 U29.J7 U34.N22
VMA_CLK1#: R68.2 U2.K7 U3.K7 U28.K7 U29.K7 U34.M22
VMA_DM0: U4.E7 U31.E7 U34.D19
VMA_DM1: U5.E7 U32.E7 U34.D14
VMA_DM2: U5.D3 U32.D3 U34.C17
VMA_DM3: U4.D3 U31.D3 U34.C22
VMA_DM4: U3.E7 U29.E7 U34.P24
VMA_DM5: U2.E7 U28.E7 U34.W24
VMA_DM6: U2.D3 U28.D3 U34.AA25
VMA_DM7: U3.D3 U29.D3 U34.U25
VMA_DQ0: U4.F2 U31.F8 U34.E18
VMA_DQ1: U4.E3 U31.F7 U34.F18
VMA_DQ2: U4.G2 U31.H8 U34.E16
VMA_DQ3: U4.H3 U31.H7 U34.F17
VMA_DQ4: U4.F7 U31.E3 U34.D20
VMA_DQ5: U4.F8 U31.F2 U34.D21
VMA_DQ6: U4.H7 U31.H3 U34.F20
VMA_DQ7: U4.H8 U31.G2 U34.E21
VMA_DQ8: U5.H7 U32.H3 U34.E15
VMA_DQ9: U5.H8 U32.G2 U34.D15
VMA_DQ10: U5.F8 U32.F2 U34.F15
VMA_DQ11: U5.F7 U32.E3 U34.F13
VMA_DQ12: U5.E3 U32.F7 U34.C13
VMA_DQ13: U5.H3 U32.H7 U34.B13
VMA_DQ14: U5.G2 U32.H8 U34.E13
VMA_DQ15: U5.F2 U32.F8 U34.D13
VMA_DQ16: U5.A2 U32.B8 U34.B15
VMA_DQ17: U5.C3 U32.D7 U34.C16
VMA_DQ18: U5.C2 U32.C8 U34.A13
VMA_DQ19: U5.A3 U32.A7 U34.A15
VMA_DQ20: U5.A7 U32.A3 U34.B18
VMA_DQ21: U5.C8 U32.C3 U34.A18
VMA_DQ22: U5.B8 U32.A2 U34.A19
VMA_DQ23: U5.D7 U32.C2 U34.C19
VMA_DQ24: U4.C2 U31.D7 U34.B24
VMA_DQ25: U4.D7 U31.C3 U34.C23
VMA_DQ26: U4.C3 U31.C8 U34.A25
VMA_DQ27: U4.A2 U31.B8 U34.A24
VMA_DQ28: U4.B8 U31.A2 U34.A21
VMA_DQ29: U4.A3 U31.A7 U34.B21
VMA_DQ30: U4.C8 U31.C2 U34.C20
VMA_DQ31: U4.A7 U31.A3 U34.C21
VMA_DQ32: U3.F7 U29.E3 U34.R22
VMA_DQ33: U3.H7 U29.H3 U34.R24
VMA_DQ34: U3.F8 U29.F2 U34.T22
VMA_DQ35: U3.H8 U29.G2 U34.R23
VMA_DQ36: U3.H3 U29.H7 U34.N25
VMA_DQ37: U3.G2 U29.H8 U34.N26
VMA_DQ38: U3.F2 U29.F8 U34.N23
VMA_DQ39: U3.E3 U29.F7 U34.N24
VMA_DQ40: U2.F2 U28.F8 U34.V23
VMA_DQ41: U2.H3 U28.H7 U34.V22
VMA_DQ42: U2.G2 U28.H8 U34.T23
VMA_DQ43: U2.E3 U28.F7 U34.U22
VMA_DQ44: U2.F7 U28.E3 U34.Y24
VMA_DQ45: U2.F8 U28.F2 U34.AA24
VMA_DQ46: U2.H8 U28.G2 U34.Y22
VMA_DQ47: U2.H7 U28.H3 U34.AA23
VMA_DQ48: U2.B8 U28.A2 U34.AD27
VMA_DQ49: U2.A7 U28.A3 U34.AB25
VMA_DQ50: U2.C8 U28.C2 U34.AD26
VMA_DQ51: U2.D7 U28.C3 U34.AC25
VMA_DQ52: U2.C3 U28.D7 U34.AA27
VMA_DQ53: U2.A3 U28.A7 U34.AA26
VMA_DQ54: U2.C2 U28.C8 U34.W26
VMA_DQ55: U2.A2 U28.B8 U34.Y25
VMA_DQ56: U3.A2 U29.B8 U34.R26
VMA_DQ57: U3.C3 U29.D7 U34.T25
VMA_DQ58: U3.A3 U29.A7 U34.N27
VMA_DQ59: U3.C2 U29.C8 U34.R27
VMA_DQ60: U3.B8 U29.A2 U34.V26
VMA_DQ61: U3.A7 U29.A3 U34.V27
VMA_DQ62: U3.D7 U29.C3 U34.W27
VMA_DQ63: U3.C8 U29.C2 U34.W25
VMA_RDQS0: U4.G3 U31.G3 U34.F19
VMA_RDQS1: U5.G3 U32.G3 U34.C14
VMA_RDQS2: U5.B7 U32.B7 U34.A16
VMA_RDQS3: U4.B7 U31.B7 U34.A22
VMA_RDQS4: U3.G3 U29.G3 U34.P25
VMA_RDQS5: U2.G3 U28.G3 U34.W22
VMA_RDQS6: U2.B7 U28.B7 U34.AB27
VMA_RDQS7: U3.B7 U29.B7 U34.T27
VMA_WDQS0: U4.F3 U31.F3 U34.E19
VMA_WDQS1: U5.F3 U32.F3 U34.C15
VMA_WDQS2: U5.C7 U32.C7 U34.B16
VMA_WDQS3: U4.C7 U31.C7 U34.B22
VMA_WDQS4: U3.F3 U29.F3 U34.R25
VMA_WDQS5: U2.F3 U28.F3 U34.W23
VMA_WDQS6: U2.C7 U28.C7 U34.AB26
VMA_WDQS7: U3.C7 U29.C7 U34.T26
VR_SVID_ALERT#_VCORE: PU1.36 R134.2 R552.2
VREFC_VMA1: C590.2 R466.1 R469.2 U4.M8 U5.M8 U31.M8 U32.M8
VREFC_VMA3: C37.2 R33.1 R34.2 U2.M8 U3.M8 U28.M8 U29.M8
VREFD_VMA1: C115.2 R76.1 R77.2 U4.H1 U5.H1 U31.H1 U32.H1
VREFD_VMA3: C599.2 R467.2 R472.1 U2.H1 U3.H1 U28.H1 U29.H1
VRON: PR28.2 PR136.1 PR196.2 R792.1 U50.4
VRON_EC: R463.1 R792.2 U45.69 U50.1
VSA_SENSE: PR50.1 R122.2 U35.H20
VSASS_SENSE: PR52.1 R109.1 U35.H21
VSYNC: U13.1 U37.2
WIFI_SUSCLK: CN10.50 R714.1 U43.4
WLAN_CLKREQ#: CN10.53 Q23.4 R245.1 R253.2
WLAN_RST#: CN10.52 R671.2 R680.2
WLAN_WAKE_R#: CN10.55 Q23.1 R242.1 R243.2
WRST#: C491.1 D12.2 Q56.6 R368.1 U45.14
XCLK_BIASREF: R512.1 R768.1 U35.E42
XD_CD#: TP43.1 U26.7
XD_D7: TP35.1 U26.23
XDP_BPM#0: TP89.1 U35.C55
XDP_BPM#1: TP90.1 U35.D55
XDP_BPM#2: TP64.1 U35.B54
XDP_BPM#3: TP62.1 U35.C56
XDP_PRDY#: TP91.1 U35.D56
XDP_PREQ#: TP92.1 U35.D61
XDP_TCK0: R517.2 R558.2 U35.B61
XDP_TCK1: R537.2 U35.B56
XDP_TDI: R515.2 R796.1 U35.D59
XDP_TDI_CPU: R796.2 U35.D60
XDP_TDO: R539.2 R795.1
XDP_TDO_CPU: R559.2 R795.2 U35.A61
XDP_TMS: R514.2 R797.1 U35.C59
XDP_TMS_CPU: R797.2 U35.C60
XDP_TRST#: R535.2 R549.2 U35.B59
XTAL1: C359.1 U15.28 Y1.3
XTAL2: C358.1 U15.29 Y1.1
XTAL24_IN: C665.2 R536.1 U35.E37 Y4.3
XTAL24_OUT: C658.2 R536.2 U35.E35 Y4.1
XTAL_SSIN: R524.1 U34.A10
N59981: R567.2 U35.L6
N59985: R571.2 U35.N9
N62917: R158.2 U35.H66
N62945: R162.2 U35.H65
N62977: R635.2 U35.AT16
N62981: R646.2 U35.AU16
N74227: R174.2 U35.AB7
N108264: R623.2 U35.AW9
N108478: C806.1 R748.1 U35.BA11
N109188: R626.2 R627.2 U35.AY9
N109300: R659.1 U35.AY13
N109332: R640.1 U35.BA13
N109356: R653.1 U35.BB13
N109380: R668.1 U35.AY12
N112417: R616.2 U35.AT1
N112429: TP63.1 U35.B7
N112433: R145.2 U35.E13
N119188: R153.1 U35.E8
N136283: CN2.2 R282.1
N136287: CN2.4 R279.1
N136291: CN2.6 R273.1
N136295: CN2.9 R268.1
N136299: CN2.11 R265.1
N136321: CN2.13 R267.1
N136329: CN2.5 R274.1
N151936: C478.1 R357.2
N151940: C478.2 R362.1 R363.1
N152180: C427.2 R327.1 R328.1
N152184: C427.1 R325.2
N163999: C397.2 R302.1 R307.1
N164003: C397.1 R313.2
N250004: TP15.1 U13.34
N250028: R202.2 U13.31
N250076: R200.2 U13.36
N250080: R201.2 U13.35
N259399: C556.1 D28.2 MR1.1 R434.1
N265494: R294.2 U18.18
N265518: R306.1 U18.8
N321886: R390.2 R395.2 U25.5
N366230: Q36.3 R673.2
N16779422: C781.1 L19.1 Q42.1 R752.1
N16779565: Q18.2 Q19.3 R148.2
N16779579: C786.1 Q42.2 R754.2
N16781100: R402.2 R415.1 R416.1
N16787949: C490.2 R373.1
N16788300: C778.1 U45.12
N16788484: C798.2 R774.1 U45.66
N16788550: C801.1 R460.1 U45.118
N16788590: TP78.1 U45.122
N16788607: TP33.1 U45.80
N16788623: C796.1 R190.1 U45.98
N16789334: TP77.1 U45.126
N16824426: R139.2 R140.2 U9.2
N16946782: Q5.2 R74.2
N16946786: Q31.1 R74.1
N16998366: Q27.2 R343.1 R344.2
N16998426: Q27.3 Q28.2 R345.2
N16999417: R284.2 R285.1 U17.1
N17002655: C529.2 U23.39
N17002661: C528.1 U23.37
N17002676: C530.2 U23.34
N17002678: C519.1 U23.19
N17002722: TP34.1 U23.48
N17002952: C481.1 U23.7
N17003087: D9.1 D10.1 R352.2
N17003129: C528.2 U23.35
N17003186: R388.2 U23.20
N17004316: D15.1 Q29.3
N17023094: TP26.1 U15.27
N17023105: TP27.1 U15.25
N17023109: TP28.1 U15.26
N17023253: Q39.3 R709.2 R713.1 R715.1
N17023337: C364.2 U42.1 U42.4 U42.7 U42.10
N17023386: C368.2 Q24.2 R259.2
N17028021: C344.2 Q22.2 R230.2
N17045098: C797.1 R349.1 U45.128
N17046941: PJ1.3 PR6.1
N17047009: PR183.2 PU5.20
N17047028: PR184.2 PU5.19
N17047083: PJ1.5 PR8.1
N17047087: PC1.1 PL1.1 PQ1.1 PQ1.2 PQ1.3 PR169.1 PR176.2 PR186.1
N17047112: PC133.2 PC136.2 PQ22.4 PR165.1
N17047335: PC4.1 PR2.2
N17047399: PC119.2 PR173.1
N17047425: PJ1.4 PR7.1
N17047601: PC1.2 PQ1.4 PR185.1
N17051540: PQ33.2 PQ35.3 PQ36.2 PQ39.2 PR336.2 PR337.1
N17051630: PQ36.3 PR338.2
N17051638: PQ39.3 PR339.2
N17052468: PC196.1 PR258.1
N17052648: PC62.1 PR76.2
N17055599: PC250.1 PR313.2
N17055737: PC243.1 PR308.2
N17067388: PR247.2 PR248.2 PU10.6
N17067390: PC173.1 PR244.1 PU10.4
N17067402: PR246.2 PR247.1
N17067414: PC174.2 PR249.1 PU10.1
N17067429: PR245.1 PU10.5
N17067472: PC104.2 PR154.2 PR155.1 PU4.8
N17067476: PD4.1 PQ12.1 PR152.1
N17067510: PQ12.3 PR154.1
N17067514: PQ12.2 PQ13.3 PR152.2
N17067548: PC102.2 PQ14.2 PR155.2 PU4.1
N17067560: PQ9.3 PR262.1
N17067629: PQ4.3 PR137.2
N17067635: PQ10.3 PR153.2
N17067696: PR330.2 PR331.2 PU19.6
N17067698: PC278.1 PR333.1 PU19.4
N17067710: PR328.2 PR330.1
N17067722: PC271.2 PR326.1 PU19.1
N17067737: PR332.1 PU19.5
N17069078: PC94.2 PR61.1 PR64.2 PR129.2
N17069086: PR62.1 PR63.2 PR128.2
N17069105: PC95.1 PQ2.2
N17069120: PC219.2 PR272.2 PR273.1
N17069170: PR132.2 PR134.1
N17069179: PC96.1 PR126.2 PR127.2 PR130.1 PR131.1
N17069186: PC82.1 PR108.1
N17069257: PC64.1 PR65.2
N17069297: PC89.2 PR122.1
N17069414: PC66.1 PR67.2
N17069439: PC81.1 PR107.1
N17069524: PQ2.3 PR130.2
N17071623: PQ15.3 PQ16.2 PQ17.2 PR157.1 PR159.2
N17071639: PC109.2 PQ15.2 PR158.1 PR160.2
N17071653: PQ17.3 PR164.2
N17071727: PR260.2 PU11.3
N17071762: PC65.1 PR68.2
N17071926: PC241.2 PR306.2
N17192633: R337.2 U19.7
N17310717: D24.1 LED2.2 R430.2
N17310725: D27.1 LED1.1 R433.2
N17310735: D25.1 LED2.1 R431.2
N17310861: D26.1 LED1.2 R432.2
N17398787: PR167.2 PU5.5
N17410561: PC222.1 PC223.1 PC225.1 PC226.1 PL13.2 PR344.1 R793.1 R794.1
N17410571: PR280.2 PR288.1 R697.1
N17410716: PC230.2 PR292.1 PU14.10
N17410893: PR290.2 PU14.13
N17424918: PR177.2 PU5.11
N17424920: PR178.2 PU5.12
N17424921: PR170.2 PU5.7
N17424925: PR172.2 PU5.9
N17424950: PR12.2 PR13.2 PU5.15
N17428106: PQ6.3 PQ7.2 PQ8.2 PR140.1 PR141.2
N17428120: PQ7.3 PR139.2
N17435661: PQ5.3 PR138.2
N17542339: C756.2 Q38.2 R710.2
N17661815: PR171.2 PU5.8
N17716011: PC129.1 PR195.2
N17716199: PC25.2 PC26.2 PC27.1 PR31.1 PR33.2 PR201.2
N17716279: PC15.1 PR23.2
N17716285: PC16.1 PR24.2
N17716287: PC11.1 PC12.1 PC16.2 PR187.1 PR191.2 PR194.2
N17716423: PC26.1 PR34.2
N17716551: PR205.1 PR243.1
N17716721: PC34.1 PR41.1
N17716783: PC135.1 PR199.2
N17716824: PC28.1 PR36.2
N17716831: PC42.2 PC44.1 PC46.2 PR50.2 PR51.1 PR217.2
N17717020: PC42.1 PR45.2
N17717324: PR224.1 PR235.2 PR236.2
N17717338: PC41.1 PR44.2
N17717460: PR225.1 PR226.2 PR227.2
N17717526: PC139.1 PR216.2
N17717790: PR218.1 PR242.1
N17717866: PC40.1 PR48.1
N17717963: PR193.1 PR241.2
N17718066: PC19.2 PR21.2
N17720504: PL4.3 PR215.2
N17720506: PL4.4 PR214.2
N17720729: PC58.1 PR60.2
N17721096: PR233.1 PU7.1
N17721116: PL2.3 PR19.2 PR20.2
N17721136: PL3.3 PR189.2 PR190.2
N17721174: PL2.4 PR17.2 PR18.1
N17721246: PC146.2 PR53.2 PU6.23 PU6.24
N17721250: PC55.1 PR57.2
N17721295: PC147.2 PR54.2 PU7.23 PU7.24
N17721303: PL3.4 PR182.2 PR188.1
N17723090: PL5.3 PR222.2
N17723092: PL5.4 PR221.2
N17723254: PC151.2 PR56.2 PU9.23 PU9.24
N17723270: PC57.1 PR59.2
N17738230: D31.1 R316.1
N17738233: D30.1 R317.1
N17762362: PR237.1 PU8.1
N17762374: PR238.1 PU8.2
N17762566: PC149.2 PR55.2 PU8.23 PU8.24
N17763940: PR231.2 PU8.3
N17766069: PC142.1 PR223.1
N17766091: PR223.2 PU6.3
N17766685: PR229.1 PU6.2
N17766721: PR228.1 PU6.1
N17768675: PC143.1 PR230.1
N17768697: PR230.2 PU7.3
N17769194: PC56.1 PR58.2
N17771799: PR234.1 PU7.2
N17776478: PR240.1 PU9.2
N17776833: PC145.1 PR232.1
N17777054: PR232.2 PU9.3
N17777700: PR239.1 PU9.1
N17790538: TP87.1 U35.AL61
N17790548: TP86.1 U35.AK62
N17792383: R172.1 R634.2 U35.AC63
N17792405: R176.1 R636.2 U35.AE63
N17792407: R633.2 U35.AL63
N17792421: R632.2 U35.AJ62
N17817978: LED1.3 R438.1 R440.1
N17818190: LED2.3 R437.1 R439.1
N17828598: PC144.1 PR231.1
N18005998: CN14.18 R326.2
N18020348: TP17.1 U35.AM23
N18021386: TP14.1 U35.AM22
N18022283: TP12.1 U35.K32
N18022286: TP20.1 U35.AK32
N18079286: R509.1 R510.2 U34.F6
N18137715: TP29.1 U35.AU11
N18834425: C764.1 Q56.2 Q56.3 R717.2
N18834459: R717.1 R756.1 R757.1
N18849499: CN5.11 R4.2 R6.2
N18849555: CN5.10 R3.2 R5.2
N18953365: R759.1 U35.AY3
N18953425: R760.1 U35.AY71
N18954271: R761.1 U35.C64
N18954886: R762.1 U35.AR56
N18954889: TP88.1 U35.AP56
N18994895: C793.2 U35.L1
N19011701: PC231.1 PR291.2
N19018012: C794.2 R775.2 U35.U11 U35.U12
N19138106: R80.2 U34.F22
N19138109: R87.2 U34.J22
N19520551: CN20.27 D34.1 R776.1
N19736816: TP84.1 U35.AM15
N19940934: PC6213.2 PR6286.2
N19940984: PC6222.1 PR6289.2
N19941046: PR6283.1 PR6284.2 PU6010.7
N19941108: PC6211.1 PD6008.3
N19941112: PC6099.2 PC6211.2 PR6285.2
N19941118: PC6097.2 PD6004.1 PD6008.2
N19941180: PC6099.1 PD6004.3
N19941188: PC6221.1 PR6288.2
N19941230: PC6215.1 PR6287.1
N19949969: PQ6057.3 PQ6058.2 PR6290.1
N20339214: R778.1 U35.AG4
N20463413: CN22.5 R755.1 R787.1
N20915811: TP95.1 U35.AK13
N21263014: TP7.1 U34.E10
N21263017: TP6.1 U34.F10
N108831390: Q14.3 R120.2 R121.2 R128.1 R129.1
N108831783: Q15.3 R99.1 R106.1 R107.2 R125.1
N108845535: C147.1 Q6.2 Q8.3 R81.1
N108845564: C162.1 Q8.2 R104.1
N112371482: Q17.3 R116.1 R117.2
N112371495: C166.1 C167.2 Q11.2 R116.2
N112697336: TP60.1 U34.V7
N112697339: TP56.1 U34.W7
N112698577: TP53.1 U34.W6
N112698579: TP57.1 U34.Y6
N112698609: TP9.1 U34.M7
N112698611: TP50.1 U34.N7
N112698638: TP59.1 U34.P6
N112698654: TP54.1 U34.T7
N112698670: TP8.1 U34.R7
N112698723: TP10.1 U34.R6
N112699151: TP55.1 U34.K7
N112699156: TP11.1 U34.J7
N112699170: TP52.1 U34.H6
N112699184: TP51.1 U34.J6
N112700854: TP5.1 U34.F11
N112701566: TP61.1 U34.W5
N112701580: TP49.1 U34.AE2
N112701871: TP2.1 U34.D23

Pads without a net: CN2 15 16 17 18 19 20; CN5 4 5 7 8 37 38; CN6 3; CN7 4; CN8 4 5; CN10 6 8 9 10 11 12 13 14 15 16 17 19 20 21 22 23 32 34 36 38 40 42 44 46 48 58 59 60 61 62 65 67 76 77; CN12 13 14; CN14 8 10 20 21 22; JDIM1 77 122 125; JDIM2 77 122 125; NOREF 1; NOREF#2 1; NOREF#7 1; NOREF#10 1; NOREF#11 1; NOREF#12 1; PU4 7; PU6 4 19 20; PU7 4 19 20; PU8 4 19 20; PU9 4 19 20; PU11 5 6; U2 J1 J9 L1 L9 M7; U3 J1 J9 L1 L9 M7; U4 J1 J9 L1 L9 M7; U5 J1 J9 L1 L9 M7; U6 1; U13 4; U18 36; U19 2 3; U22 9; U23 14 15 16 23 24; U28 J1 J9 L1 L9 M7; U29 J1 J9 L1 L9 M7; U31 J1 J9 L1 L9 M7; U32 J1 J9 L1 L9 M7; U33 1; U34 AA1 AA2 AA3 AA4 AA5 AA6 AB1 AB2 AB3 AB4 AB5 AB6 AB13 AB15 AB16 AB18 AB19 AB21 AC3 AC4 AC13 AC14 AC15 AC16 AC17 AC18 AC19 AC20 AC21 AD1 AD2 AD3 AD4 AD5 AD7 AD10 AD14 AD17 AD20 AD23 AE1 AE3 AE4 AE10 AE12 AE13 AE15 AE16 AE18 AE19 AE21 AE23 AE24 AF2 AF3 AF4 AF10 AF12 AF13 AF15 AF16 AF18 AF19 AF21 AF24 AG3 AG12 AG13 AG15 AG16 AG18 AG19 AG21 AG22 AG24 AG25 B2 B3 B6 B19 C1 C2 C3 C5 C7 C18 D4 D6 D10 D11 D16 D17 D18 E6 F4 F5 F7 F9 G1 G2 G3 G4 G5 G6 G7 H3 H4 J1 J2 J3 J4 J5 J26 K1 K2 K3 K4 K5 K6 L3 L4 M1 M2 M3 M4 M5 N1 N2 N3 N4 N5 P3 P4 R1 R2 R3 R4 R5 T1 T2 T3 T4 T5 T6 T24 U3 U4 U6 U24 V1 V2 V3 V4 V5 V6 V24 V25 W1 W2 W3 W4 Y3 Y4; U35 A3 A4 A6 A7 A11 A15 A23 A25 A26 A27 A29 A31 A33 A36 A38 A42 A45 A47 A50 A52 A65 A69 AB4 AB11 AB12 AB13 AC1 AC2 AC3 AD11 AD12 AF11 AF12 AF13 AG1 AG2 AH3 AH7 AH8 AH9 AH10 AH11 AH12 AJ3 AK6 AK7 AK9 AK10 AK12 AL25 AL27 AN55 AP13 AP53 AT5 AT15 AU1 AU5 AU56 AW1 AW7 AW17 AW20 AW48 AW56 AW68 AW69 AW70 AW71 AY1 AY2 AY4 AY5 AY7 AY8 AY20 AY21 AY56 B2 B3 B11 B15 B23 B25 B26 B27 B29 B31 B33 B36 B38 B42 B45 B47 B50 B67 B69 B70 BA3 BA4 BA7 BA8 BA9 BA68 BA70 BB2 BB3 BB4 BB5 BB7 BB9 BB68 BB69 C2 C4 C7 C8 C11 C12 C15 C23 C24 C27 C28 C29 C31 C32 C33 C36 C37 C38 C40 C41 C51 C54 C67 C68 C70 C71 D1 D3 D4 D5 D8 D12 D15 D23 D24 D27 D28 D29 D31 D32 D33 D36 D37 D38 D40 D41 D51 D54 D65 D67 D68 D71 E1 E2 E3 E10 E22 E23 E25 E27 E28 E30 E61 E63 E66 E68 F6 F10 F25 F30 F46 F50 F52 F60 F61 F63 F65 F66 F70 F71 G46 G50 G65 G68 G69 G70 G71 H1 H10 H11 H69 H70 J4 J5 J10 J68 J71 K45 K46 M1 M2 M3 M4 N1 N2 N3 N11 P1 P2 P3 P4 U1 U2 U3 U4 V1 V2 W7 W8 W10 W11 W12; U43 1; U44 1 2 3 8 12 13 14

## Via types
v1: diameter 0.508, hole 0.254, TOP to BOTTOM, 4922 vias
v2: diameter 0.483, hole 0.254, TOP to BOTTOM, 430 vias
v3: diameter 0.66, hole 0.33, TOP to BOTTOM, 570 vias
v4: diameter 0.61, hole 0.356, TOP to BOTTOM, 766 vias
v5: diameter 0.457, hole 0.254, TOP to BOTTOM, 45 vias

## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point)
1.5VGFX_AGND: length 21.9
  TOP w0.508: PR69.1 218.81,120.24 216.93,118.36 v1(216.93,117.72)
  IN2 w0.508: v1(216.93,117.72) 216.85,117.8 v1(213.53,117.8)
  BOTTOM w0.203: PU11.14 216.92,118.32 217.03,118.21 217.03,117.83 v1(216.93,117.72)
  BOTTOM w0.508: PR346.2 210.4,116.68 210.68,116.4 v3(211.95,116.4) 212.31,116.77 PR260.1 213.32,117.6 v1(213.53,117.8) ; v1(216.93,117.72) 218.2,116.45 PC199.1 218.65,115.57 219.12,115.1 219.64,115.1 220.05,115.52 220.05,117.86 PR256.2 PC195.1
1.5VGFX_BST:
  vias: v3(217.34,121.15)
1.5VGFX_EN: length 6.3
  TOP w0.203: PR73.2 PR75.2 v1(219.43,115.82)
  BOTTOM w0.203: v1(219.43,115.82) PR75.2 218.92,116.96 218.4,116.96 217.35,118.02 217.35,118.4 217.02,118.72 PU11.13
1.5VGFX_FB: length 3.7
  BOTTOM w0.203: PU11.12 217.59,119.12 v1(217.69,119.02) 218.11,119.02 PR256.1 218.65,118.25 PR259.2
1.5VGFX_PG: length 2.7
  BOTTOM w0.203: PU11.4 213.21,118.72
  BOTTOM w0.254: 213.21,118.72 v1(212.55,119.38) 212.31,119.63 PR252.2
1.5VGFX_SW:
  vias: v3(213.6,121.23) v4(215.66,121.53)
2.469V: length 5
  TOP w0.114: v3(68.95,75.08) 68.97,75.05 PR144.2 70.18,74.54 69.82,74.17 PR145.1 69.82,73.03 69.81,73.02 PU4.3
3V_LDO: length 3.9
  TOP w0.508: v1(65.77,56.24) 65.12,55.59 PC6098.1
  BOTTOM w0.203: PU6010.3 65.77,56.27 65.77,56.27 v1(65.77,56.24)
  BOTTOM w0.305: PR6280.1 v1(65.8,57.12) 65.8,56.27 v1(65.77,56.24)
3V_MAIN_PWGD: length 125.4
  TOP w0.114: Q6.3 160.52,148.69 160.74,148.47 R88.2 R90.1 160.74,146.33 162.35,144.72 162.35,141.26 163.26,140.36 164.91,140.36 165.32,139.95 165.32,139.29 v1(164.96,138.93) ; PR343.1 196.19,105.19 193.23,108.15 v1(192.01,108.15)
  IN1 w0.127: v1(198.87,80.36) 198.67,80.36 195.78,83.24 194.06,83.24 189.7,87.61 189.7,91.61 188.44,92.87 188.44,103.34 189.31,104.2 190.4,104.2 192.01,105.81 v1(192.01,108.15) 192.01,108.43 190.33,110.1 190.31,110.1 187.64,112.77 186.75,112.77 184.39,115.13 184.39,115.17 183.2,116.37 183.2,123.24 182.03,124.4 182.03,124.72 181.47,125.28 181.47,126.94 182.51,127.98 182.51,132.77 179.02,136.27 177.47,136.27 177.25,136.05 175.29,136.05 174.63,135.39 173.68,135.39 172.36,136.71 170.26,136.71 169.37,137.6 166.07,137.6 165.57,138.1 165.57,138.32 v1(164.96,138.93)
  IN2 w0.127: v1(198.87,80.36) 198.44,79.93 198.44,65.12 v1(197.57,64.26)
  BOTTOM w0.114: PR307.2 194.39,64.26 v3(196.38,64.26) v1(197.57,64.26)
51211V_DRVH: length 6.5
  IN2 w0.762: v4(82.7,115.91) 82.7,114.4 81.64,113.34 80.8,113.34 79.53,112.08 v4(78.72,112.08)
51211V_DRVL: length 10.5
  IN2 w0.762: v4(81.9,122.35) 80.79,122.35 78.19,119.76 78.19,115.11 v4(77.45,114.37)
  vias: v3(81.9,123.11)
51211V_EN: length 4.9
  TOP w0.114: v3(71.74,111.98) 72.5,111.98 v1(72.91,112.39)
  TOP w0.203: v1(72.91,112.39) 73.04,112.39 73.42,112.01 PR72.2
  BOTTOM w0.203: PR254.2 72.79,112.39 v1(72.91,112.39) 73.29,112.77 PU12.3
51211V_FB: length 4.8
  TOP w0.203: PR66.1 73.16,114.3 73.04,114.42 v3(72.5,114.42) 72.91,114.02 v1(72.91,113.66)
  BOTTOM w0.203: PR251.2 72.53,114.04 v1(72.91,113.66) 72.91,113.53 73.29,113.15 73.8,113.15 73.92,113.27 PU12.4
51211V_SW: length 10.8
  TOP w0.114: v3(82.05,120.26) 81.98,120.19 PR76.1
  TOP w0.762: PR76.1 v4(82.81,119.25)
  IN2 w0.762: v4(82.81,119.25) 80.99,119.25 79.08,117.34 79.08,113.25 v4(78.84,113.01)
51211V_TRIP: length 3.8
  TOP w0.203: PR74.2 73.46,110.92 72.56,110.92 v3(72.5,110.97) 72.5,111.35 v1(72.91,111.76)
  BOTTOM w0.203: PU12.2 73.68,112.27 73.16,111.76 v1(72.91,111.76)
51211V_TST: length 2.9
  TOP w0.114: PR71.2 72.4,113.03 v3(72.28,113.15)
  TOP w0.203: v1(73.55,113.66) 73.54,113.65 PR71.2
  BOTTOM w0.203: v1(73.55,113.66) 73.66,113.77 PU12.5
51211V_VBST:
  vias: v3(78.93,110.89)
+1.5V: length 378.8
  TOP w0.178: U18.20 22.29,72.28 ; 22.29,72.28 22.23,72.35 ; 22.29,72.28 22.69,71.88 U18.19 ; C385.1 26.62,73.52 25.69,72.59 25.69,71.4 25.49,71.2 U18.12 ; U18.31 22.29,65.33 21.2,64.23 20.77,64.23 C409.1 ; C410.1 27.19,63.82 27.19,64.69 26.76,65.12 26.02,65.12 25.89,65.25 U18.40
  TOP w0.381: v1(26.66,64.41) 27.26,63.81 C410.1
  TOP w0.508: v1(74.18,19.81) 76.62,19.81 v1(77.58,18.84) ; v1(165.72,31.62) 171.32,31.62 171.7,32 175.43,32 176.25,32.83 176.25,42.95 177.17,43.87 v1(177.17,46.12) ; v1(43.01,48.64) 43.66,47.99 C474.1 43.66,46.1 43.78,45.98 Q29.2 43.78,44.32 44.16,43.94 v1(44.16,42.92) ; v1(41.11,25.4) 41.61,25.4 C541.2 40.82,26.69 L18.2
  TOP w0.762: C385.1 26.89,72.64 26.5,72.26 ; 20.79,65.02 20.54,64.77 C409.1 ; v1(20.66,71.75) 20.41,72 v1(20.41,72.54) 20.41,73.14 C384.1 20.79,73.4 21.42,72.77 21.81,72.77 22.23,72.35
  IN1 w0.508: v1(28.54,42.41) 30.82,42.41 32.6,44.19 34,44.19 35.27,42.92 v1(44.16,42.92) 44.44,42.92 50.79,36.57 50.79,33.17 53.66,30.3 v1(53.66,29.56) ; v1(165.72,31.62) 164.93,32.41 91.07,32.41 88.91,30.25 81.78,30.25 77.03,25.5 v1(75.04,25.5) 75.02,25.5 74.31,26.21 63.51,26.21 62.9,26.82 62.01,26.82 58.61,30.22 56.93,30.22 52.26,34.9 52.26,37.13 43.8,45.59 43.8,46.35 43.01,47.14 v1(43.01,48.64) ; v1(164.99,94.05) 164.99,90.34 165.44,89.89 165.44,89.15 166.15,88.44 168.03,88.44 168.39,88.08 v1(168.39,87.79) 168.39,87.54 165.81,84.96 162.9,84.96 161.89,83.94 161.89,82.66 162.39,82.16 162.88,82.16 164.24,80.81 164.9,80.81 165.82,79.88 165.82,75.08 169.25,71.65 169.25,48.71 169.51,48.46 169.51,45.79 170.47,44.83 175.88,44.83 v1(177.17,46.12)
  IN1 w1.016: 27.9,41.52 26.84,40.46 26.84,39.44 25.62,38.22 24.85,38.22 24.09,37.46 19.99,37.46 18.66,38.8 18.66,45.98 20.25,47.57 20.25,53.55 24.09,57.4 24.09,60.08 24.73,60.71 24.73,62.48 v1(26.66,64.41) 25.41,65.65 22.06,65.65 20.92,66.8
  IN2 w0.508: v1(72.91,18.08) 72.96,18.13 72.96,23.41 v1(75.04,25.5) ; v1(53.66,29.56) 51.83,27.73 46.24,27.73 43.9,25.4 v1(41.11,25.4)
  BOTTOM w0.508: PR328.1 77.58,18.73 v1(77.58,18.84) ; v1(168.39,87.79) 171.86,87.79 172.3,88.24 Q38.1 174.21,87.57 C759.2 R712.1 ; R683.2 164.83,94.2 v1(164.99,94.05)
  vias: v1(20.66,64.77) v1(21.17,65.15) v1(26.25,71.88) v1(26.5,72.51) v1(27.9,42.41) v3(73.04,16.2) v3(73.42,19.25)
+1.5V_GFX: length 90.6
  TOP w0.229: U4.H2 206.07,166.23 206.46,166.62 207.41,166.62 v1(207.5,166.53) ; 199.86,167.42 200.62,167.42 200.65,167.45 v1(200.86,167.45) ; U4.K8 201.66,167.43 v1(201.66,166.66) ; U5.K8 213.54,167.42 v1(213.54,166.62)
  TOP w0.254: U4.D9 200.47,163.02 v1(200.87,163.42) U4.E9 ; v1(200.86,167.45) 200.86,167.62 201.06,167.82 U4.K8
  TOP w0.305: U3.A8 v1(183.79,175.07)
  TOP w0.33: v1(184.65,179.9) 185.01,180.26 U3.G7 ; v1(172.74,180.73) 173.14,180.33 U2.G7 ; U2.N1 178.74,185.1
  TOP w0.356: v1(200.07,165.82) 200.47,166.22 U4.H9 ; v1(205.67,165.83) 206.07,166.22 U4.H2 ; U4.F1 206.9,164.62 v1(207.28,164.23) ; v1(207.27,161.82) 206.87,162.22 U4.C1 U4.D2 ; U5.G7 214.07,165.29 214.72,165.29 v1(214.87,165.44) ; U5.N1 218.74,170.22 v1(219.14,170.62) ; U4.A1 v1(207.27,160.22) ; v1(199.7,169.64) 200.28,170.22 U4.N9 ; U4.K2 206.11,167.82 v1(206.48,167.45) ; v1(201.67,165.86) 201.97,165.56 201.97,165.52 U4.G7 ; U4.R9 200.25,171.6 197.68,171.6 ; v1(219.14,172.22) 218.74,171.82 U5.R1 ; v1(206.49,161.82) 206.47,161.82 U4.B2 ; U4.A8 v1(200.87,161.02) ; U3.H2 v1(189.41,181.5) ; 183.36,186.7 U3.R9 ; U4.N1 207.09,170.22 v1(207.4,169.91) ; v1(218.34,167.42) 217.94,167.82 U5.K2
  TOP w0.381: v1(200.86,161.85) 200.49,162.22 U4.C9
  TOP w0.406: R48.2 193.13,180.21 192.84,179.92 191.89,179.92 191.86,179.95
  TOP w0.457: 198.54,169.74 199.6,169.74 v1(199.7,169.64)
  TOP w0.508: v1(188.59,156.8) 188.53,156.87 C95.2 ; v1(188.6,160.95) 188.53,160.88 C82.2
  IN1 w0.305: v1(183.81,180.7) 183.86,180.7 184.65,179.91 v1(184.65,179.9)
  IN1 w0.356: v1(188.58,179.91) 187.94,179.91 187.66,179.63 187.66,179.16 188.49,178.33 188.58,178.33 v1(189.42,177.49)
  IN2 w0.203: v1(217.82,118.23) 217.64,118.41 217.64,124.14 216.47,125.31 216.47,130.65 216.17,130.96 v1(214.21,130.96)
  BOTTOM w0.203: v1(217.82,118.23) 217.82,118.06 218.4,117.47 PR259.1 ; PC193.2 211.8,120.14 212.72,120.14 212.94,119.92 PU11.7
  BOTTOM w0.229: v1(190.21,181.5) 190.37,181.66 190.37,182.08 190.15,182.29 189.29,182.29 189.01,182.57 U3.K2 ; U4.K8 201.4,167.82 201.66,167.56 v1(201.66,166.66) ; v1(213.54,166.62) 213.54,167.42 U5.K8
  BOTTOM w0.254: v1(187.7,165.14) 187.33,165.52 U34.H24 ; v1(171.93,182.28) 172.34,182.7 U2.K8
  BOTTOM w0.305: v1(171.95,181.5) 172.34,181.11 U28.H2 172.38,181.1 v1(172.74,180.73) ; v1(177.58,175.07) 177.56,175.07 U28.A8 ; v1(187.13,168.6) 187.23,168.51 187.23,167.19 U34.H26
  BOTTOM w0.33: U3.C1 190.17,177.45 v1(190.21,177.5) ; v1(188.58,179.91) 188.21,180.28 U29.G7 ; U29.D9 189.96,178.04 190.08,178.04 v1(190.32,178.29) ; U3.R9 183.12,186.41 181.98,186.41 181.95,186.43 ; v1(171.94,177.5) U28.D2 ; v1(190.21,181.5) U29.H9 ; U29.A8 189.05,175.5 v1(189.46,175.09) ; U28.G7 v1(176.73,180.68) ; U29.E9 189.85,178.7 v1(190.29,179.13)
  BOTTOM w0.356: U4.R1 207.49,172.44 v1(207.49,172.54) ; v1(183.81,182.32) 183.84,182.32 U3.K8 ; v1(219.14,170.62) 218.74,170.22 U5.N1 ; v1(205.67,165.83) 205.27,165.42 U31.G7 ; v1(213.54,166.62) 213.14,166.22 U32.H2 ; U29.H9 189.81,181.1 v1(189.41,181.5) ; U5.R1 218.74,171.82 v1(219.14,172.22) ; U4.N9 200.28,170.22 v1(199.7,169.64) ; v1(201.67,165.86) 201.31,166.22 U31.H2 201.27,166.23 201.66,166.62 v1(201.66,166.66) ; v1(216.24,165.43) 216.38,165.29 217.01,165.29 U32.G7
  BOTTOM w0.381: v1(184.38,166.74) 184.76,167.12 U34.L26 ; v1(190.17,165.11) 190.17,165.06 U34.E23 ; U34.C25 191.82,166.71 ; 191.82,166.71 v1(191.82,166.71) ; 191.82,166.71 U34.B26 ; U34.L24 184.79,165.52 184.44,165.18 184.44,165.14 v1(184.43,165.14)
  BOTTOM w0.4: v1(190.23,167.5) 190.08,167.35 190.01,167.35 U34.E26
  BOTTOM w0.508: PC193.2 211.3,121.32 210.82,121.8 210.82,129.19 211.29,129.66 ; C592.2 192.96,178.56 v1(192.21,178.56)
  vias: v1(164.83,186.25) v1(164.81,185.42) v1(164.76,184.65) v1(164.76,183.87) v1(164.78,183.08) v1(165.67,174.29) v1(165.67,173.58) v1(165.67,172.89) v1(165.65,172.18) v1(165.82,182.88) v1(166.46,185.44) v1(166.64,187.27) v1(167.22,181.17) v1(167.2,180.41) v1(167.17,179.68) v1(167.32,187.24) v1(167.3,185.47) v1(167.27,182.62) v1(167.25,181.91) v1(167.37,188.79) v1(168.31,188.84) v1(171.01,180.74) v1(171.14,187.1) v1(171.14,185.5) v1(171.14,179.1) v1(171.12,178.28) v1(171.08,175.05) v1(171.94,176.72) v1(171.94,175.1) v1(177.2,190.34) v1(177.53,181.48) v1(177.54,176.7) v1(177.56,178.28) v1(177.84,190.14) v1(177.77,163.49) v1(178.34,179.1) v1(178.37,178.23) v1(178.35,177.49) v1(178.55,190.14) v1(178.61,163.49) v1(179.01,187.12) v1(179.18,184.27) v1(182.23,184.88) v1(182.78,162.57) v1(182.93,179.03) v1(183.02,176.7) v1(183.07,190.27) v1(183.54,162.57) v1(183.79,177.5) v1(183.81,176.66) v1(186.89,163.49) v1(188.54,163.44) v1(188.6,161.79) v1(188.59,158.48) v1(188.57,157.64) v1(189.42,176.68) v1(190.87,186.3) v1(190.85,184.73) v1(196.18,155.57) v1(196.68,155.06) v1(197.53,162.15) v1(197.57,169.81) v1(197.73,165.35) v1(198.03,161.67) v1(198.08,170.81) v1(199.73,157.86) v1(200.85,157.84) v1(202.02,157.86) v1(202.81,157.84) v1(203.72,157.84) v1(204.2,187.29) v1(204.25,182.6) v1(204.81,182.01) v1(204.89,187.27) v1(205.42,186.58) v1(205.45,150.11) v1(205.57,187.3) v1(205.7,157.86) v1(205.7,149.47) v1(206.11,186.61) v1(206.08,150.11) v1(206.16,180.84) v1(206.34,149.47) v1(206.74,186.58) v1(206.72,150.11) v1(206.97,149.47) v1(207.35,150.11) v1(207.61,149.47) v1(207.99,150.11) v1(208.24,149.47) v1(211.03,173) v1(210.96,170.2) v1(211.94,165.82) v1(211.89,161.82) v1(211.89,160.22) v1(212.13,157.81) v1(212.59,158.29) v1(212.74,164.22) v1(212.74,163.42) v1(212.71,161.83) v1(213.14,158.67) v1(213.24,159.9) v1(215.14,157.87) v1(215.69,158.41) v1(216.18,158.94) v1(217.51,161.02) v1(218.15,175.84) v1(218.34,165.83) v1(218.34,163.42) v1(218.81,175.1) v1(219.16,163.44) v1(219.16,162.64) v1(219.21,160.1) v1(219.34,165.35) v1(219.54,157.93) v1(219.85,174.04) v1(219.93,172.21) v3(212.13,149.17) v3(212.97,133.14)
+1.05V_GFX: length 22.9
  BOTTOM w0.254: PR311.2 197.2,63.12 198.21,64.13 198.21,65.15 195.11,68.25 195.11,73.88 195.38,74.15 195.38,78.65 194.65,79.37 191.99,79.37
  vias: v1(170.92,157.75) v1(172.83,167.51) v1(172.82,165.11) v1(172.83,156.82) v1(173.63,165.06) v1(174.43,162.61) v1(174.43,159.28) v1(174.43,157.63) v1(174.48,165.93) v1(174.46,164.27) v1(176.06,155.98) v1(177,156.13) v1(177.03,153.72) v1(179.49,140.66) v1(179.51,140.03) v1(183.73,83.56) v1(183.98,84.2) v1(184.34,82.93) v1(184.37,83.56) v1(184.62,84.2) v1(185,83.56) v3(187.16,83.23) v3(188,77.34) v4(166.54,165.4) v4(166.46,163.7) v4(166.56,164.51)
+1.5V_GFX_VCC: length 6.6
  IN2 w0.203: v1(212.27,118.61) 214.07,120.42 v1(217.16,120.42)
  BOTTOM w0.508: PR255.2 v1(212.27,118.61)
+1.5VA: length 3.5
  TOP w0.508: L18.1 39.97,28.65 39.97,30.48 39.45,30.99 C524.1
  vias: v3(38.19,32.51)
+1.8V_PRIM: length 18.5
  IN1 w0.508: v5(121.63,128.01) 121.45,128.01 120.62,128.84 118.74,128.84 118.15,129.43 112.45,129.43 v1(111.53,128.52)
  BOTTOM w0.254: U35.G61 121.68,126.92 121.18,126.42 U35.H63
  BOTTOM w0.305: v5(121.63,128.01) 121.63,127.17 121.88,126.92
  BOTTOM w0.508: v1(111.53,128.52) 111.14,128.91 C687.1 C686.1 109.8,129.05 109.8,129.69 109.31,130.19 109.31,130.92 108.7,131.53 R565.1
+1.8V_S5: length 208.9
  TOP w0.203: v1(100.8,131.31) 103.29,133.8 103.97,133.8 105.5,135.33 105.5,138.65 v1(105.65,138.81)
  TOP w0.381: v1(169.08,112.42) 168.97,112.52 166.08,112.52 165.58,113.01 v1(165.06,113.01)
  TOP w0.508: v1(94.07,110.44) 93.66,110.84 93.66,114.27 95.43,116.04 95.43,126.81 98.03,129.41 100.78,129.41 103.2,131.82 v1(105.65,131.82)
  IN1 w0.508: v1(167.73,102.1) 166.41,100.78 166.41,96.52 167.07,95.86 167.38,95.86 167.83,95.41 167.83,93.14 167.5,92.81 166.54,92.81 166.26,92.53 166.26,89.58 166.76,89.07 168.31,89.07 169.02,88.36 169.02,87.27 167.25,85.49 167.25,85.49 165.7,83.94 162.85,83.94 v1(162.52,83.61) ; v1(165.04,115.25) 165.21,115.08 168.52,115.08 168.95,115.52 v1(168.95,115.95)
  IN2 w0.508: v1(163.96,118.2) 163.96,117.99 164.86,117.09 165.6,117.09 166.03,116.67 166.03,116.14 165.66,115.77 165.65,115.77 165.13,115.25 v1(165.04,115.25) 165.06,115.23 v1(165.06,113.9) v1(165.06,113.01) ; v1(92.25,86.71) 92.25,100.41 93.43,101.6 93.43,109.47 94.07,110.1 v1(94.07,110.44)
  BOTTOM w0.114: v1(163.96,118.2) 163.88,118.28 R775.1
  BOTTOM w0.203: v1(105.65,138.81) PR246.1
  BOTTOM w0.381: R590.2 164.99,115.19 v1(165.04,115.25)
  BOTTOM w0.508: v1(165.16,111.82) 165.15,111.83 R611.2 164.49,110.87 R615.2 ; R607.2 168.95,115.38 v1(168.95,115.95) ; R767.2 165.02,112.98 v1(165.06,113.01) ; v1(167.73,102.1) 168.52,102.89 168.52,103.86 168.62,103.96 168.62,104.51 170.57,106.47 170.57,108.12 171.08,108.63 171.08,110.62 170.32,111.37 168.98,111.37 R613.2 169.08,112.23 v1(169.08,112.42) 168.72,112.77 R608.2 R600.2 ; R593.2 165.23,115.06 v1(165.04,115.25) ; v1(92.25,86.71) v1(93.41,86.71) 95.06,86.71 95.4,87.05 145.25,87.05 145.26,87.05 145.54,87.05 149.87,82.72 161.43,82.72 162.32,83.61 v1(162.52,83.61) ; v1(100.8,131.31) 101.05,131.57 104.36,131.57 104.61,131.82 v1(105.65,131.82) 105.8,131.67 R565.2 ; v1(165.06,113.9) 164.9,114.07 R599.2
  vias: v3(100.09,132.71)

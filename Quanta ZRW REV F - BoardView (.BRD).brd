# Allegro board Quanta ZRW REV F - BoardView (.BRD).brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
M_B_DQS#2: length 64.5
  IN2 w0.076: 119.38,110.4 119.38,110.72 119.35,110.75 119.35,111.39 119.29,111.45 119.29,112.18 119.34,112.23 119.34,112.64 v2(118.96,113.03)
  IN2 w0.127: 119.38,110.4 119.38,110.18 119.06,109.86 118.43,109.86 118.15,110.14 117.06,110.14 116.36,109.44 116.36,108.5 115.79,107.94 115.41,107.94 113.89,106.42 113.89,102.98 114.11,102.76 114.11,99.13 112.22,97.24 112.22,96.4 112.49,96.14 113,96.14 113.13,96.01 113.13,95.63 113,95.5 112.49,95.5 112.22,95.23 112.22,94.65 112.49,94.38 113,94.38 113.13,94.26 113.13,93.88 113,93.75 112.49,93.75 112.22,93.48 112.22,92.9 112.49,92.63 113,92.63 113.13,92.5 113.13,92.12 113,92 112.49,92 112.22,91.73 112.22,91.15 112.49,90.88 113,90.88 113.13,90.75 113.13,90.37 113,90.24 112.49,90.24 112.22,89.98 112.22,83.11 113,82.32 113,68.72 114.33,67.38 114.33,65.53 114.74,65.13 115.03,65.13 v1(115.21,64.95)
  BOTTOM w0.114: v2(118.96,113.03) U35.AR66 ; v1(115.21,64.95) 114.34,65.82 114.34,67.21 114.44,67.32 JDIM1.45
M_B_DQS#3: length 56.8
  IN2 w0.076: 118.59,98.88 118.59,98.89 118.64,98.94 118.64,99.69 120.07,101.12 120.07,107.91 120.52,108.37 120.67,108.37 122.22,109.92 122.22,110.61 122.07,110.76 122.07,112.06 v2(121.69,112.44)
  IN2 w0.127: v1(119.12,62.7) 118.63,63.18 118.63,64.13 119.85,65.35 119.85,68.17 118.26,69.75 118.26,71.27 118.59,71.6 118.59,98.88
  BOTTOM w0.114: v1(119.12,62.7) 119.28,62.86 119.49,62.86 119.65,62.7 119.65,61.42 119.54,61.32 JDIM1.62 ; U35.AR61 v2(121.69,112.44)
M_B_DQS#4: length 58.3
  IN2 w0.076: 140.47,98.88 140.4,98.88 139.74,99.54 138.75,99.54 138.04,100.25 138.04,101.37 138.39,101.72 138.39,105.51 137.16,106.74 137.16,107.76 134.15,110.77 134.15,111.74 134.29,111.88 134.38,111.88 v5(134.51,111.76)
  IN2 w0.127: v1(144.47,64.7) 144.66,64.89 144.95,64.89 145.23,65.18 145.23,66.38 145.02,66.59 145.02,76.02 140.99,80.05 140.99,92.33 140.61,92.71 140.61,98.74 140.47,98.88
  BOTTOM w0.114: v5(134.51,111.76) U35.AT38 ; v1(144.47,64.7) 144.33,64.85 144.03,64.85 143.78,65.1 143.78,67.03 143.84,67.1 JDIM1.135
M_B_DQS#5: length 59.8
  IN2 w0.076: v2(138.11,111.74) 138.11,111.9 138.21,112.01 138.41,112.01 138.5,111.92 138.5,110.7 138.42,110.62 138.42,109.75 139.84,108.33 140.14,108.33 140.18,108.29 140.18,108.29 141,107.48 141,107.47 142.1,106.37 142.56,106.37 143.05,105.88 143.05,100.44 144.22,99.27 144.33,99.27 144.61,98.99 144.61,98.88
  IN2 w0.127: 144.61,98.88 144.61,94.61 145.96,93.26 145.96,80.6 149.19,77.37 149.19,70.32 149.58,69.93 149.58,64.83 150.46,63.95 150.46,63.18 150.32,63.04 150.15,63.04 v1(149.95,63.24)
  BOTTOM w0.114: v1(149.95,63.24) 149.54,62.84 149.34,62.84 149.06,62.56 149.06,61.34 148.94,61.22 JDIM1.152 ; v2(138.11,111.74) 138.45,111.74 138.6,111.89 U35.AT32
M_B_DQS#6: length 60
  IN2 w0.076: v2(141.83,112.42) 141.45,112.04 141.45,110.96 144.21,108.2 144.51,108.2 145.02,107.69 145.02,107.46 147.03,105.45 147.03,101.29 148.98,99.34 148.98,98.73 149.01,98.7 149.01,98.68 149.06,98.63 149.06,98.62
  IN2 w0.127: 149.06,98.62 149.06,96.4 150.33,95.13 150.33,94.49 150.46,94.36 150.57,94.36 150.84,94.1 150.84,93.51 150.57,93.25 150.46,93.25 150.33,93.12 150.33,92.74 150.46,92.61 150.57,92.61 150.84,92.34 150.84,91.76 150.57,91.49 150.46,91.49 150.33,91.37 150.33,90.99 150.46,90.86 150.57,90.86 150.84,90.59 150.84,90.01 150.57,89.74 150.46,89.74 150.33,89.61 150.33,89.23 150.46,89.11 150.57,89.11 150.84,88.84 150.84,88.26 150.57,87.99 150.46,87.99 150.33,87.86 150.33,87.48 150.46,87.35 150.57,87.35 150.84,87.08 150.84,86.5 150.57,86.24 150.46,86.24 150.33,86.11 150.33,82.41 154.18,78.56 154.18,68.63 155.39,67.42 155.39,66.24 155.15,66 154.61,66 v1(154.55,65.95)
  BOTTOM w0.114: JDIM1.169 154.04,67.34 153.63,66.92 153.63,66.25 153.88,66 154.5,66 v1(154.55,65.95) ; U35.AR25 v2(141.83,112.42)
M_B_DQS#7: length 61.8
  IN2 w0.076: v5(144.54,112.37) 144.64,112.47 144.77,112.47 144.92,112.32 144.92,111.2 145.21,110.91 145.21,110.08 146.24,109.05 146.84,109.05 148.07,107.82 148.07,107.72
  IN2 w0.127: v1(159.92,63.31) 159.92,63.1 160.04,62.98 160.39,62.98 160.55,63.14 160.55,63.58 160.01,64.12 160.01,67.58 159.47,68.12 159.47,68.88 158.62,69.73 158.62,82.09 155.04,85.67 155.04,96.93 152.95,99.02 152.95,101.82 150.18,104.59 150.18,104.63 149.75,105.06 149.75,105.74 148.07,107.41 148.07,107.72
  BOTTOM w0.114: v1(159.92,63.31) 159.92,63.11 159.74,62.94 159.42,62.94 159.14,62.66 JDIM1.186 ; v5(144.54,112.37) 144.27,112.37 144.09,112.51 U35.AR22
M_B_ODT0_DIMM: length 55.2
  IN2 w0.076: 136.78,98.12 136.73,98.17 136.61,98.17 134.4,100.38 134.4,103.3 v5(132.91,104.8)
  IN2 w0.216: 136.78,98.12 136.86,98.04 136.86,78.48 141.53,73.8 141.53,70.28 141.1,69.85 141.1,66.07 139.28,64.25 139.28,63.24 139.57,62.95 v1(140.03,62.95)
  BOTTOM w0.076: U35.BA42 133.39,108.82 133.53,108.68 133.53,108.67 133.53,108.67 133.65,108.42 133.65,107.29 133.45,107.09 133.45,106.87 133.31,106.73 133.31,105.19 v5(132.91,104.8)
  BOTTOM w0.165: v1(140.03,62.95) 139.67,62.95 138.14,61.42 JDIM1.116
M_B_ODT1_DIMM: length 57
  IN2 w0.076: 137.25,98.83 136.01,100.07 135.22,100.07 134.89,100.4 134.89,104.34 133.12,106.1 v1(132.75,106.1)
  IN2 w0.216: 137.25,98.83 138.06,98.02 138.06,78.6 142.47,74.19 142.47,69.85 142.04,69.41 142.04,63.33 140.37,61.67 v1(140.04,61.67)
  BOTTOM w0.076: v1(132.75,106.1) 132.96,106.31 132.96,106.86 133.12,107.02 133.12,107.23 133.32,107.43 133.32,107.93 133.12,108.13 133.12,108.22 133.12,108.22 133.12,108.42 133.15,108.5 133.17,108.52 133.17,108.75 133.12,108.86 133.12,109.09 133.16,109.17 133.16,109.43 133.12,109.46 133.12,109.77 133.16,109.81 133.16,110.04 U35.AW42
  BOTTOM w0.165: v1(140.04,61.67) 139.55,61.67 139.34,61.46 JDIM1.120
M_B_RAS#: length 56.2
  IN2 w0.076: 133.98,98.88 133.98,99.2 132.42,100.75 132.42,103.25 131.52,104.15 v1(131.34,104.15)
  IN2 w0.216: v1(136.16,62.45) 136.65,62.45 136.84,62.25 138.04,62.25 138.32,62.53 138.32,65.1 137.69,65.72 137.69,67.24 137.88,67.43 137.88,73.77 134.23,77.42 134.23,96.9 133.98,97.15 133.98,98.88
  BOTTOM w0.076: U35.AW44 132.16,110.11 132,109.94 131.89,109.73 131.87,109.66 131.87,109.19 131.63,108.96 131.63,106.71 131.53,106.61 131.53,105.48 131.56,105.45 131.56,104.52
  BOTTOM w0.102: 131.56,104.52 131.56,104.37 v1(131.34,104.15)
  BOTTOM w0.165: JDIM1.110 136.34,61.3 136.62,61.58 136.62,62.22 136.39,62.45 v1(136.16,62.45)
M_B_WE#: length 57.5
  IN2 w0.076: v1(132.91,101.55) 132.91,100.49 134.45,98.96 134.45,98.8
  IN2 w0.216: 134.45,98.8 134.45,97.4 134.7,97.15 134.7,77.62 138.39,73.92 138.39,66.9 v1(138.18,66.69)
  BOTTOM w0.076: U35.AY44 132.16,109.37 132.26,109.27 132.26,109.26 132.34,109.04 132.34,108.91 132.27,108.68 132.27,108.54 132.33,108.42 132.33,108.15 132.12,107.95 132.12,106.5 132.03,106.4 132.03,105.75 132.13,105.65 132.13,104.52
  BOTTOM w0.102: 132.13,104.52 132.13,101.78 132.36,101.55 v1(132.91,101.55)
  BOTTOM w0.165: JDIM1.113 137.24,67.14 136.62,66.52 136.62,65.72 136.29,65.4 135.25,65.4 134.84,64.99 134.84,64.13 135.09,63.88 135.64,63.88 135.93,64.17 136.69,64.17 137.63,65.1 137.63,66.41 137.9,66.69 v1(138.18,66.69)
MAIND: length 194.2
  TOP w0.254: v1(51.14,94.61) 57.24,100.71 v1(58.64,100.71) ; PQ6058.3 v1(87.82,34.18) 87.31,33.68 87.31,30.45 88,29.76 88,27.76 84.59,24.35 80.76,24.35 80.15,24.96 80.15,25.26 v1(80.16,25.27) ; PQ3.3 PC103.2 PR148.2 47.83,71.38 49.87,69.34 v1(50.51,69.34)
  IN1 w0.254: v1(51.14,94.61) 47.46,90.93 47.46,90.11 47.13,89.78 47.13,84.78 49.26,82.65 50.93,82.65 55.3,78.28 56.5,78.28 57.67,77.11 57.67,77.08 58.94,75.81 59.22,75.81 59.75,75.28 59.75,75 60.26,74.49 60.26,72.11 61.3,71.07 v1(61.3,69.16) 61.3,67.38 65.67,63.01 67.42,63.01 69.58,60.85 69.58,59.25 69.41,59.08 69.41,57.58 70.88,56.1 74.74,56.1 82.18,48.67 82.18,48.21 83.2,47.19 87.13,47.19 94.04,40.28 94.04,35.2 93.43,34.59 88.23,34.59 v1(87.82,34.18)
  IN2 w0.254: v1(50.51,69.34) 50.76,69.08 61.23,69.08 v1(61.3,69.16)
  BOTTOM w0.254: v1(80.16,25.27) 80.15,25.27 80.15,26.64 80.61,27.1 PQ38.4 81.79,27.1 82.28,27.6 PQ18.4 ; v1(58.64,100.71) 60.21,102.28 v3(65.24,102.28) 81.3,102.28 91.02,111.99 96.24,111.99 99.09,114.84 99.09,117.33 PQ26.4
MAINON: length 319.3
  TOP w0.114: v1(55.92,69.62) 56.5,69.62 57.85,70.96 PQ11.2 57.92,71.9 57.98,71.95 PR147.1 ; R791.1 51.53,9 51.79,8.74 U49.4 53.32,8.74 v1(53.56,8.5) ; v1(99.15,27.55) 100.88,25.83 136.31,25.83 138.14,24 165.32,24 166.26,24.94 179.08,24.94 180.3,26.16 180.3,27.1 v1(183.98,30.78)
  IN1 w0.127: v1(75.7,26.16) 75.7,29.21 73.75,31.16 69.08,31.16 68.62,30.7 67.78,30.7 67.07,29.99 67.07,27.48 66.36,26.77 64.55,26.77 62.24,29.08 62.24,30.27 61.58,30.93 57.26,30.93 52.97,35.23 52.97,37.44 50.03,40.38 50.03,59.33 52.91,62.21 52.91,66.28 55.92,69.29 v1(55.92,69.62)
  IN2 w0.127: v1(75.7,26.16) 75.7,24.48 77.36,22.83 77.36,19.83 v1(74.71,17.19) ; v1(99.15,27.55) 99.15,27.43 98.23,26.51 90.54,26.51 86.02,21.99 86.02,18 79.34,11.32 73.27,11.32 69.25,7.31 67.88,7.31 67.2,6.63 67.2,4.85 66.64,4.29 58.03,4.29 53.82,8.5 v1(53.56,8.5)
  BOTTOM w0.114: v1(74.71,17.19) 75.86,17.19 76.42,17.75 PR326.2 76.43,17.75 83.15,17.75 84.19,18.79 84.19,20.21 85.35,21.38 85.35,23.08 v3(85.64,23.36) 86.65,23.36 89.95,26.67 98.39,26.67 99.15,27.43 v1(99.15,27.55) ; PR301.1 172.81,66.54 171.92,65.65 171.92,51.3 170.57,49.96 170.57,37.8 174.66,33.72 177.95,33.72 180.89,30.78 v1(183.98,30.78)
MAINON_EC: length 187.6
  TOP w0.114: v1(209.13,31.95) 208.62,31.95 208.19,31.52 R389.1 193.86,31.16 192.73,32.28 186.3,32.28 180.56,26.54 180.56,25.78 179.49,24.71 166.41,24.71 165.32,23.62 137.63,23.62 135.72,25.52 100.55,25.52 v1(96.74,29.33) ; R791.2 50.03,11.32 49.62,10.92 v1(49.62,10.03) 49.63,10.04 U49.1
  IN2 w0.127: v1(96.74,29.33) 93,29.33 85.76,22.09 85.76,18.11 79.23,11.58 73.16,11.58 69.15,7.57 67.78,7.57 66.94,6.73 66.94,4.95 66.53,4.54 59.45,4.54 58.18,5.81 56.91,5.81 52.69,10.03 v1(49.62,10.03)
  BOTTOM w0.114: U45.30 208.87,32.31 209.13,32.05 v1(209.13,31.95)
MAINON_ON_G: length 28.4
  TOP w0.114: PQ3.2 47.33,76.2 v1(47.46,76.32) ; v1(51.27,76.32) 51.14,76.2 PQ4.2 ; PR150.1 PR151.2 57.26,67.47 PQ11.3 54.98,68.98 54.65,69.31 54.65,69.95 54.95,70.25 PQ10.2 v1(54.95,72.69) PQ5.2 55.71,75.18 55.97,75.43 v1(55.97,76.12)
  IN1 w0.127: v1(51.27,76.32) 50.76,75.81 47.97,75.81 v1(47.46,76.32)
  IN2 w0.127: v1(51.27,76.32) 50.79,76.81 50.79,78.25 51.14,78.61 51.8,78.61 53.35,77.06 54.8,77.06 55.74,76.12 v1(55.97,76.12)
MBCLK: length 252.8
  TOP w0.114: v1(211.75,189.43) 211.56,189.62 209.22,189.62 208.44,190.41 207.22,190.41 206.63,190.99 204.61,190.99 203.92,191.69 202.68,191.69 200.51,193.86 199.52,193.86 198.42,194.95 182.73,194.95 182.21,195.47 179.05,195.47 177.9,194.32 175.93,194.32 175.31,194.94 167.75,194.94 163.56,199.13 162.98,199.13 v3(162.06,198.22) 161.15,199.13 159.93,199.13 159.78,198.98 159.78,198.55 159.99,198.34 PD2.1 160.36,196.97 160.62,196.72 PC9.1 PR7.2
  IN2 w0.127: v1(211.16,193.92) 211.4,193.92 211.61,193.72 211.61,193.35 214.61,190.35 214.61,187.41 222.06,179.96 222.06,167.5 223.57,165.98 223.57,154.14 215.58,146.16 215.58,132.49 217.25,130.83 217.25,126.13 218.38,125 218.38,110.24 228.67,99.94 228.67,95.76 225.08,92.17 222.77,92.17 218.39,87.79 218.39,70.01 211.04,62.66 199.81,62.66 197.9,60.76 197.9,56.31 198.59,55.62 198.59,53.03 199.34,52.28 199.34,50.86 v1(199.18,50.69)
  BOTTOM w0.114: R731.1 199.18,50.83 v1(199.18,50.69) 199.38,50.5 199.38,50.08 199,49.7 199,47.29 199.29,47 199.29,46.65 199.25,46.61 199.25,46.5 199.11,46.37 U45.110 ; PR178.1 210.91,193.67 v1(211.16,193.92) 211.63,193.46 211.63,190.91 211.32,190.6 211.32,189.86 v1(211.75,189.43)
MBDATA: length 253.6
  TOP w0.114: PR6.2 PC8.1 158.58,197.23 158.2,197.61 PD1.1 158.76,198.34 159.82,199.4 161.98,199.4 v3(162.06,199.49) 162.15,199.4 163.67,199.4 167.86,195.21 175.42,195.21 176.04,194.59 177.79,194.59 178.94,195.74 182.32,195.74 182.84,195.22 198.53,195.22 199.63,194.12 200.62,194.12 202.79,191.96 204.03,191.96 204.73,191.26 206.74,191.26 207.33,190.67 208.55,190.67 209.33,189.89 211.57,189.89 v1(211.75,190.06)
  IN2 w0.127: v1(211.16,194.56) 211.89,193.84 211.89,193.47 214.89,190.46 214.89,187.52 222.34,180.07 222.34,167.61 223.85,166.1 223.85,154.03 215.86,146.04 215.86,132.61 217.53,130.95 217.53,126.25 218.66,125.12 218.66,110.36 228.95,100.06 228.95,95.65 225.2,91.89 222.89,91.89 218.67,87.68 218.67,69.9 211.15,62.38 199.92,62.38 198.18,60.64 198.18,56.42 198.87,55.74 198.87,53.15 199.62,52.39 199.62,50.93 v1(199.86,50.69)
  BOTTOM w0.114: R732.1 199.58,51.27 199.58,50.9 199.78,50.69 ; 199.78,50.69 199.64,50.55 199.64,49.97 199.26,49.59 199.26,47.4 199.56,47.11 199.56,46.54 199.51,46.5 U45.111 ; 199.78,50.69 v1(199.86,50.69) ; v1(211.75,190.06) 211.58,190.23 211.58,190.49 211.9,190.8 211.9,193.83 v1(211.16,194.56) 210.91,194.81 PR177.1
MDI_0+: length 8.7
  TOP w0.114: U15.1 33.3,88.52 32.67,89.15 32.42,89.15 32.14,89.43 v1(31.99,89.43)
  BOTTOM w0.114: U42.2 28.03,91.96 28.24,91.74 29.63,91.74 30.7,90.67 30.7,89.91 31.18,89.43 v1(31.99,89.43)
MDI_0-: length 8.6
  TOP w0.114: U15.2 32.9,88.12 32.44,88.58 32.18,88.58 v1(31.99,88.77)
  BOTTOM w0.114: v1(31.99,88.77) 31.9,88.86 30.94,88.86 30.12,89.68 30.12,90.44 29.39,91.17 28.27,91.17 28.06,90.96 U42.3
MDI_1+: length 7.5
  TOP w0.114: U15.4 32.98,87.32 32.96,87.29 32.27,87.29 31.76,87.8 v1(31.58,87.8)
  BOTTOM w0.114: v1(31.58,87.8) 29.89,87.8 28.97,88.72 28.27,88.72 28.03,88.96 U42.5
MDI_1-: length 7.4
  TOP w0.114: U15.5 31.84,86.92 v1(31.58,87.17)
  BOTTOM w0.114: U42.6 28.04,87.96 28.23,88.15 28.74,88.15 29.65,87.23 31.52,87.23 v1(31.58,87.17)
MDI_2+: length 7.2
  TOP w0.114: v1(31.61,86.36) 31.77,86.52 U15.6
  BOTTOM w0.114: v1(31.61,86.36) 31.52,86.27 30.48,86.27 29.93,85.72 28.31,85.72 28.07,85.96 U42.8
MDI_2-: length 7.3
  TOP w0.114: U15.7 33.22,86.12 33.04,85.95 32.06,85.95 31.81,85.7 v1(31.61,85.7)
  BOTTOM w0.114: U42.9 28.05,84.96 28.25,85.15 30.17,85.15 30.72,85.7 v1(31.61,85.7)
MDI_3+: length 10.3
  TOP w0.114: v1(33.36,83.56) 33.51,83.56 34.5,84.55 U15.9
  BOTTOM w0.114: U42.11 28.16,82.96 28.25,82.87 28.25,82.64 28.36,82.53 33.43,82.53 33.78,82.88 33.78,83.4 33.62,83.56 v1(33.36,83.56)
MDI_3-: length 10.2
  TOP w0.114: v1(34.35,83.6) 34.9,84.15 U15.10
  BOTTOM w0.114: U42.12 33.66,81.96 34.35,82.65 v1(34.35,83.6)
ME_WR#: length 3.3
  BOTTOM w0.114: R737.1 198.64,48.58 v1(198.64,46.99) 198.64,46.68 198.71,46.6 U45.109
MIC2-VREFO: length 37.8
  TOP w0.203: v1(31.71,29.33) 32,29.62 U23.29
  TOP w0.381: R424.1 v1(19.69,12.49) ; v1(17.18,21.74) 17.46,22.02 17.46,22.17 v3(17.61,22.32) 18.45,21.48 R407.1
  IN2 w0.381: v1(19.69,12.49) 19.14,12.49 17.47,14.16 15.88,14.16 15.54,14.49 15.54,17.46 15.51,17.49 15.51,19.22 16.65,20.37 16.65,21.2 v1(17.18,21.74) 16.62,22.3 16.62,24.1 19.88,27.36 26.53,27.36 27.62,28.44 30.06,28.44 30.95,29.33 v1(31.71,29.33)
MOD_EN_5V: length 7.6
  BOTTOM w0.114: Q37.6 217.21,92.97 216.98,93.2 C752.1 216.98,94.65 216.63,94.99 R686.1 v1(216.63,96.62) 216.63,97.9 217.6,98.86 Q34.3
MPHY_EXT_PWR: length 18.2
  TOP w0.114: v2(151.8,115.21) 151.8,115.85 152.29,116.33 153.81,116.33 153.94,116.2 155.48,116.2 156.07,115.61 156.07,114.91 157.41,113.57 162.26,113.57 162.6,113.92 162.6,114.24 162.89,114.53 163.02,114.53 163.42,114.93 164.3,114.93 164.43,114.8 165.79,114.8 R195.2
  BOTTOM w0.114: v2(151.8,115.21) 151.8,115.08 U35.AM10
MX0: length 36.6
  TOP w0.114: v1(188.99,22.58) 190.19,22.58 192.98,25.37 194.92,25.37 195.38,25.83 196.13,25.83 v1(196.3,25.65) 196.59,25.65 197.07,26.13 198.33,26.13 198.56,26.35 198.56,26.99 199.3,27.73 199.3,28.28 198.85,28.72 198.36,28.72 198.23,28.6 RP1.4
  IN2 w0.127: v1(188.99,22.58) 186.86,20.44 180.66,20.44 179.29,19.07 179.29,17.91 178.64,17.27 178.27,17.27 v1(177.76,17.78)
  BOTTOM w0.114: U45.58 196.31,28.56 196.2,28.44 v1(196.2,27.53) 196.2,25.95 196.3,25.85 v1(196.3,25.65) ; CN20.1 176.79,17.73 177.1,18.03 177.63,18.03 177.76,17.9 v1(177.76,17.78) ; CP6.1 v1(188.99,22.58)
MX1: length 38.8
  TOP w0.114: RP1.5 198.67,29.23 199.57,28.33 199.57,27.37 v1(199.5,27.3) 198.79,26.59 198.79,26.23 198.46,25.9 197.44,25.9 196.77,25.22 196.13,25.22 195.96,25.4 v1(195.67,25.4) 195.27,25.4 195.02,25.14 193.08,25.14 190.09,22.15 188.63,22.15 v1(188.2,22.58)
  IN2 w0.127: v1(178.52,17.78) 179.03,18.28 179.03,19.17 180.56,20.7 186.32,20.7 v1(188.2,22.58)
  BOTTOM w0.114: CP6.3 v1(188.2,22.58) ; U45.59 195.91,29.04 195.77,28.9 195.77,26.89 195.87,26.79 195.87,26.31 195.67,26.11 v1(195.67,25.4) ; CN20.2 175.79,17.84 176.24,18.28 178.14,18.28 178.52,17.9 v1(178.52,17.78)
MX2: length 38
  TOP w0.114: RP1.3 197.93,27.96 198.46,28.49 198.76,28.49 199.07,28.18 199.07,27.83 198.33,27.09 198.33,26.45 198.23,26.35 196.95,26.35 196.67,26.08 193.81,26.08 v1(193.64,25.9) 193.57,25.84 193.13,25.84 190.29,23 187.76,23 v1(187.39,22.63)
  BOTTOM w0.114: CN20.3 174.79,17.98 174.98,18.17 175.8,18.17 176.17,18.54 178.66,18.54 178.66,18.54 179.31,18.54 181.01,20.24 185.36,20.24 187.39,22.27 v1(187.39,22.63) CP6.5 ; U45.60 195.51,26.56 v1(195.44,26.49) 194.86,25.9 v1(193.64,25.9)
MX3: length 32.7
  TOP w0.114: v1(186.6,22.58) 188.84,24.81 191.78,24.81 193.48,26.51 v1(194.78,26.51) 194.99,26.3 196.58,26.3 196.96,26.69 RP1.1
  BOTTOM w0.114: CP6.7 v1(186.6,22.58) 186.6,22.48 v3(186.08,21.96) 184.59,20.47 180.89,20.47 179.18,18.77 178.75,18.77 176.07,18.77 175.71,18.4 174.19,18.4 173.79,18 CN20.4 ; U45.61 195.11,28.97 195.19,28.9 195.19,27.25 194.78,26.84 v1(194.78,26.51)
MX4: length 32.6
  TOP w0.114: v1(185.25,22.53) 187.77,25.04 189.86,25.04 192.19,27.37 v1(193.5,27.37) 193.96,27.37 194.5,27.91 195.01,27.91 195.16,27.76 195.16,27.53 195.36,27.33 RP1.9
  BOTTOM w0.114: CP5.1 185.18,22.6 v1(185.25,22.53) 185.25,22.17 183.78,20.7 180.78,20.7 179.08,18.99 178.85,18.99 178.85,19 175.98,19 175.61,18.63 174.1,18.63 173.64,18.17 173.08,18.17 172.79,17.89 CN20.5 ; U45.62 v1(194.71,28.44) 194.71,28.12 193.96,27.37 v1(193.5,27.37)
MX5: length 32.1
  TOP w0.114: RP1.7 193.94,28.6 v1(193.94,28.59) 192.76,28.59 189.73,25.55 187.01,25.55 184.39,22.93 v1(184.39,22.55)
  BOTTOM w0.114: U45.63 194.31,28.97 v1(193.94,28.59) ; CN20.6 171.79,18.03 171.95,18.18 172.58,18.18 172.8,18.4 173.55,18.4 174,18.86 175.52,18.86 175.88,19.22 178.98,19.22 180.71,20.95 183.3,20.95 v3(184.21,21.87) 184.39,22.04 v1(184.39,22.55) CP5.3
MX6: length 34
  TOP w0.114: RP1.8 195.31,27.96 195.06,28.22 194.28,28.22 194.09,28.02 v1(193.51,28.02) 192.52,28.02 189.77,25.27 187.39,25.27 184.82,22.7 184.82,22.37 184.54,22.09 183.96,22.09 183.58,22.47 v1(183.58,22.6)
  BOTTOM w0.114: v1(193.51,28.02) 193.51,28.82 193.91,29.23 U45.64 ; CP5.5 v1(183.58,22.6) 183.58,22.04 v1(182.94,21.41) 182.71,21.18 180.61,21.18 178.9,19.48 178.87,19.48 175.78,19.48 175.39,19.09 173.91,19.09 173.45,18.63 172.65,18.63 172.43,18.41 171.16,18.41 170.79,18.05 CN20.7
MX7: length 36.3
  TOP w0.114: RP1.6 193.03,29.23 192.54,29.71 v1(191.81,29.71) 189.73,29.71 182.79,22.77 v1(182.79,22.55)
  BOTTOM w0.114: v1(191.81,29.71) 191.2,30.33 v3(191.2,30.6) 191.2,31.39 191.32,31.52 U45.65 ; CN20.8 169.79,18.06 170.37,18.64 172.28,18.64 172.49,18.86 173.36,18.86 173.82,19.31 175.29,19.31 175.69,19.71 178.58,19.71 178.78,19.71 179.66,20.58 179.66,20.58 180.07,21 180.07,21 180.49,21.42 182.27,21.42 182.42,21.58 182.43,21.58 182.79,21.93 v1(182.79,22.55) CP5.7
MY0: length 65.7
  TOP w0.114: v1(205.25,28.7) 205.25,28.89 203.22,30.93 193.76,30.93 192.91,31.78 186.69,31.78 v3(185.86,30.95) 185.81,30.91 185.81,30.12 180.15,24.46 167.07,24.46 v1(165.82,23.21)
  BOTTOM w0.114: U45.36 205.11,28.84 v1(205.25,28.7) ; CP1.7 167.93,23.24 167.66,22.96 167.44,22.96 167.07,23.34 165.95,23.34 v1(165.82,23.21) 165.57,22.96 156.61,22.96 151.79,18.15 CN20.26
MY1: length 63.8
  TOP w0.114: v1(166.87,22.86) v3(167.78,22.86) 168.36,22.86 169.74,24.23 180.24,24.23 187.57,31.56 192.81,31.56 193.67,30.7 202.97,30.7 204.62,29.04 v1(204.62,28.64)
  BOTTOM w0.114: v1(204.62,28.64) 204.71,28.73 U45.37 ; CN20.25 152.79,18.72 156.77,22.69 166.33,22.69 166.49,22.86 v1(166.87,22.86) 167.07,22.86 167.23,22.69 168.49,22.69 168.72,22.92 CP1.5
MY2: length 62.2
  TOP w0.114: v1(204.41,28.04) 204.19,28.25 204.19,28.99 202.71,30.47 193.57,30.47 192.72,31.33 187.66,31.33 180.34,24 170.78,24 v3(170.17,23.39) v1(169.41,22.63)
  BOTTOM w0.114: CP1.3 169.53,22.75 v1(169.41,22.63) 169.2,22.42 156.88,22.42 153.79,19.34 CN20.24 ; v1(204.41,28.04) 204.19,28.25 204.19,28.91 204.31,29.03 U45.38
MY3: length 59.4
  TOP w0.114: v1(203.77,28.69) 203.77,29.01 202.53,30.24 193.48,30.24 192.62,31.1 188.89,31.1 183.09,25.3 182.8,25.3 v1(182.11,24.61) 181.27,23.77 171.49,23.77 v1(170.32,22.6)
  BOTTOM w0.114: U45.39 203.91,28.83 v1(203.77,28.69) ; CP1.1 v1(170.32,22.6) 170.14,22.6 169.71,22.17 157.14,22.17 154.79,19.83 CN20.23
MY4: length 59.5
  TOP w0.114: v1(171.62,22.6) 172.3,23.29 v1(172.33,23.29) 172.58,23.54 181.66,23.54 188.98,30.87 192.53,30.87 193.38,30.01 202.36,30.01 203.34,29.03 203.34,28.47 v1(203.77,28.04)
  BOTTOM w0.114: CP2.7 v1(171.62,22.6) 171.11,22.6 170.62,22.12 170.34,22.12 170.16,21.94 157.8,21.94 155.79,19.94 CN20.22 ; v1(203.77,28.04) 203.34,28.47 203.34,28.88 203.51,29.05 U45.40
MY5: length 56.2
  TOP w0.114: v1(172.33,22.6) 173.01,23.29 182.66,23.29 189.99,30.61 192.46,30.61 193.29,29.78 201.8,29.78 v1(202.91,28.67)
  BOTTOM w0.114: CN20.21 156.79,19.8 158.69,21.69 170.29,21.69 170.47,21.87 171.8,21.87 v1(172,22.07) 172.33,22.4 v1(172.33,22.6) 172.4,22.68 CP2.5 ; U45.41 203.11,28.88 v1(202.91,28.67)
MY6: length 56
  TOP w0.114: v1(173.13,22.51) 173.67,23.06 182.76,23.06 190.04,30.35 192.4,30.35 193.19,29.56 201.03,29.56 v3(201.87,28.72) 202.26,28.33 202.59,28.33 v1(202.88,28.04)
  BOTTOM w0.114: CN20.20 157.79,19.78 159.45,21.43 170.42,21.43 170.63,21.64 172.26,21.64 v1(173.13,22.51) 173.22,22.6 CP2.3 ; U45.42 202.71,29.11 202.48,28.88 202.48,28.44 v1(202.88,28.04)
MY7: length 71.6
  TOP w0.114: v1(173.86,22.59) 173.86,17.1 180.17,10.79 190.84,10.79 191.48,11.43 191.48,19.17 191.85,19.54 195.92,19.54 199.3,22.92 199.3,24.12 200.33,25.15 200.94,25.15 v1(201.23,25.45)
  BOTTOM w0.114: CN20.19 158.79,19.51 160.46,21.18 170.54,21.18 170.78,21.41 172.36,21.41 172.78,21.84 173.34,21.84 173.86,22.36 v1(173.86,22.59) 174,22.73 CP2.1 ; v1(201.23,25.45) 201.89,25.45 v3(202.1,25.65) 202.1,28.92 202.31,29.14 U45.43
MY8: length 70.1
  TOP w0.114: v1(175.3,22.63) 175.3,16.05 180.3,11.04 190.72,11.04 191.22,11.55 191.22,19.55 191.44,19.77 195.82,19.77 198.71,22.66 198.71,24.37 199.35,25.01 v1(199.56,25.01)
  BOTTOM w0.114: CN20.18 159.79,18.86 161.89,20.95 170.64,20.95 170.87,21.19 172.45,21.19 172.88,21.61 174.18,21.61 174.61,22.04 174.92,22.04 175.3,22.42 v1(175.3,22.63) CP3.7 ; U45.44 201.91,29.14 201.84,29.06 201.84,26.72 200.7,25.57 v3(200.37,25.57) 200.11,25.57 v1(199.56,25.01)
MY9: length 52
  TOP w0.114: v1(176.09,22.58) 178.66,20 191.16,20 192.09,20.93 194.21,20.93 195.08,21.8 197.01,21.8 198.48,23.26 198.48,24.65 v1(199.48,25.65)
  BOTTOM w0.114: CN20.17 160.79,18.59 162.9,20.7 170.77,20.7 171.03,20.96 172.55,20.96 172.97,21.38 174.45,21.38 174.88,21.81 175.22,21.81 175.47,22.06 175.47,22.06 175.72,22.31 175.72,22.32 175.98,22.58 v1(176.09,22.58) CP3.5 ; v1(199.48,25.65) 200.37,26.54 200.7,26.54 v1(200.97,26.81) 201.51,27.35 U45.45
MY10: length 51.1
  TOP w0.114: v1(176.9,22.55) 179.22,20.23 190.93,20.23 191.86,21.16 194.12,21.16 194.98,22.02 196.92,22.02 198.25,23.36 198.25,25.37 199.05,26.16 199.7,26.16 199.97,26.44 199.97,26.75 v1(200.39,27.17)
  BOTTOM w0.114: v1(200.39,27.17) 200.47,27.25 201,27.25 201.28,27.53 201.28,28.95 201.11,29.12 U45.46 ; CN20.16 161.79,18.7 163.56,20.47 170.92,20.47 171.18,20.73 172.64,20.73 173.07,21.15 174.55,21.15 174.98,21.59 175.6,21.59 v1(175.9,21.88) 176.16,22.14 176.26,22.14 176.67,22.55 v1(176.9,22.55) CP3.3
MY11: length 48.6
  TOP w0.114: v1(197.83,23.53) 197.83,23.32 196.76,22.25 192.53,22.25 190.73,20.46 179.76,20.46 v1(177.69,22.53)
  BOTTOM w0.114: CN20.15 162.79,18.3 164.73,20.24 171.01,20.24 171.23,20.46 172.69,20.46 173.16,20.93 174.64,20.93 175.06,21.35 176.3,21.35 177.48,22.53 v1(177.69,22.53) CP3.1 ; v1(197.83,23.53) 198.97,24.68 198.97,26.21 v3(198.53,26.65) 198.11,27.07 198.11,27.29 198.11,27.29 198.11,28.19 198.75,28.84 198.83,28.84 199.11,29.12 U45.51
MY12: length 46.7
  TOP w0.114: v1(197.62,24.2) 197.4,23.98 197.4,23.21 196.67,22.48 192.43,22.48 190.63,20.68 180.47,20.68 178.6,22.56 v1(178.6,22.58)
  BOTTOM w0.114: U45.52 198.71,29.14 197.88,28.3 197.88,27.39 197.87,27.38 197.87,26.15 198.28,25.74 198.28,24.86 v1(197.62,24.2) ; CP4.7 179.11,23.08 v1(178.6,22.58) 178.5,22.58 177.99,22.07 177.58,22.07 177.46,21.94 v1(177.46,21.89) 177.46,21.84 176.74,21.12 175.16,21.12 174.74,20.7 173.26,20.7 172.79,20.23 171.38,20.23 171.16,20.01 165.77,20.01 163.79,18.03 CN20.14
MY13: length 45.1
  TOP w0.114: v1(197.62,24.84) 197.17,24.39 197.17,23.31 196.57,22.71 192.33,22.71 190.54,20.91 180.85,20.91 v1(180.33,21.43) v1(179.24,22.53)
  BOTTOM w0.114: v1(197.62,24.84) 198.05,25.26 198.05,25.65 197.64,26.05 197.64,28.47 198.31,29.14 U45.53 ; CN20.13 164.79,17.89 166.69,19.78 171.32,19.78 171.53,20 172.88,20 173.34,20.46 174.82,20.46 175.21,20.85 177.08,20.85 177.97,21.74 178.09,21.74 178.5,22.14 178.78,22.14 179.16,22.53 v1(179.24,22.53) 179.9,23.19 CP4.5
MY14: length 43.6
  TOP w0.114: v1(197.62,25.47) 196.95,24.79 196.95,23.4 196.48,22.94 192.24,22.94 190.44,21.14 181.25,21.14 179.95,22.45 v1(179.95,22.5)
  BOTTOM w0.114: U45.54 197.91,29.14 197.42,28.64 197.42,25.68 v1(197.62,25.47) ; CN20.12 165.79,18.13 166.43,18.77 166.94,18.77 167.5,19.33 v1(167.5,19.35) 167.53,19.35 167.73,19.55 171.41,19.55 171.63,19.77 172.98,19.77 173.44,20.23 174.91,20.23 175.31,20.62 177.2,20.62 177.76,21.17 177.96,21.17 178.68,21.89 179.34,21.89 v1(179.95,22.5) 179.95,22.51 180.71,23.27 CP4.3
MY15: length 41.5
  TOP w0.114: v1(180.7,22.56) 181.89,21.37 190.35,21.37 192.22,23.24 193.46,23.24 194.19,23.97 v1(195.45,23.97)
  BOTTOM w0.114: CN20.11 166.79,18.04 167.58,18.82 167.6,18.82 167.85,19.07 167.85,19.09 168.08,19.33 171.56,19.33 171.78,19.54 173.07,19.54 173.53,20 175.01,20 175.4,20.39 177.66,20.39 v1(178.02,20.75) 178.93,21.66 179.44,21.66 179.84,22.07 180.12,22.07 180.62,22.56 v1(180.7,22.56) 180.77,22.56 181.5,23.29 CP4.1 ; v1(195.45,23.97) 196.65,23.97 197.19,24.5 197.19,28.75 197.51,29.07 U45.55
MY16: length 38.6
  TOP w0.114: v1(195.72,24.54) 195.68,24.58 193.24,24.58 190.25,21.6 182.27,21.6 v1(181.36,22.51)
  BOTTOM w0.114: v1(181.36,22.51) 181.35,22.51 180.73,21.89 180.3,21.89 180.25,21.84 180.02,21.84 179.41,21.23 v1(179.26,21.23) 178.19,20.16 175.5,20.16 175.1,19.77 173.63,19.77 173.17,19.31 172.06,19.31 171.84,19.1 169.05,19.1 167.79,17.84 CN20.10 ; v1(195.72,24.54) 195.89,24.37 196.63,24.37 196.96,24.7 196.96,28.84 197.11,29 U45.56
MY17: length 37.2
  TOP w0.114: v1(196.3,24.8) 196.13,24.97 195.29,24.97 195.17,24.86 193.12,24.86 190.09,21.83 182.73,21.83 v1(182.03,22.53)
  BOTTOM w0.114: v1(196.3,24.8) 196.73,25.22 196.73,26.11 196.71,26.13 U45.57 ; CN20.9 168.79,18.21 169.46,18.87 172,18.87 172.21,19.09 173.26,19.09 173.72,19.54 175.2,19.54 175.59,19.93 178.68,19.93 180.4,21.66 181.55,21.66 v1(181.76,21.88) 182.03,22.14 v1(182.03,22.53)
N12E_SCL: length 16.2
  BOTTOM w0.102: 194.16,149.91 194.04,150.03 194.04,151.21 193.11,152.14 192.84,152.14 192.38,152.61 192.25,152.61 191.75,153.1 U34.C9
  BOTTOM w0.114: R522.1 194.73,139.7 194.73,140.51 194.83,140.61 194.83,142.44 195.54,143.15 195.54,148.53 194.16,149.91
N12E_SDA: length 13.3
  BOTTOM w0.114: U34.C8 191.91,151.79 193.17,151.79 193.83,151.13 193.83,149.91 195.31,148.43 195.31,144.38 194.41,143.48 v1(194.41,142.62) R503.1
NBSWON#: length 191.8
  TOP w0.114: v1(173.38,84.14) 173.85,84.61 174.2,84.61 R265.2 ; v1(196.81,51.53) 195.44,51.53 192.49,54.48 192.49,67.2 192.21,67.48 192.21,75.48 191.83,75.87 182.89,75.87 182.05,75.02 175.18,75.02 174.65,75.55 172.42,75.55 171.41,76.56 169.41,76.56 167.7,78.26 v1(167.7,83.99)
  IN1 w0.127: v1(173.38,84.14) 172.92,84.6 171.09,84.6 169.51,86.18 168.57,86.18 167.7,85.31 v1(167.7,83.99) ; v1(195.09,21.17) 195.21,21.04 202.47,21.04 203.63,22.2 203.63,24.1 201.55,26.19 201.55,29.57 203.1,31.12 203.1,32.39 200.18,35.31 200.18,38.71 198.91,39.98 198.91,41.34 199.59,42.03 199.59,45.45 197.83,47.22 v1(197.83,48.26) 197.36,48.73 197.36,49.5 196.63,50.23 196.63,50.59 196.81,50.77 v1(196.81,51.53)
  BOTTOM w0.114: v1(195.09,21.17) 194.91,20.99 194.91,13.97 194.73,13.79 SW2.2 SW2.1 192.8,21.46 192.87,21.52 C785.2 R753.1 190.08,23.36 189.57,23.87 189.57,25.9 188.43,27.05 154.16,27.05 R776.2 C805.1 ; v1(196.81,51.53) 196.92,51.42 R730.1 ; v1(197.83,48.26) 198.08,48 198.08,46.53 197.91,46.36 U45.107
NV_PLLVDD: length 0.6
  BOTTOM w0.254: v1(184.39,150.16) 184.79,150.56 U34.L6
  vias: v3(185.28,147.98)
ODD_EN: length 5.2
  BOTTOM w0.114: R703.1 R704.1 216.37,90.78 216.12,91.03 v1(216.12,91.23) 216.12,92.19 R692.1 Q37.5
ODD_EN_Q: length 6.4
  BOTTOM w0.114: Q37.3 v1(221.17,91.67) 222.06,91.67 R695.2 222.2,92.45 222.21,92.46 Q36.2 221.7,93.21 220.81,92.32 Q37.2
ODD_POWER: length 75.7
  IN1 w0.203: v1(205.5,52.14) 204.53,51.18 204.53,47.34 202.41,45.22 202.41,38.79 v1(203.14,38.07)
  BOTTOM w0.114: R704.2 216.37,87.12 219.37,84.12 v3(219.37,80.31) 219.37,75.64 217.39,73.66 214.46,73.66 213.45,72.64 213.45,71.24 209.26,67.05 v3(209.26,61.29) 209.26,53.59 207.74,52.07 205.57,52.07 v1(205.5,52.14)
  BOTTOM w0.203: U45.71 193.13,33.91 193.25,34.03 194.38,34.03 195.56,35.21 197.44,35.21 197.7,34.96 198.4,34.96 201.54,38.1 203.11,38.1 v1(203.14,38.07)
ODD_PRSNT#: length 99.4
  TOP w0.114: R217.2 C802.1 228.44,104.78 227.93,104.26 222.08,104.26 217.89,100.07 217.89,98.67 214.82,95.6 211.34,95.6 210.78,96.16 203.88,96.16 202.74,95.03 200.89,95.03 199.35,93.49 195.29,93.49 192.08,96.7 192.08,100.38 192.75,101.04 192.75,103.37 189.3,106.82 187.26,106.82 186.24,107.84 183.9,107.84 183.45,108.3 183.45,109.2 183.1,109.55 183.1,111.27 182.99,111.37 182.99,114.14 v1(182.11,115.03)
  IN1 w0.127: v1(174.18,117.42) 173.61,117.99 171.07,117.99 170.7,118.36 164.88,118.36 164.33,118.92 163.56,118.92 163.26,118.61 158.94,118.61 158.71,118.84 158.28,118.84 v1(158.08,119.05)
  BOTTOM w0.076: v1(158.08,119.05) 157.38,119.75 156.71,119.75 156.63,119.71 156.39,119.71 U35.AB2
  BOTTOM w0.114: v1(182.11,115.03) 179.87,115.03 v3(178.24,116.66) 177.48,117.42 v1(174.18,117.42)
ODD_PRSNT#_C: length 6.3
  TOP w0.114: R217.1 227.16,107.18 C330.1 R216.1 v3(229.96,107.94) 231.93,107.94 CN9.8
PCBEEP: length 13.5
  TOP w0.114: U23.12 30.4,37.5 29.17,38.73 29.17,39.95 31.76,42.54 33.49,42.54 34.12,43.18 34.12,44.6 v3(34.58,45.06) 34.84,44.8 34.84,44.49 C476.1
PCBEEP_EC: length 196.5
  TOP w0.114: D10.2 41.16,46.99 42,47.82 v1(42,48.26)
  IN1 w0.127: v1(205.19,28.04) 204.84,27.68 204.84,23.75 205.38,23.2 205.38,20.89 204.91,20.42 194.48,20.42 193.24,21.66 193.24,22.94 189.2,26.98 173.58,26.98 170.09,30.48 170.09,31.23 167.19,34.13 100.67,34.13 87.29,47.52 83.32,47.52 82.5,48.34 82.5,48.8 74.69,56.61 v1(71.79,56.61)
  IN2 w0.127: v1(71.79,56.61) 71.79,56.61 71.16,55.98 70.19,55.98 68.36,57.81 51.55,57.81 v1(42,48.26)
  BOTTOM w0.114: U45.34 205.91,28.76 v1(205.19,28.04)
PCH _JTAG_TDO: length 7.9
  BOTTOM w0.076: U35.A56 124.88,130.97 124.88,132.45 124.55,132.78 124.55,133.88
  BOTTOM w0.114: R539.1 R538.2 124.55,137.03 125.01,136.57 125.01,135.87 124.55,135.41 124.55,133.88
PCH_ACPRESENT: length 17.6
  BOTTOM w0.076: 154.61,103.33 154.61,104.9 154.02,105.49 153.19,105.49 153.02,105.66 151.91,105.66 151.58,105.99 150.92,105.99 150.8,106.1 149.87,106.1 149.58,106.39 148.79,106.39 148,107.18 148,109.16 148.2,109.37 U35.AY15
  BOTTOM w0.114: 154.61,103.33 154.61,102.64 R651.2 155.16,101.32 v1(155.41,101.06) 155.96,100.52 155.96,99.48 156.55,98.89 R676.2
PCH_AZ_CODEC_BITCLK: length 236
  TOP w0.114: U23.6 32.8,38.4 C493.2 32.34,39.33 33.13,40.13 v1(33.22,40.13)
  IN2 w0.127: v1(173.44,80.36) 173.24,80.16 173.24,79.68 174.38,78.53 174.38,42.52 164.12,32.25 96,32.25 95.19,33.07 87.62,33.07 86.19,31.64 72.28,31.64 71.18,32.74 57.47,32.74 49.24,40.97 37.48,40.97 36.75,41.69 34.79,41.69 v1(33.22,40.13)
  BOTTOM w0.114: C739.2 R644.1 146.14,102.86 v3(146.14,100.45) 145.88,100.2 145.88,97.24 157.37,85.75 162.18,85.75 166.14,81.79 170.36,81.79 171.03,81.12 171.24,81.12 172,80.36 v1(173.44,80.36)
PCH_AZ_CODEC_RST#: length 234.4
  TOP w0.114: U23.11 30.8,37.61 29.68,38.73 29.68,39.75 31.97,42.03 33.74,42.03 34.81,43.1 37.56,43.1 38.01,43.55 38.01,44.38 38.32,44.69 39.95,44.69 v1(40.73,43.91) 41.74,44.93 Q29.1
  IN2 w0.127: v1(40.73,43.91) 47.16,43.91 57.72,33.35 71.44,33.35 72.53,32.25 85.53,32.25 86.98,33.7 95.44,33.7 96.28,32.86 163.87,32.86 173.77,42.77 173.77,78.15 172.63,79.29 172.63,82.11 v1(172.52,82.23)
  BOTTOM w0.114: v1(172.52,82.23) 172.36,82.38 171.46,82.38 170.33,83.52 168.24,83.52 168,83.28 166.31,83.28 162.66,86.92 157.86,86.92 149.95,94.83 v3(149.95,98.67) R660.1
PCH_AZ_CODEC_SDIN0: length 230.8
  TOP w0.114: R359.2 v1(39.97,43.94)
  IN2 w0.127: v1(173.39,82.44) 172.94,81.98 172.94,79.55 174.08,78.41 174.08,42.64 164,32.56 96.13,32.56 95.29,33.4 87.13,33.4 85.69,31.95 72.4,31.95 71.31,33.04 57.59,33.04 47.21,43.43 40.47,43.43 v1(39.97,43.94)
  BOTTOM w0.076: U35.BA21 145.26,109.25 145.26,108.23 148.26,105.23 149.04,105.23 149.28,104.99 149.28,103.88
  BOTTOM w0.114: v1(173.39,82.44) 173.16,82.67 171.59,82.67 170.45,83.81 168.12,83.81 167.88,83.57 166.43,83.57 162.79,87.21 157.98,87.21 150.92,94.28 150.92,101.46 149.28,103.1 149.28,103.88
PCH_AZ_CODEC_SDOUT: length 234.4
  TOP w0.114: U23.5 33.2,37.93 33.62,38.35 33.62,39.49 v1(33.87,39.75)
  IN2 w0.127: v1(174.08,81.23) 174.45,81.23 174.7,80.99 174.7,63.78 174.69,63.78 174.69,42.39 164.25,31.95 95.87,31.95 95.42,32.41 88.58,32.41 87.52,31.34 72.15,31.34 71.06,32.43 57.34,32.43 49.16,40.61 37.33,40.61 36.56,41.39 35,41.39 33.87,40.25 v1(33.87,39.75)
  BOTTOM w0.114: R645.1 147.28,102.73 147.28,98.55 v3(146.9,98.17) 146.9,97.05 157.62,86.34 162.42,86.34 166.06,82.69 168.24,82.69 168.49,82.93 170.09,82.93 171.32,81.7 171.48,81.7 172.08,81.11 173.96,81.11 v1(174.08,81.23)
PCH_AZ_CODEC_SYNC: length 233.5
  TOP w0.114: v1(31.08,37.97) 31.2,37.84 U23.10
  IN2 w0.127: v1(31.08,37.97) 33.36,37.97 34.95,39.56 34.95,39.93 34.63,40.25 34.63,40.51 35.2,41.08 36.43,41.08 37.23,40.28 49.03,40.28 56.12,33.19 56.12,31.77 56.98,30.91 87.54,30.91 88.73,32.1 95.29,32.1 95.75,31.64 164.4,31.64 172.68,39.92 172.68,39.95 172.99,40.25 173.01,40.25 175,42.24 175,63.66 175.73,64.38 175.73,64.89 175,65.62 175,81.12 174.08,82.04 v1(174.08,82.09)
  BOTTOM w0.114: v1(174.08,82.09) 174,82.01 173.04,82.01 172.83,81.8 172.28,81.8 172.09,81.99 171.44,81.99 170.21,83.23 168.36,83.23 168.12,82.98 166.19,82.98 162.54,86.63 157.74,86.63 148.69,95.68 v3(148.69,96.59) R667.1
PCH_BATLOW#: length 23.8
  IN1 w0.132: v1(167.73,107.69) 167.3,108.12 166.87,108.12 165.47,106.73 164.86,106.73 163.98,105.84 161.07,105.84 160.78,105.55 158.4,105.55 158.1,105.84 157.13,105.84 155.15,107.82 153.13,107.82 150.11,110.83 150.11,111.03 v2(150.03,111.11)
  BOTTOM w0.114: R628.2 167.86,106.88 TP74.1 167.78,107.64 v1(167.73,107.69)
  BOTTOM w0.127: v2(150.03,111.11) U35.AU13
PCH_BLON: length 115.7
  TOP w0.114: v1(139.66,173.68) 139.66,174.13 139.55,174.24 132.34,174.24 130.21,172.11 119.01,172.11 118.83,171.93 118.04,171.93 117.8,172.16 113.8,172.16 113.77,172.2 R67.1
  IN1 w0.076: 154.11,123.21 154.01,123.11 152.72,123.11 152.55,122.94 151.64,122.94 v5(151.12,122.42)
  IN1 w0.127: v1(139.66,173.68) 139.66,172.84 141.95,170.56 146.14,170.56 150.58,166.11 150.58,164.59 151.73,163.44 151.73,157.86 150.46,156.59 150.46,146.3 152.06,144.7 152.06,140.94 153.66,139.34 157.95,139.34 158.94,138.35 158.94,136.55 163.61,131.89 165.58,131.89 167.2,130.27 167.2,128.82 166.92,128.55 166.92,127.1 167.27,126.74 167.98,126.74 168.47,126.25 168.47,125.68 168.16,125.37 162.62,125.37 161.4,124.15 158.92,124.15 158.19,123.43 154.33,123.43 154.11,123.21
  BOTTOM w0.114: v5(151.12,122.42) 150.9,122.64 150.51,122.64 U35.R12
PCH_BLON_EC: length 238.1
  TOP w0.114: R66.1 112.1,171.78 112.26,171.62 114.23,171.62 114.54,171.93 117.71,171.93 118.04,171.6 v1(120.74,171.6) 121.02,171.88 130.3,171.88 132.28,173.86 138.83,173.86 v1(139.03,173.66)
  IN1 w0.127: v1(204.61,41.07) 204.48,41.07 204.19,41.36 204.19,44.55 206.73,47.09 206.73,48.67 207.29,49.23 207.29,51.15 209.45,53.31 209.45,64.51 208.05,65.91 208.05,66.33 208.05,67.78 201.32,74.52 201.32,78.23 200.11,79.43 200.11,80.85 196.68,84.28 196.68,84.3 195.8,85.19 193.2,85.19 191.74,86.65 191.74,87.33 191.98,87.57 193.76,87.57 194.27,88.08 194.27,89.53 195.54,90.8 195.54,97.25 193.84,98.95 193.84,107.69 193.48,108.05 193.48,108.12 192.98,108.63 192.95,108.63 190.72,110.87 190.69,110.87 188.02,113.53 187.07,113.53 185.15,115.45 185.15,115.49 183.96,116.68 183.96,123.57 183.57,123.96 183.57,124.27 183.2,124.63 183.2,125.07 183.54,125.41 183.54,133.54 176.55,140.53 170.38,140.53 167.73,143.18 167.73,143.19 166.46,144.46 166.46,145.15 165.91,145.7 165.13,145.7 164.59,146.24 164.59,148.6 165.19,149.2 165.19,150.52 165.97,151.3 166.69,151.3 168.74,153.36 v1(168.74,153.79) ; v1(139.03,173.66) 139.03,174.09 140.59,175.65 142.59,175.65 143.29,176.35 155.33,176.35 155.92,175.76 155.92,174.75 v1(156.17,174.49)
  IN2 w0.127: v1(156.17,174.49) 156.68,174.49 158.18,173 160.39,173 160.64,173.25 163.08,173.25 165.7,170.63 165.7,162.81 168.16,160.35 168.16,154.38 v1(168.74,153.79)
  BOTTOM w0.114: v1(204.61,41.07) 204.32,40.78 202.01,40.78 200.69,39.47 194.68,39.47 193.43,40.71 U45.88
PCH_BLON_R: length 6.2
  TOP w0.114: R66.2 111.37,172.98 R65.2 110.72,173.26 110.5,173.48 110.5,174.24 110.68,174.42 111.02,174.42 111.37,174.06 112.06,174.06 112.23,174.23 Q3.5
  TOP w0.127: R67.2 R66.2
PCH_BRIGHT: length 126.3
  TOP w0.114: v1(119.72,159.89) 121.88,157.74 121.88,154.94 123.25,153.57 128.84,153.57 130.52,151.89 130.52,151 129.11,149.6 129.11,142.29 128.1,141.28 v1(128.1,140.84) ; v1(135.34,185.67) 135.31,185.67 v3(133.85,184.2) 133.28,183.64 131.16,183.64 129.37,181.86 129.37,177.92 124.12,172.67 v1(118.22,172.67)
  IN1 w0.127: v1(119.72,159.89) 119.34,159.89 119.01,160.22 119.01,161.7 118.58,162.13 118.58,172.31 v1(118.22,172.67) ; v1(128.1,140.84) 128.34,140.61 136.31,140.61 139.76,137.16 147.26,137.16 147.74,137.64 150.36,137.64 152.11,135.89 154.04,135.89 160.39,129.54 160.39,128.9 160.12,128.63 158.23,128.63 158.11,128.52 155.2,128.52 153.93,127.25 153.63,127.25 153.23,126.85 153.23,125.71 153.05,125.52 152.11,125.52 151.35,124.76 151.35,124.2 150.69,123.54 v2(150.48,123.54)
  BOTTOM w0.114: v2(150.48,123.54) 150.83,123.19 U35.R11 ; CN5.27 133.94,188.59 134.07,188.59 135.14,187.52 135.14,185.87 v1(135.34,185.67) ; R546.1 128.1,137.88 v1(128.1,140.84)
PCH_JTAGX: length 10.2
  BOTTOM w0.076: 123.41,133.98 123.41,131.09 U35.A59
  BOTTOM w0.114: R513.1 121.51,140.07 121.89,139.69 R517.1 122.52,138.69 122.52,136.42 123.41,135.53 123.41,133.98
PCH_MBCLK0_R: length 20.1
  TOP w0.076: v2(153.76,122.55) 154.15,122.94 154.9,122.94 155.52,123.57
  TOP w0.114: v1(167.22,125.85) 167.22,126.23 165.9,127.55 163.44,127.55 163.03,127.15 163.03,126.18 162.78,125.93 162.49,125.93 162.34,125.78 161.02,125.78 v3(160.97,125.83) 160.49,125.83 159.7,125.04 156.52,125.04 155.89,124.41 155.89,123.94 155.52,123.57
  BOTTOM w0.076: U35.R7 153.43,122.88 v2(153.76,122.55)
  BOTTOM w0.114: R578.2 166.86,125.36 166.86,125.49 v1(167.22,125.85) 167.03,125.85 166.59,126.3 Q32.6
PCH_MBDAT0_R: length 16.3
  TOP w0.076: 155.14,123.57 154.69,123.11 153.49,123.11 v2(153.08,123.52)
  TOP w0.114: 155.14,123.57 155.61,124.04 155.61,124.51 156.41,125.31 159.59,125.31 160.65,126.36 161.23,126.36 161.54,126.04 162.23,126.04 162.55,126.36 v1(162.6,126.36)
  BOTTOM w0.114: Q32.3 163.5,127.6 163.28,127.38 163.28,126.77 162.88,126.36 162.6,126.36 v1(162.6,126.36) 163.28,125.68 163.38,125.68 R580.2 ; v2(153.08,123.52) 153.08,123.27 U35.R8
PCH_ODD_EN: length 127.1
  IN1 w0.076: v2(149.87,123.54) 150.55,122.87 150.55,121.37 150.93,120.99 154,120.99 154.28,120.71 154.77,120.71
  IN1 w0.127: 154.77,120.71 156.18,120.71 156.36,120.89 161.61,120.89 163.25,122.53 163.74,122.53 164.74,121.53 165.83,121.53 166.75,120.61 169.11,120.61 169.33,120.82 170.65,120.82 v1(171.11,121.28) ; v1(179.74,131.11) 179.16,131.11 178.19,132.08 172.3,132.08 v1(172.28,132.05)
  BOTTOM w0.114: R703.2 213.18,87.22 209.28,87.22 208.7,87.8 208.7,88.31 210.53,90.14 210.53,92.88 208.78,94.64 201.43,94.64 199.22,96.85 199.22,99.49 197.78,100.94 v3(194.2,100.94) 192.57,100.94 191.2,102.31 186.52,102.31 183.6,105.23 183.6,105.69 185.99,108.07 185.99,108.5 186.5,109.01 186.5,110.18 v1(185.04,111.64) 184.83,111.85 184.83,115.74 183.71,116.85 183.71,122.45 181.95,124.21 181.95,130.3 181.39,130.86 179.99,130.86 v1(179.74,131.11) ; v2(149.87,123.54) 150.18,123.85 U35.N12 ; v1(171.11,121.28) 171.23,121.41 v1(172.28,121.41) 173.94,121.41 175.27,122.73 175.27,129.21 174.38,130.09 174.38,130.68 173.01,132.05 v1(172.28,132.05)
PCH_PWRBTN#: length 17.7
  BOTTOM w0.076: U35.BA15 148.55,108.68 148.55,108.17 148.42,108.04 148.42,107.22 148.93,106.72 149.72,106.72 150,106.43 150.94,106.43 151.06,106.32 151.72,106.32 152.03,106.01 153.13,106.01 153.32,105.82 154.16,105.82 154.67,105.31 154.75,105.31
  BOTTOM w0.114: R677.2 157.57,98.9 156.68,99.78 v1(156.68,100.66) 156.68,101.09 156.18,101.59 156.18,102.67 156.04,102.81 156.04,104.77 155.51,105.31 154.75,105.31
PCH_PWROK: length 141.3
  TOP w0.114: v1(190.08,85.1) 193.09,85.1 194.65,86.66 194.65,87.07 194.35,87.37 193.71,87.37 193.59,87.5 193.59,88.22 R103.2 ; v1(151.9,102.19) 151.94,102.15 153.86,102.15 159.58,96.43 162.26,96.43 163.92,94.76 163.93,94.76 164.55,94.14 164.55,91.86 164.01,91.31 164.01,91.06 163.25,90.3 162.66,90.3 161.23,88.87 161.23,87.53 160.59,86.89 160.59,84.73 160.91,84.41 162.77,84.41 164.93,82.25 164.93,77.35 167.85,74.44 169.68,74.44 170.14,74.89 170.62,74.89 171.2,74.32 171.64,74.32 172.28,73.68 176.39,73.68 176.62,73.45 178.22,73.45 v1(178.52,73.15) 178.65,73.15 179.26,72.54 179.26,71.73 177.08,69.55 177.08,69.03 177.33,68.79 178.16,68.79 180.09,70.72 182.86,70.72 183.34,70.23 183.34,64.97 190.48,57.83 190.48,48.34 190.08,47.94 190.08,43.22 192.41,40.89 194.53,40.89 194.91,40.51 195.29,40.51 195.67,40.13 195.67,39.13 193.43,36.89 v1(193.43,36.79)
  BOTTOM w0.114: U45.78 193.36,36.71 v1(193.43,36.79) ; v1(178.52,73.15) 178.7,72.97 181.65,72.97 182.79,74.11 182.79,83.79 183.65,84.65 v1(189.34,84.65) 189.64,84.65 v1(190.08,85.1) ; v1(151.9,102.19) 151.6,102.48 R648.1 R647.2
PCH_RSMRST#: length 17.4
  BOTTOM w0.076: U35.AY17 146.67,109.22 146.67,108.48 146.29,108.1 146.29,107.9 148.47,105.72 149.31,105.72 150.21,104.82 150.64,104.82 151.15,105.33 151.52,105.33 151.73,105.13 152.85,105.13 153.19,104.78 R642.1
  BOTTOM w0.114: v3(153.4,100.5) 153.32,100.59 R661.2 152.49,100.96 153.1,101.57 153.1,102.51 153.21,102.62 R655.2 153.11,103.14 153.11,104.26 R642.1
PCH_SLP_A#: length 54.8
  TOP w0.114: R273.2 174.03,82.83 v1(173.95,82.74)
  IN1 w0.132: v1(173.95,82.74) 174.48,83.27 174.48,84.81 173.32,85.97 170.4,85.97 170.08,86.29 170.08,88.02 168.29,89.81 168.29,94.15 168.44,94.31 168.44,95.43 167.53,96.34 167.22,96.34 166.86,96.71 166.86,100.6 168.18,101.92 168.18,102.29 167.69,102.77 167.69,104.14 167,104.84 165.6,104.84 164.85,105.58 161.18,105.58 160.89,105.29 158.29,105.29 158,105.58 157.02,105.58 155.05,107.56 152.88,107.56 149.58,110.86 149.58,113.9 149.28,114.2 148.7,114.2 v2(148.21,113.71)
  BOTTOM w0.127: U35.AN16 v2(148.21,113.71)
PCH_SLP_LAN#: length 19
  TOP w0.114: TP30.1 155.54,96.86 151.02,101.38 151.02,103.84 150.67,104.18 150.67,104.98 150.96,105.28 150.96,108.83 150.46,109.34 150.46,109.75 149.33,110.88 149.33,110.91 v2(149.11,111.12)
  BOTTOM w0.076: U35.AW15 148.22,110.44
  BOTTOM w0.114: 148.22,110.44 148.22,110.46 148.88,111.12 v2(149.11,111.12)
PCH_SLP_S5#: length 47.7
  TOP w0.114: R279.2 173.92,80.79 173.5,81.21 173.5,81.46 v1(173.43,81.53)
  IN1 w0.127: v1(169,85.23) 169,84.27 171.61,81.66 173.31,81.66 v1(173.43,81.53)
  BOTTOM w0.076: 154.15,102.88 154.15,104.89 153.88,105.16 153.05,105.16 152.9,105.3 151.8,105.3 151.47,105.63 150.81,105.63 150.67,105.77 149.73,105.77 149.45,106.06 148.65,106.06 147.67,107.04 147.67,108.45 147.34,108.78 147.34,109.42 147.64,109.73 U35.AY16
  BOTTOM w0.114: v1(169,85.23) 168.8,85.42 166.68,85.42 163.4,88.7 162.62,88.7 161.41,89.91 158.99,89.91 158.37,90.53 158.37,92.68 155.9,95.15 155.9,98.89 155.5,99.3 155.5,99.98 154.15,101.33 154.15,102.88
PCH_SLP_SUS#: length 150.6
  TOP w0.114: v1(175.02,33.19) 175.39,33.56 175.39,41.43 174.7,42.11 170.35,42.11 169.76,42.69 169.76,44.8 169.24,45.32 168.15,45.32 167.53,44.7 v1(166.64,44.7) 165.44,44.7 163.28,46.86 162.39,46.86 162.04,47.21 162.04,50.77 v1(161.76,51.05)
  IN2 w0.127: v1(199.71,33.35) 199.17,32.81 199.17,28 199.06,27.89 199.06,27.14 198.08,26.16 197.68,26.16 197.07,25.54 197.07,24.79 195.8,23.52 195.8,23.27 195.44,22.92 193.9,22.92 193.18,23.64 193.18,25.22 191.5,26.89 179.44,26.89 178.17,28.16 178.17,30.04 v1(175.02,33.19) ; v1(161.76,51.05) 163.03,52.32 163.03,62.86 163.84,63.67 163.84,65.94 164.09,66.18 164.09,70.06 161.62,72.52 161.62,79.12 161.49,79.24 161.49,82.99 160.39,84.09 160.39,89.37 159.95,89.81 159.11,89.81 158.41,90.52 158.41,98.11 157.58,98.93 157.58,102.94 157.71,103.07 157.71,104.3 151.65,110.36 150.08,110.36 149.57,110.87 149.57,113.26 v2(149.12,113.71)
  BOTTOM w0.114: v1(199.71,33.35) 200.9,34.54 203.58,34.54 205.84,36.8 206.74,36.8 206.83,36.71 U45.19
  BOTTOM w0.127: v2(149.12,113.71) U35.AN15
PCH_SLP_WLAN#: length 1.3
  TOP w0.114: v1(147.08,107.78) 147.08,107.94 TP23.1
  BOTTOM w0.089: v1(147.08,107.78) 147.07,107.8 U35.BB17
PCH_SPI_CLK: length 36.3
  IN1 w0.127: v1(176.24,102.13) 175.88,102.13 175.32,101.57 174.75,101.57 174.09,102.23 174.09,102.5 170.78,105.81 170.78,106.89 170.58,107.08 170.58,108.54 170.77,108.73 170.77,110.72 170.1,111.39 166.52,111.39 165.71,110.59 164.36,110.59 163.99,110.22 162.59,110.22 162.1,109.74 160.11,109.74 159.78,110.07 158.9,110.07 v1(158.84,110)
  BOTTOM w0.076: v1(158.84,110) 158.45,110.4 157.14,110.4 157,110.54 156.63,110.54 156.43,110.74 155.95,110.74 U35.AV2
  BOTTOM w0.114: v1(176.24,102.13) 176.24,102.1 175.68,101.55 v3(175.68,100.45) 175.68,100 176.36,99.31 R669.1 C745.2 C747.1 R684.2
PCH_SPI_CLK_EC: length 92.7
  IN1 w0.127: v1(175.09,93.98) 174.97,94.1 174.97,94.23 174.44,94.75 174.28,94.75 174.06,94.53 174.06,94.25 174.71,93.59 174.71,88.96 178.03,85.65 178.03,84.12 178.33,83.81 178.33,83.5 178.66,83.18 179.94,83.18 182.44,80.68 182.44,78.75 182.8,78.39 183.01,78.39 183.16,78.24 183.16,78.03 182.08,76.95 182.08,76.74 182.23,76.59 182.44,76.59 183.52,77.67 183.73,77.67 183.88,77.52 183.88,77.31 182.71,76.14 182.71,75.93 182.86,75.78 183.07,75.78 184.24,76.95 184.45,76.95 184.6,76.81 184.6,76.59 183.43,75.43 183.43,75.21 184.38,74.26 184.59,74.26 184.74,74.41 184.74,74.62 184.14,75.22 184.14,75.42 184.96,76.24 185.17,76.24 185.54,75.87 190.01,75.87 192.2,73.67 192.2,68.02 192.42,67.81 192.42,66.07 192.27,65.93 191.75,65.93 191.6,65.78 191.6,65.57 191.75,65.42 192.27,65.42 192.42,65.27 192.42,65.06 192.27,64.91 191.75,64.91 191.6,64.76 191.6,64.55 191.75,64.4 192.27,64.4 192.42,64.25 192.42,63.49 191.91,62.98 191.7,62.98 191.38,63.3 191.17,63.3 191.02,63.15 191.02,62.94 191.34,62.62 191.34,62.41 191.19,62.26 190.98,62.26 189.95,63.29 189.73,63.29 189.59,63.14 189.59,62.93 190.62,61.9 190.62,61.69 190.33,61.41 190.33,52.57 190.69,52.21 190.91,52.21 191.01,52.32 191.22,52.32 191.37,52.17 191.37,51.96 191.15,51.74 191.15,51.53 191.3,51.39 191.51,51.39 191.73,51.6 191.94,51.6 192.09,51.45 192.09,51.24 191.98,51.14 191.98,50.76 v1(192.86,49.88)
  BOTTOM w0.114: v1(175.09,93.98) 175.09,94 175.32,94.23 175.98,94.23 176.24,93.98 R689.1 176.99,94.21 R687.1 ; v1(192.86,49.88) 192.93,49.88 193.81,50.77 196.15,50.77 196.61,50.31 196.61,48.64 196.81,48.44 196.81,47.75 197.11,47.45 U45.105
PCH_SPI_CLK_R: length 13.2
  BOTTOM w0.114: U39.6 174.84,103.37 175.02,103.2 176.67,103.2 176.87,102.99 176.87,100.86 176.62,100.61 176.62,100 176.8,99.82 177.26,99.82 R669.2 178.22,98.86 178.22,94.43 177.77,93.98 R689.2
PCH_SPI_CS0#: length 32.1
  IN1 w0.127: v1(158.11,111.32) 158.56,110.87 159.12,110.87 159.56,111.31 161.28,111.31 161.59,111.01 163.66,111.01 164.03,111.37 165.39,111.37 166.19,112.18 167.43,112.18 168.14,112.89 169.27,112.89 169.71,112.44 v1(169.71,112.39)
  BOTTOM w0.076: v1(158.11,111.32) 157.69,110.89 157.31,110.89 157.12,111.08 156.13,111.08 155.69,111.52 U35.AU3
  BOTTOM w0.114: U41.1 169.76,101.34 169.09,102.02 169.09,103.59 169.18,103.69 169.18,104.28 171.16,106.25 171.16,107.82 171.64,108.3 171.64,111.04 v3(170.65,112.04) 170.32,112.37 170.32,112.71 R602.2 169.76,112.44 v1(169.71,112.39)
PCH_SPI_CS1#: length 33.3
  IN1 w0.127: v1(172.3,105.64) 171.72,106.22 171.72,107.2 171.47,107.45 171.47,108.16 171.66,108.35 171.66,109.1 171.66,111.23 170.62,112.26 170.62,112.73 170.09,113.27 167.99,113.27 167.49,112.77 166.05,112.77 165.56,112.28 164.91,112.28 164.46,111.83 163.95,111.83 163.5,111.39 161.75,111.39 161.44,111.69 159.16,111.69 158.78,112.07 158.2,112.07 157.48,111.34 v5(157.48,111.32)
  BOTTOM w0.076: v5(157.48,111.32) 157.41,111.25 156.43,111.25 U35.AU2
  BOTTOM w0.114: R603.2 171.28,112.76 172.05,112.76 172.3,112.51 U39.1 172.3,108.45 172.73,108.03 172.73,105.99 172.6,105.87 172.52,105.87 v1(172.3,105.64)
PCH_SPI_IO2: length 24.8
  IN1 w0.127: 157.03,110.26 157.03,109.95 157.26,109.72 v1(157.26,109.72) ; 172.02,113.7 172.57,114.25 173.98,114.25 v1(174,114.27)
  IN1 w0.132: 157.03,110.26 157.03,111.53 157.83,112.32 164.49,112.32 164.71,112.54 165.42,112.54 165.9,113.03 167.38,113.03 168.06,113.7 172.02,113.7
  BOTTOM w0.089: U35.AW2 156.2,110.27 156.72,109.75 157.23,109.75 v1(157.26,109.72)
  BOTTOM w0.114: v1(174,114.27) 174.03,114.3 174.16,114.3 174.51,114.65 174.51,115.13 175.04,115.67 R589.1 175.21,115.11 174.94,114.84 R596.1
PCH_SPI_IO3: length 35.9
  TOP w0.114: R238.1 174.83,98.41 v1(174.33,97.91) 174.21,98.04 R239.1 173.72,98.06 v3(173.72,98.98)
  IN1 w0.132: v2(154.72,111.02) 155.28,110.46 155.28,109.34 156.93,107.69 159.96,107.69 160.58,108.32 164.18,108.32 164.25,108.25 165.37,108.25 165.82,108.71 165.82,109.42 166.43,110.03 167.53,110.03 168.06,110.56 168.92,110.56 169.2,110.28 169.2,109.6 169.81,108.98 169.81,106.77 169.99,106.59 169.99,105.52 171.22,104.29 171.22,103.57 172.68,102.1 173.06,102.1 174.33,100.83 v1(174.33,97.91)
  BOTTOM w0.076: U35.AU4 154.86,111.15 v2(154.72,111.02)

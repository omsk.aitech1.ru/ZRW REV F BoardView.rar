# Allegro board Quanta ZRW REV F - BoardView (.BRD).brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
FBA_CMD29: length 133.2
  TOP w0.114: U5.M2 218.21,169.42 218.32,169.31 218.32,169.11 218.21,168.99 217.65,168.99 217.54,169.11 217.54,169.55 217.74,169.75 217.74,169.91 217.6,170.04 217.44,170.04 217.29,169.88 216.64,169.88 v1(216.26,170.26) ; U2.M2 177.14,183.98 177.03,183.87 176.79,183.87 176.68,183.98 176.68,184.44 176.36,184.76 176.11,184.76 175.59,185.28 175.26,185.28 175.2,185.21 174.69,185.21 174.56,185.34 v1(174.56,185.61) ; U3.M2 189.33,184.3 189.47,184.16 189.58,184.06 189.58,183.89 189.46,183.77 189.29,183.77 189.22,183.83 188.87,183.83 188.55,184.16 188.55,184.44 188.35,184.63 188.2,184.63 187.87,184.96 187.62,184.96 187.23,185.34 v1(187.23,185.45) ; U4.M2 205.63,169.86 205.15,169.86 204.65,170.36 203.8,170.36 203.44,170.01 202.98,170.01 v1(202.6,170.39)
  TOP w0.127: R48.1 194.14,180.21 194.65,179.7 195.68,179.7 R49.2 196.19,180.84 v1(196.1,180.92)
  IN1 w0.127: v1(210.53,172.12) 210.53,172.16 210.01,172.68 208.76,172.68 208.44,173 207.21,173 206.97,172.77 205.49,172.77 205.03,173.22 204.37,173.22 203.79,173.8 202.7,173.8 202.29,173.4 201.75,173.4 200.62,174.53 200.62,175.19 198.39,177.43 198.39,178.82 196.29,180.92 v1(196.1,180.92) 194.71,182.31 194.71,182.32 194.46,182.56 194.46,183.34 190.87,186.93 185.28,186.93 183.62,186.73 183.62,186.73 182.99,186.1 182.04,186.1 181.6,186.54 180.77,186.54 180.71,186.61 180.24,186.61 v1(179.87,186.24) 179.81,186.18 178.19,186.18 177.41,185.39 177.17,185.39 177.05,185.5 177.05,185.81 176.94,185.92 176.73,185.92 176.62,185.81 176.62,184.95 176.5,184.83 176.2,184.83 176.09,184.95 176.09,185.81 175.97,185.92 175.73,185.92 175.6,185.8 175.6,185.42 175.48,185.29 175.16,185.29 175.04,185.4 175.04,185.81 174.93,185.92 174.68,185.92 174.56,185.81 v1(174.56,185.61)
  IN2 w0.127: v1(202.6,170.39) 202.99,170 203.43,170 203.69,170.26 203.69,170.42 203.88,170.61 204.7,170.61 204.98,170.9 205.51,170.9 206.25,171.63 206.82,171.63 207.08,171.38 209.27,171.38 209.37,171.48 209.69,171.48 v1(210.53,172.12) 210.78,171.86 211.81,171.86 212.75,170.92 213.19,170.92 214.24,169.87 215.28,169.87 215.29,169.89 215.83,169.89 215.98,169.74 217.22,169.74 217.33,169.85 217.33,170.14 217.22,170.26 v1(216.26,170.26) ; v1(179.87,186.24) 180.15,186.24 181.06,185.32 181.58,185.32 181.91,185.66 183.22,185.66 183.54,185.34 183.78,185.34 183.97,185.15 184.1,185.15 184.21,185.26 184.21,185.33 184.33,185.44 184.51,185.44 184.62,185.33 184.62,185.13 184.83,184.92 185.93,184.92 186.24,184.6 186.5,184.6 186.61,184.72 186.61,185.04 187.02,185.45 v1(187.23,185.45)
  BOTTOM w0.114: v1(202.6,170.39) 202.72,170.39 202.91,170.2 202.91,170.03 202.81,169.94 202.45,169.94 202.29,169.78 201.99,169.78 201.72,170.05 201.58,170.05 201.44,169.91 201.44,169.77 201.73,169.48 201.73,169.09 201.61,168.97 201.4,168.97 201.29,169.08 201.29,169.4 U31.M2 ; U28.M2 172.34,184.24 172.15,184.04 172.01,184.04 171.89,184.16 171.89,184.43 172.22,184.76 173.27,184.76 173.67,185.15 173.67,185.23 174.05,185.61 v1(174.56,185.61) ; v1(216.26,170.26) 216.26,169.9 216.13,169.77 215.97,169.77 215.73,170.01 215.3,170.01 215.06,169.76 214.76,169.76 214.08,169.08 213.48,169.08 U32.M2 ; U29.M2 184.09,184.3 183.93,184.45 183.93,184.63 184.05,184.74 186.26,184.74 186.96,185.45 v1(187.23,185.45)
  BOTTOM w0.127: U34.K25 185.25,166.72 185.25,167.48 185.07,167.67 185.07,168.19 185.36,168.47 185.36,169.46 188.91,173.02 190.2,173.02 195.19,178.01 195.19,180.01 v1(196.1,180.92)
FBA_CMD30: length 110.9
  TOP w0.114: U3.M3 187.97,184.06 187.76,184.06 187.64,184.17 187.64,184.5 v1(187.67,184.53) ; v1(204.59,169.83) 204.59,169.66 204.69,169.57 204.91,169.57 204.97,169.63 205.06,169.63 U4.M3 ; U5.M3 217.14,169.51 216.99,169.67 216.63,169.67 216.52,169.56 v1(216.52,169.3) ; U2.M3 175.98,184.3 v1(175.48,184.81)
  TOP w0.127: v1(197.61,178.34) 197.61,180.69 199.39,182.47 199.39,183.15 200.26,184.02 R35.2 200.61,183.69 200.79,183.51 202.26,183.51 R36.1
  IN1 w0.127: v1(181.25,185.77) 181.72,185.44 183.93,185.44 185.45,186.27 187.66,186.27 188.18,185.76 188.18,185.36 188.46,185.08 189.82,185.08 189.89,185.15 191.02,185.15 191.56,184.61 193.8,182.29 194.06,182.04 194.34,181.45 194.34,180.66 194.6,180.4 195.8,179.64 196.64,179.05 v1(197.61,178.34) 197.42,178.15 197.42,177.44 199.96,174.9 199.96,174.25 201.65,172.56 204.76,172.56 205.45,171.87 205.45,171.71 205.76,171.4 209.14,171.4 209.47,171.72 210.11,171.72 210.33,171.5 210.58,171.5 211.4,172.32 211.58,172.32 211.77,172.13 211.77,171.95 211.33,171.51 210.87,171.05 v1(210.87,170.84)
  IN2 w0.127: v1(204.59,169.83) 204.85,169.83 205.26,170.24 205.57,170.24 205.67,170.13 205.94,170.13 206.06,170.25 206.06,170.37 206.2,170.52 206.34,170.52 206.42,170.43 206.42,170.35 206.51,170.26 206.66,170.26 206.84,170.45 206.84,170.57 207,170.72 208.45,170.72 208.77,170.4 208.93,170.4 209.03,170.5 209.03,170.57 209.14,170.68 209.34,170.68 209.62,170.4 209.92,170.4 210.1,170.58 210.27,170.58 210.35,170.66 210.35,170.91 210.46,171.02 210.69,171.02 v1(210.87,170.84) 211.08,170.84 211.34,170.59 211.9,170.59 212.25,170.24 212.94,170.24 213.97,169.21 214.85,169.21 215.24,168.82 215.68,168.82 216.1,168.41 216.79,168.41 216.95,168.57 216.95,168.98 216.64,169.3 v1(216.52,169.3) ; v1(175.48,184.81) 175.48,185.63 175.59,185.75 177.93,185.75 178.04,185.86 178.04,186.34 178.16,186.46 178.49,186.46 178.6,186.34 178.6,186.22 178.71,186.1 178.95,186.1 179.06,186.22 179.06,186.36 179.39,186.69 180.17,186.69 181.07,185.78 181.23,185.78 v1(181.25,185.77) 181.77,185.99 183.38,185.99 183.69,185.77 184.65,185.77 185.17,185.25 186.04,185.25 186.49,185.38 186.97,185.86 187.41,185.86 187.67,185.6 v1(187.67,184.53)
  BOTTOM w0.127: v1(197.61,178.34) 197.61,178.34 197.61,179.88 197.51,179.98 197.25,179.98 197.12,179.84 197.12,178.15 197.57,177.69 198.01,177.69 198.11,177.59 198.11,177.14 198.01,177.04 197.47,177.04 196.96,177.54 196.78,177.54 196.6,177.36 196.6,177.18 196.73,177.06 196.73,176.88 196.55,176.7 196.37,176.7 196.2,176.87 196.02,176.87 195.87,176.73 195.87,176.48 196.01,176.34 196.01,176.13 195.26,175.38 194.43,175.38 190.75,171.7 189.65,171.7 187.34,169.39 187.01,169.39 186.45,168.84 U34.J27
FBA_ZQ0: length 15
  BOTTOM w0.102: 219.53,168.13 219.53,168.3 218.88,168.95 218.28,168.95 217.95,168.62 U32.L8
  BOTTOM w0.114: 219.53,168.13 221.07,166.59 221.07,157.36 v3(220.93,157.22) 220.69,156.98 R487.1
FBA_ZQ1: length 13.5
  BOTTOM w0.102: U31.L8 206.4,168.62 206.79,168.23 206.93,168.23 207.73,167.42
  BOTTOM w0.114: R486.1 207.99,157.41 209.05,158.47 209.05,165.43 208.5,165.98 208.5,166.66 207.73,167.42
FBA_ZQ2: length 14.3
  TOP w0.102: U5.L8 213.04,168.52 212.79,168.52 212.41,168.15 212.06,168.15 211.73,167.83 211.73,166.96 211.48,166.71
  TOP w0.114: R78.1 209.73,156.92 209.73,163.41 210.53,164.21 210.53,165.35 211.42,166.24 211.42,166.65 211.48,166.71
FBA_ZQ3: length 4.8
  TOP w0.102: U4.L8 200.97,168.62 200.61,168.25 200.19,168.25
  TOP w0.114: R70.1 198.2,168.25 200.19,168.25
FBA_ZQ4: length 5.3
  BOTTOM w0.102: U29.L8 189.31,183.5 189.67,183.87 190.44,183.87
  BOTTOM w0.114: 190.44,183.87 192.57,183.87 192.89,184.19 v1(193.13,184.19) R464.1
FBA_ZQ5: length 13.2
  BOTTOM w0.102: U28.L8 177.47,183.5 177.84,183.13 177.97,183.13 178.88,182.23 178.88,182.22
  BOTTOM w0.114: R471.1 178.28,172.98 179.78,174.48 179.78,181.07 179.17,181.68 179.17,181.92 178.88,182.22
FBA_ZQ6: length 13.5
  TOP w0.102: 182.38,182.47 183.08,183.17 183.56,183.17 183.89,183.5 U3.L8
  TOP w0.114: 182.38,182.47 181.38,181.46 181.38,174.75 182.84,173.29 R69.1
FBA_ZQ7: length 4.9
  TOP w0.114: R44.1 168.47,182.24 170.2,182.24 171.13,183.16 171.15,183.16 171.69,183.16 171.7,183.16 172,183.16 172.08,183.24 172.09,183.24 U2.L8
FBVDDQ_EN: length 103.4
  TOP w0.114: R126.2 172.99,136.26 U9.4 172.1,134.92 v1(172.05,134.87) 172.05,135.25 171.45,135.85 R137.1 ; PR73.1 218.02,117.47 217,116.45 v3(217,113.89) 217,109.47 216.24,108.71 210.4,108.71 208.19,106.5 208.19,103.47 208.41,103.25 208.41,98.08 206.72,96.39 203.79,96.39 202.65,95.26 200.78,95.26 199.27,93.75 195.38,93.75 192.31,96.82 192.31,100.18 193,100.86 193,103.47 189.41,107.05 187.36,107.05 186.37,108.03 186.37,109.95 184.49,111.84 184.49,115.07 183.09,116.46 183.09,122.83 181.4,124.52 181.4,128.49 181.12,128.77 180.49,128.77 179.44,129.83 179.44,130.76 179.11,131.09 179.11,132.21 179.57,132.67 179.57,134.06 v1(179.24,134.39)
  IN1 w0.127: v1(172.05,134.87) 172.29,134.63 178.49,134.63 178.63,134.49 179.13,134.49 v1(179.24,134.39)
FCCM_A: length 6.7
  TOP w0.203: v1(145.63,175.13) 145.5,175.26 PR42.1
  BOTTOM w0.203: v1(145.63,175.13) 145.38,174.87 v3(145.38,172.59) 145.38,171.06 145.12,170.81 PR238.2
FCCM_B: length 35.1
  TOP w0.203: v1(128.61,172.84) 129.12,173.35 130.24,173.35 130.59,173.71 130.59,181.56 131.73,182.69 134.27,182.69 136.99,185.42 141.81,185.42 PR26.2
  IN1 w0.203: v1(128.61,172.84) 129.25,172.84 131.08,171.01 133.62,171.01 v1(134.2,170.43)
  BOTTOM w0.203: PR229.2 125.06,171.06 126.39,172.4 127.23,172.4 v3(127.6,172.77) 127.67,172.84 v1(128.61,172.84) ; v1(134.2,170.43) PR234.2
FCCM_C: length 7.6
  TOP w0.203: PR46.1 154.65,176.02 v1(155.16,175.51)
  BOTTOM w0.203: PR240.2 155.49,169.85 155.49,171.75 v1(155.92,172.18) 155.49,172.61 155.49,173.17 155.66,173.35 155.66,175.13 155.28,175.51 v1(155.16,175.51)
G_MBCLK_R: length 6.4
  TOP w0.127: R333.1 R329.2 198.22,55.99 197.93,56.28 197.93,56.86 C431.1
  TOP w0.254: U19.4 199.19,56.8 198.84,57.15 C431.1
G_MBDATA_R: length 5.9
  TOP w0.127: R334.1 200.88,52.57 R336.2 C454.1
  TOP w0.254: C454.1 202.56,53 U19.6
GC6_FB_EN: length 65.3
  TOP w0.114: v1(153.13,115.18) 153.13,115.63 v1(153.38,115.87) 153.48,115.97 155.39,115.97 155.77,115.59 155.77,114.89 157.31,113.34 159.7,113.34 159.96,113.08 162.09,113.08 162.64,113.63 R199.2 164.59,114.56 165.36,114.56 165.77,114.14 165.77,114.05 166.48,113.34 170.07,113.34 170.9,114.17 171.26,114.17 171.51,114.42 R204.1 172.04,114.05 173.24,112.85 174.54,112.85 174.85,113.16 174.85,113.63 174.43,114.05 174.43,115.65 175.43,116.65 175.43,117.5 174.21,118.72 174.21,121.97 175.08,122.84 175.08,125.12 v1(174.84,125.36) ; v1(169.76,134.49) 169.79,134.49 170.21,134.91 170.21,136.21 170.4,136.4 171.45,136.4 172.59,137.54 173.57,137.54 174.55,136.56 R128.2 175.04,135.78 176.09,135.78 176.49,135.38 R139.1
  IN2 w0.127: v1(174.84,125.36) 174.7,125.5 174.7,127.47 174.28,127.88 173.29,127.88 172.55,128.62 172.55,130.55 171.79,131.31 171.79,132.25 172.35,132.81 172.35,133.17 171.92,133.6 170.78,133.6 169.89,134.49 v1(169.76,134.49)
  BOTTOM w0.076: v1(153.13,115.18) 153.08,115.18 152.87,114.97 152.87,114.4 U35.AN7
GPIO0: length 2.2
  TOP w0.114: TP41.1 59.07,19.15 58.36,19.86 58.36,20.14 58.5,20.28 U26.17
GPIO12_ACIN: length 15.9
  TOP w0.114: v1(194.65,144.67) 194.36,144.38 R94.1 193.95,144.19 v1(193.48,144.19) 193.24,144.19 192.89,144.55 Q9.1 193.67,145.19 193.87,145.39 193.87,146.25 193.15,146.96 193.15,149.98 192.12,151.02 v1(191.04,151.02) ; R758.2 196.56,144.85 v1(196.99,144.42)
  IN2 w0.127: v1(194.65,144.67) 196.2,144.67 196.46,144.42 v1(196.99,144.42)
  BOTTOM w0.114: U34.D7 v1(191.04,151.02)
GPU_EVENT#: length 38.2
  TOP w0.114: v1(174.43,139.59) 173.98,139.59 172.94,138.55 172.94,139.52 172.68,139.78 171.34,139.78 171.05,140.07 169.71,140.07 R107.1
  BOTTOM w0.114: U34.A4 193.07,148.92 194.08,147.91 194.08,145.68 193.26,144.85 193.26,143.42 192.09,142.25 192.09,140.05 191.89,139.86 R516.1 191.45,139.37 191.45,138.89 191.14,138.58 190.72,138.58 189.74,137.59 180.65,137.59 178.1,140.15 v1(174.84,140.15) 174.66,140.15 174.43,139.92 v1(174.43,139.59)
GPU_GPIO16: length 10
  BOTTOM w0.114: TP58.1 190.97,143.54 193.4,145.97 193.4,147.47 193.17,147.7 192.95,147.7 192.67,147.98 192.67,148.2 192.31,148.56 192.09,148.56 191.86,148.79 191.86,149.01 191.52,149.35 191.2,149.35 190.77,149.77 U34.D5
GPU_PEX_RST_HOLD#: length 16.5
  TOP w0.114: v1(191.3,140.86) 194.02,140.86 v1(194.74,140.14) 194.67,140.06 U7.1
  BOTTOM w0.114: U34.C4 191.43,148.76 191.83,148.36 191.83,148.01 192.1,147.75 192.32,147.75 192.6,147.47 192.6,146.38 192.52,146.3 192.52,145.79 190.33,143.61 190.33,142.35 189.84,141.85 R501.1 190.52,141.65 v1(191.3,140.86)
GPU_PWR_GD: length 85.1
  TOP w0.114: U9.1 174.28,133.62 173.53,134.36 171.67,134.36 171.41,134.62 v1(171.41,135) 170.67,135.74 R137.2 ; v1(178.78,134.97) 179.29,134.97 v3(180.15,134.11) 180.66,133.6 180.66,131.42 179.67,130.42 179.67,129.92 180.59,129 181.21,129 181.63,128.59 181.63,124.61 183.32,122.92 183.32,116.56 184.72,115.16 184.72,111.97 186.6,110.08 186.6,108.13 187.45,107.28 189.51,107.28 193.22,103.56 193.22,100.77 192.54,100.08 192.54,96.91 195.45,94 199.2,94 200.68,95.48 202.55,95.48 203.69,96.62 206.61,96.62 208.16,98.17 208.16,103.18 207.86,103.48 PR110.2
  IN1 w0.127: v1(178.78,134.97) 178.69,134.88 172.66,134.88 172.22,135.33 171.74,135.33 v1(171.41,135)
GPU_THROTTING#: length 3.6
  TOP w0.114: PQ40.3 198.46,145.28 198.33,145.15 197.94,145.15 v1(197.4,145.69) 197.16,145.93 R758.1
GPUT_CLK_L: length 18.1
  TOP w0.114: v1(199.73,142.49) R100.2 200.24,141.74 200.41,141.91 Q13.1
  IN2 w0.127: v1(199.73,142.49) 199.37,142.49 197.92,143.94 197.92,144.57 196.84,145.65 196.84,147.54 191.55,152.83 191.55,152.98 v1(191.03,153.5)
  BOTTOM w0.114: U34.D9 v1(191.03,153.5)
GPUT_DATA_L: length 25.7
  TOP w0.114: v1(206.72,141.09) 206.46,141.09 206.2,140.83 R101.2 205.01,140.83 204.78,140.61 Q13.4
  IN2 w0.127: v1(191.06,151.87) 191.64,151.87 191.79,152.02 191.97,152.02 196.56,147.43 196.56,145.54 197.64,144.46 197.64,143.82 199.69,141.77 206.24,141.77 206.72,141.29 v1(206.72,141.09)
  BOTTOM w0.102: 190.64,152.26 190.66,152.26 v1(191.06,151.87)
  BOTTOM w0.114: U34.D8 190.64,152.26
GPX: length 3
  BOTTOM w0.114: R727.2 214.24,57.67 v1(214.24,57.02) 214.76,56.5 U44.6
GSPI0_MOSI: length 14.5
  BOTTOM w0.076: 160.36,111.65 160.13,111.88 154.65,111.88 154.52,111.76 154.04,111.76 153.73,112.06 153.73,112.29 153.29,112.73 U35.AR7
  BOTTOM w0.114: 160.36,111.65 160.44,111.58 160.44,110.28 160.74,109.98 161.2,109.98 161.37,110.15 164.95,110.15 R619.2
GSPI1_MOSI: length 13.4
  TOP w0.114: v2(154.67,113.53) v1(155.38,113.53) 155.51,113.53 156.62,112.43 159.24,112.43 159.69,111.98 161.73,111.98 162.59,111.12 164.35,111.12 164.55,111.32 165.65,111.32 165.82,111.49 R207.2
  BOTTOM w0.076: U35.AN5 154.17,114.03 v2(154.67,113.53)
H_CPU_SVIDART#: length 13.3
  BOTTOM w0.076: 118.28,133.78 119.14,133.78 120.64,132.28 120.64,131.75 120.79,131.59 120.79,130.73 121.07,130.45 U35.B63
  BOTTOM w0.114: R552.1 113.75,135.2 115.16,133.79 118.26,133.79 118.28,133.78
H_CPU_SVIDCLK: length 137.8
  TOP w0.114: PR35.1 156.17,182.11 v1(156.3,182.24) 156.8,182.74 PR341.2
  BOTTOM w0.114: U35.A63 121.07,131.62 120.82,131.87 120.82,132.37 119.19,134.01 118.66,134.01 118.31,134.36 115.46,134.36 114.34,135.47 114.34,139.4 116.67,141.72 116.67,145.15 116.01,145.81 116.01,173.28 116.19,173.46 116.44,173.46 116.62,173.28 116.62,170.47 116.82,170.28 117.09,170.28 117.28,170.47 117.28,173.43 116.01,174.7 116.01,179.17 114.6,180.58 114.6,184.76 120.92,191.07 121.65,191.07 124.71,194.14 127.69,194.14 135.01,201.47 143.75,201.47 144.21,201.93 145.88,201.93 146.6,201.21 147.97,201.21 148.83,200.35 148.83,197.46 151.09,195.19 151.09,193.29 156.71,187.68 156.71,187.43 156.53,187.26 156.29,187.26 155.26,188.28 155,188.28 154.81,188.1 154.81,187.84 156.71,185.94 156.71,184.82 157.42,184.1 157.42,183.36 v1(156.3,182.24)
H_CPU_SVIDDAT: length 138
  TOP w0.114: PR40.2 156.1,180.72 v1(156.3,180.51) 156.8,181.01 PR340.2
  BOTTOM w0.076: U35.D64 120.74,129.55 120.74,129.74 120.87,129.87 120.87,130.04 120.59,130.32 120.59,131.56 120.41,131.74 120.41,132.25 119.67,132.99 118.61,132.99
  BOTTOM w0.114: v1(156.3,180.51) 156.31,180.5 156.97,180.5 158.56,182.09 158.56,184.58 157.85,185.29 157.85,188.15 152.23,193.76 152.23,195.67 150.42,197.48 149.97,197.93 149.97,200.82 148.44,202.36 147.19,202.36 146.47,203.07 143.57,203.07 143.12,202.61 134.38,202.61 127.22,195.45 124.41,195.45 121.17,192.22 120.45,192.22 113.46,185.23 113.46,180.1 114.87,178.7 114.87,145.33 115.53,144.67 115.53,142.86 113.25,140.58 112.48,140.58 111.47,139.57 R138.2 111.85,139.07 112.1,138.82 112.1,136.01 114.9,133.22 118.2,133.22 118.43,132.99 118.61,132.99
H_PECI: length 184.5
  TOP w0.114: v1(128.51,122.91) 128.33,123.08 128.33,125.6 128.61,125.88 128.61,126.79 v1(128.99,127.17) ; v1(158.1,88.54) 157.7,88.54 157.52,88.72 150.76,88.72 148.96,86.91 148.96,80.89 152.29,77.57 152.29,69.92 153.25,68.96 155.92,68.96 156.5,68.38 156.5,55.8 158.46,53.84 158.46,48.1 165.62,40.94 v1(174.33,40.94)
  IN2 w0.127: v1(126.71,131.92) 127.06,131.92 129.48,129.51 129.48,127.66 v1(128.99,127.17) ; v1(189.88,49.6) 188.51,49.6 187.92,49.02 187.92,46.6 184.34,43.02 177.86,43.02 175.78,40.94 v1(174.33,40.94) ; v1(128.51,122.91) 128.66,122.75 141.36,122.75 141.87,122.25 141.87,117.95 142.79,117.04 142.79,116.25 143.57,115.46 145.43,115.46 145.5,115.39 146.09,115.39 146.13,115.43 147.42,115.43 147.76,115.08 147.76,110.96 148.02,110.7 149.1,110.7 149.75,110.05 151.12,110.05 157.12,104.05 157.12,103.31 157,103.18 157,98.69 157.82,97.86 157.82,90.28 158.43,89.67 158.43,88.87 v1(158.1,88.54)
  BOTTOM w0.076: U35.A54 126.03,131.17 125.7,131.5 125.7,132.34 125.95,132.58 126.2,132.58 126.71,132.08 v1(126.71,131.92)
  BOTTOM w0.114: v1(189.88,49.6) 190.44,50.16 190.44,50.19 192.98,52.73 195.82,52.73 v3(196.2,53.11) 196.23,53.13 202.75,53.13 203.24,52.64 203.24,51.76 202.5,51.02 202.5,50.9 201.79,50.19 R738.2
H_PROCHOT#: length 620.2
  TOP w0.114: PR32.2 156.05,183.64 v1(156.81,183.64) ; Q30.3 207.18,32.25 207.53,32.61 209.74,32.61 210.55,33.42 211.52,33.42 211.9,33.04 211.9,32.2 v1(211.7,32)
  IN2 w0.127: v1(156.81,183.64) 157.87,184.7 157.87,189.78 161.51,193.42 163.77,193.42 164.81,194.46 164.81,199.26 166.92,201.37 191.69,201.37 191.79,201.47 194.81,201.47 194.93,201.6 198.82,201.6 200.48,199.93 207.7,199.93 208.37,199.26 208.37,196.39 v1(208.62,196.14) 208.75,196.01 208.75,194.18 208.88,194.05 208.88,191.89 211.04,189.73 211.04,187.45 216.37,182.11 218.2,182.11 220.87,179.45 220.87,167 222.38,165.49 222.38,154.72 214.5,146.84 210.03,146.84 207.4,144.22 207.4,140.61 207.93,140.08 207.93,134.21 206.66,132.94 206.66,128.19 209.28,125.57 209.28,121.4 210.15,120.54 210.15,116.62 212.45,114.32 212.45,108.64 215.33,105.76 219.75,105.76 226.82,98.69 226.82,96.53 224.58,94.29 222.27,94.29 221.63,93.66 220.88,93.66 220.56,93.33 220.56,92.59 216.03,88.05 216.03,70.29 v1(211.9,66.16) ; v1(211.7,32) 212.18,31.52 212.18,22.4 211.98,22.2 211.98,20.11 207.04,15.17 198.96,15.17 196.94,17.19 195.24,17.19 191.53,20.9 191.53,24.52 190.98,25.07 190.2,25.07 189.44,24.3 177.51,24.3 176.34,25.47 176.34,26.46 175.04,27.76 168.29,27.76 164.83,24.3 140.7,24.3 v1(140.09,24.91) ; v1(108.42,139.75) 108.39,139.72 105.45,139.72 104.76,139.04 104.76,138.58 101.9,135.72 101.9,135.1 101.29,134.49 98.62,134.49 92.29,128.16 92.29,120.01 91.59,119.31 86.52,119.31 84.29,117.09 84.29,115.44 84.29,115.44 84.29,113.2 83.3,112.21 80.73,112.21 75.98,107.46 v1(60.69,107.46)
  BOTTOM w0.114: PR174.1 209.18,195.96 209.03,196.11 208.65,196.11 v1(208.62,196.14) PU5.10 ; v1(108.42,139.75) 108.42,136.59 R531.1 ; v1(60.69,107.46) 60.67,107.44 60.67,106.42 59.65,105.41 59.65,102.61 v3(56.55,99.51) 55.71,98.67 55.71,92.71 52.18,89.18 52.18,85 49.82,82.65 49.82,72.94 51.68,71.09 57.14,71.09 58.69,72.64 70.2,72.64 71.77,71.07 76.77,71.07 81.94,65.91 85.36,65.91 91.62,59.65 91.62,54.64 101.74,44.52 112.32,44.52 132.71,24.13 139.31,24.13 v1(140.09,24.91) ; R465.1 PR32.2 156.3,183.13 v1(156.81,183.64) ; v1(211.7,32) 222.21,42.52 222.21,46.6 221.2,47.62 220.66,47.62 220.38,47.9 220.38,53.03 220.81,53.46 220.81,60.07 214.72,66.16 v1(211.9,66.16)
H_PROCHOT#_R: length 9.4
  BOTTOM w0.076: U35.C65 119.95,129.77 119.44,130.27 119.19,130.27 118.88,130.58 118.88,131.31 118.75,131.45 118.75,131.61 118.25,132.1
  BOTTOM w0.114: R531.2 113.84,131.95 117.41,131.95 117.56,132.1 118.25,132.1
HDA_BCLK_R: length 6.6
  BOTTOM w0.076: U35.AY22 144.36,109.33 144.36,108.02 144.49,107.89 144.66,107.89 144.74,107.82 144.74,107.06 145.56,106.24 146.06,106.24 147.15,105.15 147.15,104.65 R644.2
HDA_RST#_R: length 12.1
  BOTTOM w0.076: U35.AW22 144.65,110.07 144.93,109.79 144.93,109.4 144.87,109.34 144.87,109.22 145.08,109 145.08,108.18 148.2,105.06 148.37,105.06 148.97,104.46 148.97,103.88
  BOTTOM w0.114: R660.2 149.95,101.88 149.34,102.48 v1(149.29,102.48) 148.97,102.8 148.97,103.88
HDA_SDO_R: length 104.1
  IN2 w0.127: v1(176.87,77.36) 176.92,77.42 180.99,77.42 182.78,75.62 191.67,75.62 191.91,75.38 191.91,64.69 191.73,64.51 189.88,64.51 189.57,64.21 189.57,63.39 189.7,63.27 189.7,53.34 192.51,50.53 v1(192.86,50.53)
  BOTTOM w0.076: R645.2 148.17,104.62 144.65,108.14 U35.BB22
  BOTTOM w0.114: R737.2 198.46,50.36 197.9,50.92 196.71,50.92 196.37,51.27 193.6,51.27 v1(192.86,50.53) ; v1(176.87,77.36) v3(175.02,79.21) 174.83,79.41 174.83,80.31 174.34,80.81 171.97,80.81 171.36,81.41 171.2,81.41 170.52,82.08 166.26,82.08 162.3,86.04 157.5,86.04 146.39,97.15 146.39,99.06 146.65,99.31 146.65,102.61 147.66,103.63 147.66,103.89 R645.2
HDA_SYNC_R: length 11.5
  BOTTOM w0.076: 148.68,103.88 148.68,104.52 148.3,104.9 148.13,104.9 144.92,108.11 144.92,108.7 U35.BA22
  BOTTOM w0.114: R667.2 C742.2 147.91,102 v3(147.92,102) 147.92,102.26 148.68,103.02 148.68,103.88
HDMI4K2K_CFG: length 2.9
  TOP w0.114: U18.23 20.53,69.19 v1(20.08,69.64) 19.88,69.85 R311.2
HDMI4K2K_DDCBUF: length 3.4
  TOP w0.114: U18.14 24.69,71.33 24.78,71.41 24.78,72.03 v1(24.24,72.56) 24.86,73.18 24.86,73.51 R297.2
HDMI4K2K_EN: length 3.2
  TOP w0.114: U18.13 25.09,71.58 v1(25.23,71.73) 25.23,72.89 R298.2
HDMI4K2K_EQ: length 7
  TOP w0.114: U18.17 23.49,72.85 R295.1 23.33,74.03 23.33,75.55 R292.2 22.82,76.04 21.93,76.04 v3(21.91,76.07)
HDMI4K2K_ISET: length 4.6
  TOP w0.114: R320.1 R321.2 24.09,63.25 v1(24.09,63.6) 24.09,64 23.49,64.6 U18.34
HDMI4K2K_PRE: length 6.9
  TOP w0.114: v3(24.75,76.2) 24.4,76.2 24.26,76.06 R293.2 24.35,75.55 24.35,74.03 R296.1 23.72,73.4 23.72,71.62 23.89,71.45 U18.16
HDMI_5V:
  vias: v1(12.51,73.76) v1(13.14,73.76) v3(12.66,74.49)
HDMI_DDCCLK_MB: length 22.7
  TOP w0.114: R316.2 22.31,64.01 v1(22.31,64.13) 22.49,64.31 22.49,64.89 22.69,65.09 U18.32
  IN1 w0.127: CN12.15 9.74,70.85 9.74,72.24 10.25,72.74 11.37,72.74 12.43,71.67 12.43,70.76 19.11,64.08 19.7,64.08 20.26,63.53 22.11,63.53 22.31,63.73 v1(22.31,64.13)
HDMI_DDCCLK_SW: length 231.2
  TOP w0.114: v1(33.57,61.65) 32.22,61.65 31.94,61.93 31.88,61.93 v3(31.33,61.39) 30.78,61.93 29.63,61.93 R322.1 28.81,61.81 28.1,61.81 25.09,64.82 U18.38
  IN2 w0.102: v2(149.82,124.51) 150.22,124.91 150.76,124.91 151.57,124.1 152.39,124.1 152.44,124.14 154.9,124.14
  IN2 w0.127: v1(33.57,61.65) 38.22,61.65 45.66,69.08 49.22,69.08 50.51,70.38 61.84,70.38 62.12,70.1 68.49,70.1 68.77,70.38 73.67,70.38 74.82,71.53 85.14,71.53 92.78,79.17 v1(94.02,79.17) ; v1(169.2,80.16) 169.81,80.77 169.81,83.46 170.47,84.12 170.47,85.02 171.63,86.18 172.6,86.18 178.55,92.12 178.55,96.52 179.26,97.23 179.26,101.65 179.68,102.07 179.68,105.14 179.49,105.33 179.49,107.96 176.23,111.22 176.23,113.68 175.5,114.4 175.5,115.44 174.98,115.96 174.98,117.61 174.08,118.51 173.42,118.51 171.16,120.77 170.78,120.77 169.61,121.95 169.61,124.55 168.9,125.26 167.16,125.26 166.8,124.9 164.46,124.9 163.92,124.35 159.63,124.35 159.37,124.1 156.32,124.1 156.28,124.14 154.9,124.14
  BOTTOM w0.114: v2(149.82,124.51) 149.53,124.8 U35.L13 ; v1(94.02,79.17) 94.2,79.35 94.88,79.35 96.12,80.58 165.37,80.58 165.53,80.43 168.94,80.43 v1(169.2,80.16)
HDMI_DDCDATA_MB: length 22.8
  TOP w0.114: R317.2 22.59,63.48 22.59,63.78 v1(22.95,64.13) 22.73,64.35 22.73,64.79 22.85,64.91 22.96,64.91 23.09,65.03 U18.33
  IN1 w0.127: v1(22.95,64.13) 22.57,63.75 22.57,63.62 22.22,63.27 20.15,63.27 19.6,63.83 19.01,63.83 12.18,70.65 12.18,71.57 11.26,72.49 10.35,72.49 9.99,72.13 9.99,70.79 10.08,70.7 CN12.16
HDMI_DDCDATA_SW: length 231.1
  TOP w0.114: v1(33.57,62.58) 33.62,62.53 33.62,62.23 33.49,62.1 33.39,62.1 33.18,61.89 32.32,61.89 32.04,62.18 31.81,62.18 v3(31.33,62.66) 30.85,62.18 29.22,62.18 29.16,62.23 R319.1 28.61,62.06 28.2,62.06 25.33,64.92 25.33,65.09 25.49,65.25 U18.39
  IN2 w0.102: v2(150.45,124.51) 150.59,124.66 150.75,124.66 151.49,123.91 152.47,123.91 152.51,123.95 154.65,123.95 154.71,123.89 154.9,123.89
  IN2 w0.127: v1(94.02,79.97) 94.09,79.89 94.09,79.74 93.97,79.61 93.8,79.61 93.61,79.42 92.67,79.42 85.03,71.78 74.72,71.78 73.57,70.63 68.64,70.63 68.36,70.35 62.22,70.35 61.94,70.63 50.41,70.63 49.11,69.34 45.55,69.34 38.12,61.91 33.96,61.91 33.77,62.1 33.69,62.1 33.57,62.23 v1(33.57,62.58) ; 154.9,123.89 156.17,123.89 156.22,123.85 159.48,123.85 159.73,124.1 164.02,124.1 164.57,124.65 166.91,124.65 167.26,125 168.8,125 169.35,124.45 169.35,121.84 170.68,120.52 171.05,120.52 173.31,118.26 173.98,118.26 174.73,117.51 174.73,115.86 175.25,115.34 175.25,114.3 175.97,113.57 175.97,111.11 179.24,107.85 179.24,105.22 179.43,105.03 179.43,102.17 179.01,101.75 179.01,97.34 178.3,96.63 178.3,92.23 172.5,86.43 171.52,86.43 170.22,85.13 170.22,84.23 169.56,83.57 169.56,80.87 169.43,80.74 169.31,80.74 v1(169.2,80.85)
  BOTTOM w0.114: v1(169.2,80.85) 169.02,80.67 165.63,80.67 165.47,80.83 96.02,80.83 94.78,79.59 94.12,79.59 94.02,79.69 v1(94.02,79.97) ; v2(150.45,124.51) 150.18,124.78 U35.L12
HDMI_MB_HPD: length 15.4
  TOP w0.114: U18.28 20.63,67.19 v1(20.38,66.95) 20.36,66.92 v1(19.77,66.92)
  IN2 w0.127: v1(14.58,76.44) 14.58,73.77 17.49,70.86 17.49,69.21 v1(19.77,66.92)
  BOTTOM w0.114: v1(14.58,76.44) R720.1 R721.1
HDMI_MB_HPD_R: length 19.3
  TOP w0.114: U18.3 v1(27.5,67.19)
  BOTTOM w0.114: v1(27.5,67.19) 27.39,67.31 v3(27.39,68.27) 27.39,73.15 26.89,73.66 22.44,73.66 21.3,74.8 21.3,75.81 21,76.11 R718.1 19.41,76.45 18.12,76.45 17.74,76.07 17.11,76.07
HP-L2: length 36.2
  TOP w0.203: 33.36,28.7 33.36,29.08 33.2,29.24 U23.32
  TOP w0.381: 33.36,28.7 v1(33.36,28.29) 33.36,27.17 v1(33.11,26.92) ; R422.2 R423.1 16.52,13.31 17.04,13.83 C552.2 R421.1 v1(19.76,13.83)
  IN2 w0.381: v1(19.76,13.83) 18.88,14.7 18.88,16.7 17.79,17.79 17.79,23.66 20.27,26.14 32.32,26.14 v1(33.11,26.92)
HP-L3: length 9.4
  TOP w0.381: R422.1 C553.1 13.62,14.09 13.3,13.76 v3(13.3,11.3) 13.3,10.16 12.79,9.65 10.22,9.65 CN21.1
HP-R2: length 36.9
  TOP w0.203: 33.81,29.27 33.6,29.48 U23.33
  TOP w0.381: v1(34,26.54) v1(34,27.15) 34,29.08 33.81,29.27 ; v1(19.77,15.62) 19.52,15.87 R418.1 19,16.62 C549.2 17.39,17.57 16.9,17.57 v3(16.55,17.22) 15.96,16.62 R417.1 15.09,16.39 R420.2
  IN2 w0.381: v1(19.77,15.62) 19.77,17.07 18.68,18.16 18.68,23.29 20.64,25.25 32.71,25.25 v1(34,26.54)
HP-R3: length 14.1
  TOP w0.381: R420.1 C550.1 13.81,16.62 12.92,17.52 12.92,19.05 v3(12.3,19.66) 11.52,20.44 5.21,20.44 CN21.2
HP_DET_CN: length 5.7
  BOTTOM w0.114: R721.2 v1(12.79,74.67) 12.38,74.67 10.73,73.02 9.92,73.02 CN12.19
HP_JD#: length 33.6
  TOP w0.381: R383.1 v1(26.89,33.52)
  IN2 w0.381: v1(26.89,33.52) 26.95,33.46 26.95,29.39 26.06,28.5 19.4,28.5 15.48,24.58 15.48,20.85 14.19,19.55 v1(14.19,19.43) 13.17,19.43 12.15,20.44 7.96,20.44 CN21.6
  BOTTOM w0.381: v1(14.92,19.4) 14.21,19.4 v1(14.19,19.43) 14.06,19.55 D33.1
HSYNC: length 8.4
  TOP w0.114: U13.2 18.37,109.98 v1(18.25,110.1)
  BOTTOM w0.114: U40.2 13.58,107.13 13.96,107.51 v3(15.46,107.51) 16.37,107.51 16.67,107.82 17.36,107.82 17.81,108.27 17.81,109.67 v1(18.25,110.1)
HWPG: length 100
  TOP w0.254: D17.2 D18.2 200.52,31.9 201.69,31.9 D19.2 D20.2 203.77,32.76 204.3,33.3 204.3,35.39 204.13,35.57 203.54,35.57 201.1,38.01 198.99,38.01 198.34,38.67 D11.2 199.33,39.32 199.62,39.03 199.62,38.76 199.92,38.45 201.79,38.45 202.65,39.32 D14.2 203.92,38.32 204.29,37.96 R374.1 205.32,37.58 205.95,36.95 207.05,36.95 v3(207.07,36.93) 207.1,36.95 207.71,36.95 209.95,39.2 v1(210.53,39.2) ; R102.2 195.06,89.06 v1(194.84,89.28)
  IN1 w0.254: v1(194.84,89.28) 194.84,87.82 195.22,87.44 196.31,87.44 201.65,82.1 203.35,82.1 207.1,78.35 207.1,71.62 209.89,68.83 209.89,66.67 211.95,64.61 211.95,52.75 211.23,52.03 211.23,50.55 209.36,48.69 209.36,45.82 208.42,44.88 208.42,43.67 210.27,41.82 210.27,39.46 v1(210.53,39.2)
  BOTTOM w0.203: U45.21 209.79,35.91 210.53,36.65 v1(210.53,39.2)
HWPG_1.5V: length 179.9
  TOP w0.114: v1(84.39,21.15) 84.42,21.13 85.61,21.13 92.44,27.96 92.44,41.73 83.78,50.39 83.78,54.63 v1(82.99,55.42) 81.62,56.79 v1(81.62,57.27)
  TOP w0.254: v1(196.43,31.58) 197.05,31.58 197.28,31.81 197.28,33.12 198.02,33.85 199.91,33.85 200.22,34.16 D18.1
  IN1 w0.254: v1(81.62,57.27) 101.24,37.65 167.89,37.65 170.15,35.39 176.3,35.39 180.99,30.7 183.3,30.7 183.73,30.27 184.34,30.27 184.99,30.92 195.73,30.92 196.39,31.58 v1(196.43,31.58)
  BOTTOM w0.114: PR332.2 82.65,21.11 82.9,21.36 84.18,21.36 v1(84.39,21.15)
HWPG_1.5VGFX: length 99.4
  TOP w0.254: v1(165.42,146.5) 165.16,146.76 165.09,146.76 v1(164.91,146.93) 164.81,147.04 164.81,148.32 R83.2
  IN2 w0.254: v1(165.42,146.5) 165.57,146.66 169.46,146.66 173.25,142.87 174.59,142.87 175.48,141.99 175.48,140.97 177.74,138.71 178.32,138.71 178.93,138.1 178.93,137.41 182,134.34 182,134.31 182.03,134.29 182.03,125.04 182.33,124.74 182.33,124.51 182.87,123.97 182.87,122.78 183.87,121.78 183.87,117 187.11,113.76 187.57,113.76 197.57,103.75 197.57,101.72 199.78,99.51 204.89,99.51 206.4,101.02 208.43,101.02 209.87,102.46 209.87,103.67 209.4,104.14 209.4,118.74 v1(209.26,118.88)
  BOTTOM w0.254: v1(209.26,118.88) 209.77,118.88 PR252.1 PR255.1 210.52,117.6 PR346.1
HWPG_1.05VGFX: length 2.2
  BOTTOM w0.114: PR302.1 195.17,66.29 PR304.1 196.3,66.17 TP76.1
HWPG_1.8VS5: length 268.9
  TOP w0.114: v1(106.9,140.46) 106.48,140.05 106.29,140.05 105.23,138.98 105.23,135.44 103.86,134.08 102.96,134.08 99.62,130.74 97.68,130.74 94.24,127.3 94.24,119.29 93.14,118.19 v3(91.91,118.19) 89.29,118.19 v1(88.99,118.49) ; D11.1 195.92,41.94 195.58,42.28 193.68,42.28 v1(193.43,42.03)
  IN1 w0.127: v1(88.99,118.49) 88.73,118.49 84.8,114.55 84.8,112.01 83.68,110.89 79.91,110.89 74.78,105.76 57.85,105.76 56.27,104.19 56.27,99.68 52.73,96.13 52.73,89.04 56.2,85.57 56.2,82.46 57.03,81.63 57.81,81.63 58.24,81.21 58.24,79.91 59.95,78.2 61.25,78.2 62.69,76.77 63.16,76.77 63.29,76.64 66.51,73.42 66.51,70.02 67.65,68.88 71.37,68.88 73.31,66.94 74.01,66.94 76.54,64.4 76.54,63.51 77.43,62.62 78.82,62.62 100.22,41.22 158.74,41.22 159.58,40.38 167.75,40.38 170.8,37.33 177.55,37.33 179.1,38.88 179.1,40.83 180.66,42.39 186.17,42.39 187.77,43.99 192.09,43.99 193.43,42.64 v1(193.43,42.03)
  BOTTOM w0.114: PR245.2 107.16,140.2 v1(106.9,140.46)
HWPG_1VS5: length 281.6
  TOP w0.254: v1(70.19,112.51) 69.57,112.51 68.29,113.79 45.05,113.79 40.35,109.09 v1(40.35,103.25) ; v1(196.79,32.13) 196.79,33.17 D17.1
  IN1 w0.254: v1(196.79,32.13) 197.02,31.9 197.02,31.06 196.49,30.54 185.24,30.54 184.59,29.89 183.55,29.89 183.15,30.3 180.86,30.3 176.17,34.98 169.98,34.98 167.69,37.27 100.81,37.27 80.1,57.98 80.1,58.33 73.03,65.4 68.49,65.4 64.48,69.41 v1(64.48,71.55)
  IN2 w0.254: v1(40.35,103.25) 44.16,99.44 44.16,91.05 40.86,87.75 40.86,83.31 30.31,72.77 30.31,66.42 v1(30.82,65.91)
  BOTTOM w0.254: PU12.1 74.07,111.77 73.55,111.25 72.54,111.25 72.16,111.63 PR257.1 71.52,112.52 70.08,112.52 70.07,112.51 v1(70.19,112.51) ; v1(64.48,71.55) 59,71.55 56.29,68.84 40.54,68.84 36.59,64.89 v3(35.73,64.89) 32.98,64.89 31.97,65.91 v1(30.82,65.91)
HWPG_+VCCOPC: length 193.7
  TOP w0.114: D14.1 203.92,42.54 203.5,42.97 199.73,42.97 199.5,43.19 196.49,43.19 v1(196.29,43)
  IN1 w0.127: v1(55.59,80.39) 55.59,80.39 55.97,80.39 59.45,76.91 60.54,76.91 63.74,73.71 63.74,69.64 68.3,65.08 72.9,65.08 79.77,58.21 79.77,57.86 100.67,36.95 167.55,36.95 169.84,34.67 175.88,34.67 180.61,29.94 182.97,29.94 183.34,29.57 184.81,29.57 185.46,30.22 196.74,30.22 197.33,30.82 197.33,32.98 195.41,34.9 195.41,35.93 196.37,36.89 196.63,36.89 196.82,37.08 196.82,38.62 196.1,39.34 196.1,42.81 v1(196.29,43)
  BOTTOM w0.114: v1(55.59,80.39) 55.59,79.37 v1(55.16,78.95) 54.83,78.61 54.83,77.86 54.95,77.73 PR293.1 55.33,78.35 PR290.1
HWPG_VDDR: length 60.5
  TOP w0.203: v1(177.51,69.21) 178.2,69.21 179.98,70.99 182.97,70.99 183.62,70.34 183.62,65.08 190.75,57.94 190.75,48.23 190.35,47.83 190.35,43.33 192.31,41.38 194.45,41.38 194.85,40.98 197.23,40.98 197.85,40.36 197.85,38.62 199.34,37.14 201.45,37.14 203.16,35.43 203.16,35.05 203.39,34.82 D20.1
  BOTTOM w0.203: v1(177.51,69.21) 177,69.21 v1(176.69,69.52) 176.31,69.9 PR295.1 175.69,69.53 176.78,68.44 PU15.20
I2C0_SCL: length 151.5
  TOP w0.114: v2(154.39,121.51) 154.55,121.51 154.72,121.34 155.98,121.34 157.36,122.72 157.75,122.72 158.08,123.05 158.34,123.05 R166.2 ; v1(202.91,23.49) 202.65,23.24 R403.1
  IN1 w0.127: v1(202.91,23.49) 199.61,23.49 199.03,24.06 199.03,27.36 199.34,27.67 199.34,28.56 200.62,29.84 200.62,33.61 199.29,34.94 199.29,37.78 198.7,38.37 198.7,38.93 198.02,39.61 198.02,43.05 197.68,43.39 197.68,45.59 195.85,47.42 195.85,48.17 196.33,48.65 196.33,49.28 195.77,49.83 195.69,49.83 195.49,50.03 195.49,50.91 192.96,53.44 192.96,61.23 195.63,63.9 195.63,68.69 194.56,69.76 194.56,74.65 190.99,78.23 187.52,78.23 185.36,80.39 185.36,81.28 183.29,83.35 183.29,85.83 180.27,88.85 180.27,91.42 179.67,92.03 179.67,96.95 179.59,97.02 179.59,97.48 180.3,98.19 180.3,101.68 180.34,101.72 180.34,102.98 176.52,106.8 176.52,108.37 175.63,109.26 175.63,112.14 177,113.51 177,115.48 176.05,116.43 176.05,118.85 176.11,118.92 176.11,119.97 175.97,120.12 175.97,120.85 175.31,121.51 173.34,121.51 171.78,123.07 170.09,123.07 168.56,121.55 167.72,121.55 166.83,122.44 165.12,122.44 163.84,123.72 163.15,123.72 161.23,121.8 156.16,121.8 155.7,121.34 154.56,121.34 v2(154.39,121.51)
  BOTTOM w0.076: v2(154.39,121.51) 154.08,121.82 U35.U6
  BOTTOM w0.114: Q43.4 202.64,23.76 v1(202.91,23.49)
I2C0_SDA: length 156.6
  TOP w0.114: R167.2 159.14,123.18 158.72,122.75 158.16,122.75 157.86,122.45 157.47,122.45 156.09,121.08 154.19,121.08 v2(153.76,121.51) ; v1(199.5,21.84) 200.19,21.84 200.32,21.97 R405.1
  IN1 w0.127: v2(153.76,121.51) 153.78,121.51 154.23,121.07 155.82,121.07 156.28,121.52 161.35,121.52 163.26,123.44 163.73,123.44 165,122.16 166.71,122.16 167.61,121.27 168.68,121.27 170.2,122.79 171.66,122.79 173.23,121.23 175.2,121.23 175.69,120.74 175.69,120 175.83,119.86 175.83,119.04 175.77,118.97 175.77,116.32 176.72,115.36 176.72,113.62 175.35,112.25 175.35,109.14 176.24,108.25 176.24,106.69 180.06,102.86 180.06,101.84 180.02,101.8 180.02,98.31 179.31,97.6 179.31,96.91 179.39,96.83 179.39,91.91 179.99,91.31 179.99,88.73 183.01,85.72 183.01,83.24 185.08,81.17 185.08,80.27 187.4,77.95 190.87,77.95 194.28,74.54 194.28,69.64 195.35,68.57 195.35,64.01 192.68,61.35 192.68,53.32 195.21,50.8 195.21,49.92 195.58,49.55 195.66,49.55 196.05,49.16 196.05,48.77 195.57,48.28 195.57,47.3 197.4,45.47 197.4,43.28 197.74,42.93 197.74,39.5 198.42,38.81 198.42,38.25 199.01,37.67 199.01,34.83 200.34,33.5 200.34,29.96 199.06,28.67 199.06,27.79 198.75,27.48 198.75,23.95 199.49,23.21 201.26,23.21 201.51,22.96 201.51,22.55 200.9,21.94 199.61,21.94 v1(199.5,21.84)
  BOTTOM w0.076: U35.U7 153.43,121.84 v2(153.76,121.51)
  BOTTOM w0.114: v1(199.5,21.84) 200.49,21.84 200.56,21.9 200.56,22.4 200.49,22.46 Q43.1
I2C1_SCL: length 121.3
  TOP w0.076: 155.16,121.9 155.14,121.92 153.33,121.92 153.06,121.65 152.92,121.65 152.6,121.65 v2(152.46,121.51)
  TOP w0.114: R169.1 157.37,123.11 156.85,123.11 155.65,121.9 155.16,121.9 ; Q2.3 139.6,192.26 139.36,192.5 139,192.5 138.75,192.25 138.75,190.14 139.15,189.73 142.33,189.73 142.72,190.12 R13.2 143.22,191 143.47,190.75 v3(143.47,188.59) 144.09,187.96 144.1,187.96 v1(144.49,187.57)
  IN1 w0.076: v2(152.46,121.51) 152.9,121.95 154.83,121.95 154.88,121.89 154.9,121.89
  IN1 w0.127: 154.9,121.89 155.65,121.89 156.03,122.27 158.69,122.27 159.11,122.69 160.17,122.69 160.19,122.67 161.56,122.67 163.09,124.2 167.1,124.2 167.47,123.83 168.63,123.83 169.53,124.73 169.53,126.51 168.14,127.9 168.14,131.35 167.12,132.37 167.12,133.69 166,134.81 164.87,134.81 164.22,135.45 163.39,135.45 161.94,136.9 160.39,136.9 159.88,137.41 159.88,139.82 159.63,140.08 159.63,149.38 160.11,149.87 160.11,150.74 163.06,153.68 163.06,156.32 162.17,157.21 162.17,162.14 162.89,162.86 162.89,164.22 160.92,166.19 160.92,173.17 157.19,176.9 157.19,179.33 156.51,180.01 155.48,180.01 152.91,182.57 152.91,185.08 152.14,185.85 151.44,185.85 150.32,186.97 145.1,186.97 v1(144.49,187.57)
  BOTTOM w0.114: U35.U9 152.46,121.56 v2(152.46,121.51)
I2C1_SCL_C: length 15.9
  TOP w0.114: R13.1 R12.1 v1(140.69,191.69) ; R6.1 141.61,196.94 141.29,196.62 141.29,196.45 141.91,195.83 143.6,195.83 144.21,195.22 v3(144.21,193.59) v1(144.21,192.48) 144.21,191.99 143.98,191.77 143.22,191.77 142.72,192.26 Q2.4
  IN1 w0.127: v1(144.21,192.48) 143.52,193.16 142.16,193.16 v1(140.69,191.69)
I2C1_SDA: length 127
  TOP w0.076: v2(153.12,122.55) 153.02,122.55 152.59,122.12 152.59,121.92 152.69,121.81 152.99,121.81 153.26,122.08 155.07,122.08 155.16,122.17
  TOP w0.114: 155.16,122.17 155.54,122.17 156.43,123.06 R165.1 ; v1(142.25,194.13) 142.33,194.05 Q2.6 141.68,193.56 141.44,193.8 141.44,194.18 141.06,194.56 R10.2
  IN1 w0.076: v2(153.12,122.55) 153.56,122.11 154.83,122.11 154.88,122.17 154.9,122.17
  IN1 w0.127: v1(143.52,187.04) 144.63,187.04 144.98,186.69 150.2,186.69 151.32,185.57 152.03,185.57 152.63,184.97 152.63,182.46 155.36,179.73 156.39,179.73 156.91,179.21 156.91,176.79 160.64,173.05 160.64,166.07 162.61,164.1 162.61,162.98 161.89,162.25 161.89,157.1 162.78,156.21 162.78,153.8 159.83,150.85 159.83,149.98 159.35,149.5 159.35,139.96 159.6,139.71 159.6,137.29 160.27,136.62 161.82,136.62 163.27,135.17 164.11,135.17 164.76,134.53 165.88,134.53 166.84,133.57 166.84,132.25 167.86,131.24 167.86,127.78 169.25,126.39 169.25,124.85 168.51,124.11 167.59,124.11 167.22,124.48 162.98,124.48 161.44,122.94 160.31,122.94 160.28,122.97 158.99,122.97 158.57,122.55 155.92,122.55 155.54,122.17 154.9,122.17
  BOTTOM w0.114: v1(143.52,187.04) 143.15,187.42 141.93,187.42 141.75,187.59 141.75,188.42 141.88,188.55 142.14,188.55 142.27,188.42 142.27,187.99 142.41,187.85 142.6,187.85 142.73,187.99 142.73,188.42 142.86,188.55 143.31,188.55 143.44,188.69 143.44,188.88 143.31,189.01 141.88,189.01 141.75,189.14 141.75,189.33 141.88,189.47 v1(142.48,189.47) 143.31,189.47 143.44,189.6 143.44,189.79 143.31,189.92 141.45,189.92 141.29,190.09 141.29,190.52 141.11,190.7 141.11,191.57 141.5,191.96 141.5,192.34 142.25,193.09 v1(142.25,194.13) ; U35.U8 152.78,122.21 v2(153.12,122.55)
I2C1_SDA_C: length 7.1
  TOP w0.114: Q2.1 139.6,193.56 139.46,193.7 139.46,194.14 R10.1 140.52,195.19 141.06,195.19 141.44,194.81 R9.1 141.94,195.42 140.55,196.81 R5.1
I2C_TP_SCL_R: length 16.1
  TOP w0.114: R410.1 207.59,21.06 207.59,21.23 v1(207.35,21.46) ; v1(200.77,24.3) 200.37,23.9 200.37,23.61 R403.2
  IN2 w0.127: v1(200.77,24.3) 201.11,23.97 201.11,22.95 200.93,22.77 200.93,21.61 201.41,21.13 202.65,21.13 203.09,21.56 204.29,21.56 205.15,20.7 206.59,20.7 v1(207.35,21.46)
  BOTTOM w0.114: Q43.3 200.23,23.76 v1(200.77,24.3) ; v1(207.35,21.46) 207.05,21.15 CN17.3
I2C_TP_SDA_R: length 13.9
  TOP w0.114: R405.2 201.76,21.97 201.84,21.89 v1(202.27,21.89) ; v1(206.72,21.51) 206.72,21.33 207.07,20.98 R409.1
  IN2 w0.127: v1(206.72,21.51) 206.72,21.22 206.48,20.98 205.27,20.98 204.41,21.84 202.97,21.84 202.54,21.41 201.53,21.41 201.21,21.73 201.21,22.66 201.3,22.76 201.51,22.76 202.27,21.99 v1(202.27,21.89)
  BOTTOM w0.114: v1(202.27,21.89) 201.77,22.39 Q43.6 ; v1(206.72,21.51) 206.34,21.51 206.05,21.22 CN17.4
I2CA_SCL: length 14.4
  BOTTOM w0.114: R521.1 193.27,140.01 192.77,140.51 192.77,141.97 193.94,143.13 193.94,144.57 194.79,145.42 194.79,148.3 193.88,149.21 193.88,149.23 193.31,149.81 193.31,150.21 193.4,150.3 193.4,150.76 193.14,151.02 192.73,151.02 192.32,151.42 U34.B7
I2CA_SDA: length 11.4
  BOTTOM w0.114: U34.A7 193.61,150.85 193.61,150 193.61,149.82 194.16,149.27 194.16,149.25 195.08,148.34 195.08,144.48 194.17,143.57 194.17,143.04 193.27,142.14 R502.1
ICMNT: length 237.4
  TOP w0.114: v1(193.51,32.23) 193.66,32.38 194.27,32.38 195.26,33.37 C516.2 ; v1(211.8,198.24) 211.44,198.6 211.44,199.08 v1(211.42,199.11) 211.39,199.13 PC3.2
  IN2 w0.127: v1(211.8,198.24) 212.31,197.73 212.31,196.08 213.31,195.08 213.31,194.05 216.41,190.94 216.41,187.78 224.99,179.21 224.99,149.97 224.99,149.76 223.66,148.43 220.34,148.43 218,146.09 218,131.73 218.41,131.32 218.41,126.62 219.54,125.49 219.54,117.22 223.71,113.05 227.01,113.05 230.64,109.42 230.64,92.71 228.94,91 223.26,91 219.56,87.31 219.56,56.51 219.1,56.06 219.1,49.06 223.91,44.24 223.91,33.12 222.47,31.67 221.2,31.67 214.11,38.76 206.76,38.76 206.75,38.77 206.38,38.77 206.37,38.76 206.06,38.76 204.33,37.03 v1(203.92,37.03)
  BOTTOM w0.114: PR170.1 210.91,199.39 211.8,198.5 v1(211.8,198.24) ; v1(203.92,37.03) 203.75,37.21 203.29,37.21 203.05,36.97 201.44,36.97 198.67,34.2 197.73,34.2 197.37,33.84 195.91,33.84 194.45,32.38 193.66,32.38 v1(193.51,32.23) 193.42,32.31 U45.67
IDCHG: length 297.7
  TOP w0.114: v1(174.66,26.54) 175.54,27.17 179.74,27.17 181.38,28.81 v1(181.38,32.51) ; PC6.2 210.91,197.99 v1(211.16,198.24)
  IN1 w0.127: v1(181.38,32.51) 190.41,32.51 190.77,32.86 v1(190.77,33.52)
  IN2 w0.127: v1(174.66,26.54) 177.13,23.87 189.42,23.87 189.62,23.87 190.38,24.63 190.8,24.63 191.1,24.34 191.1,20.68 195.09,16.68 196.83,16.68 198.78,14.74 199.13,14.74 208.71,14.74 213.42,19.45 213.42,29.1 214.24,29.92 223.91,29.92 226.35,32.36 226.35,52.45 226.91,53.01 226.91,58.75 226.5,59.15 221.78,59.15 219.81,61.12 219.81,87.2 223.28,90.67 229.1,90.67 230.92,92.5 230.92,109.75 227.24,113.43 224.83,113.43 219.8,118.46 219.8,125.75 218.68,126.87 218.68,131.41 218.26,131.82 218.26,146 220.45,148.18 223.77,148.18 225.26,149.67 225.26,179.37 217.87,186.76 217.87,196.64 215.51,199 211.82,199 211.16,198.34 v1(211.16,198.24)
  BOTTOM w0.114: U45.70 190.78,33.52 v1(190.77,33.52) ; PR171.1 v1(211.16,198.24)
ILIM_HI: length 2.6
  TOP w0.114: U22.16 21.41,39.35 20.89,38.83 v1(20.89,38.38) 20.92,38.35 R377.1
ILIM_LO: length 2.8
  TOP w0.114: U22.15 20.91,39.24 19.9,38.23 R376.2
IMVP_PWRGD: length 32.9
  TOP w0.114: PR30.2 157.32,184.15 PR197.2 158.85,185.28 160.62,183.51 160.62,182.49 160.24,182.11 159.32,182.11 157.06,179.85 157.06,176.91 v1(161.48,172.49)
  BOTTOM w0.114: v1(161.48,172.49) 162.52,171.45 163.54,171.45 164.68,170.3 v3(164.68,167.13) 164.05,166.49 U33.2 164.05,164.89 164.22,164.71 165.21,164.71 165.44,164.95 R478.1
IMVP_PWRGD_3V: length 37.2
  TOP w0.114: U8.1 159.71,135.36 160.06,135.71 160.06,138.11 R113.2 159.97,143.08 159.49,143.56 v1(158.48,143.56)
  BOTTOM w0.114: v1(158.48,143.56) 159.27,144.34 159.27,147.24 159.47,147.44 159.47,149.73 159.85,150.11 159.85,150.77 163,153.92 163,155.7 164.05,156.74 164.05,158.36 162.9,159.51 162.27,159.51 162.27,160.65 163.28,161.67 v3(163.51,161.67) R485.2 164.55,162.41 164.7,162.56 U33.4 164.7,164.2 164.83,164.33 165.41,164.33 165.57,164.17 R478.2
INT_AMIC-VREFO: length 5.6
  TOP w0.114: C534.1 28.92,28.37 28.05,27.5 v1(28.05,27.12)
  TOP w0.203: U23.27 31.2,30.12 30.24,29.16 30.24,28.76 R397.2 C534.1
INT_HDMI_HPD: length 201
  IN1 w0.127: v1(54.64,93.28) 63.2,101.85 75.4,101.85 81.32,107.77 82.14,107.77 97.19,122.82 99.09,122.82 104.46,128.19 106.31,128.19 107.33,129.21 109.31,129.21 109.7,129.6 111.14,129.6 114.79,133.24 119.83,133.24 120.76,132.31 120.76,131.72 121.31,131.17 121.86,131.17 122.41,131.17 124.1,132.86 124.1,134.55 125.63,136.08 125.63,139.28 125.9,139.54 125.9,140.38 126.8,141.28 128.29,141.28 128.64,140.94 136.45,140.94 139.24,138.15 144.05,138.15 144.6,138.71 149.8,138.71 152.29,136.22 154.2,136.22 160.67,129.74 160.94,129.74 161.29,129.4 161.29,128.95 161.25,128.91 161.25,128.9 160.4,128.05 158.47,128.05 158.19,127.77 156.26,127.77 154.55,126.06 154.55,125.62 154.14,125.22 153.89,125.22 153.68,125.01 152.96,125.01 v2(152.5,124.55)
  BOTTOM w0.114: U35.L9 152.13,124.92 v2(152.5,124.55) ; v1(54.64,93.28) 50.68,89.32 50.68,85.67 49.97,84.96 48.48,84.96 40.41,76.89 v3(20.94,76.89) R718.2 16.53,76.89 16.09,76.45 Q41.1 14.96,74.04 R722.2
INT_HDMICLK+: length 138
  TOP w0.114: v1(34.73,71.72) 34.49,71.97 30.46,71.97 C389.1
  IN2 w0.127: v2(125.35,127.25) 124.93,127.67 124.93,128.02 124.49,128.46 124.17,128.46 123.7,128.93 122.9,128.93 121.91,129.92 117.97,129.92 116.23,131.65 115.7,131.65 114.95,132.41 109.29,132.41 108.7,131.81 107.71,131.81 104.34,128.44 102.48,128.44 98.16,124.12 98.16,117.05 91.56,110.46 91.56,110.13 87.78,106.35 83.58,106.35 75.53,98.29 57.68,98.29 48.93,89.54 48.93,85.38 40.51,76.96 40.51,76.78 41.29,76 41.29,75.61 40.96,75.28 40.57,75.28 39.79,76.06 39.62,76.06 39.44,75.88 39.44,75.7 40.21,74.92 40.21,74.53 39.88,74.2 39.49,74.2 38.72,74.98 38.54,74.98 38.36,74.8 38.36,74.62 39.13,73.84 39.13,73.46 38.8,73.13 38.41,73.13 37.64,73.9 37.46,73.9 35.38,71.82 34.83,71.82 v1(34.73,71.72)
  BOTTOM w0.114: v2(125.35,127.25) 125.02,126.92 U35.G56
INT_HDMICLK+_C: length 15.3
  TOP w0.114: v1(13.72,71.32) 14,71.59 14.57,71.59 14.68,71.49 R303.1 17.06,71.49 v3(17.46,71.09) 17.83,71.46 18.88,71.46 20.74,69.59 U18.22
  IN2 w0.127: v1(13.72,71.32) 13.72,71.48 13.55,71.65 13.21,71.65 12.36,70.8 12.36,68.8 11.52,67.97 10.9,67.97 10.64,67.71 CN12.10
INT_HDMICLK+_C_R: length 5.2
  TOP w0.114: C389.2 28.92,71.94 28.32,71.94 27.8,71.42 27.8,71.24 27.88,71.17 28.21,71.17 v1(28.28,71.09) 27.74,70.54 27.74,70.1 27.39,69.75 27.29,69.75 27.13,69.59 U18.9
INT_HDMICLK-: length 138
  TOP w0.114: v1(34.73,72.54) 34.4,72.21 30.55,72.21 C387.1
  IN2 w0.127: v2(125.36,127.89) 125.18,128.07 125.18,128.12 124.59,128.71 124.28,128.71 123.81,129.18 123,129.18 122.01,130.17 118.07,130.17 116.34,131.9 115.81,131.9 115.05,132.66 109.19,132.66 108.59,132.07 107.6,132.07 104.23,128.7 102.37,128.7 97.9,124.23 97.9,117.16 91.31,110.56 91.31,110.24 87.67,106.6 83.47,106.6 75.42,98.55 57.58,98.55 48.68,89.65 48.68,85.48 40.26,77.06 40.26,76.67 41.03,75.9 41.03,75.72 40.85,75.54 40.67,75.54 39.9,76.31 39.51,76.31 39.18,75.98 39.18,75.59 39.96,74.82 39.96,74.64 39.77,74.46 39.6,74.46 38.82,75.23 38.43,75.23 38.1,74.9 38.1,74.51 38.88,73.74 38.88,73.56 38.7,73.38 38.52,73.38 37.74,74.15 37.35,74.15 35.28,72.08 35.04,72.08 34.73,72.39 v1(34.73,72.54)
  BOTTOM w0.114: U35.F56 125.04,127.57 v2(125.36,127.89)
INT_HDMICLK-_C: length 15.3
  TOP w0.114: v1(13.72,72.44) 14,72.16 14.57,72.16 14.68,72.27 R303.2 15.47,72.27 15.68,72.06 17.16,72.06 v3(17.46,72.36) 17.79,72.03 19.11,72.03 21.15,70 U18.21
  IN2 w0.127: CN12.12 10.92,68.42 11.33,68.42 11.9,68.99 11.9,70.99 13.02,72.11 13.39,72.11 v1(13.72,72.44)
INT_HDMICLK-_C_R: length 5.2
  TOP w0.114: C387.2 28.78,72.18 28.22,72.18 27.56,71.52 27.56,71.33 27.39,71.17 27.09,71.17 v1(27.01,71.09) 27.5,70.61 27.5,70.2 27.29,70 U18.10
INT_HDMITX0N: length 139.1
  TOP w0.114: v1(31.11,69.24) 30.65,68.78 30.21,68.78 30.07,68.92 C398.1
  IN2 w0.127: v1(31.11,69.24) 31.39,68.96 31.58,68.96 32.35,69.72 32.35,73.63 34.02,75.31 35.65,75.31 44.79,84.45 44.79,88.26 46.06,89.53 46.06,90.67 55.46,100.07 67.29,100.07 67.8,100.58 73.03,100.58 74.11,101.66 76.32,101.66 82.78,108.12 87.04,108.12 89.79,110.87 89.79,111.19 96.38,117.79 96.38,125.17 101.43,130.22 103.06,130.22 106.43,133.59 108.18,133.59 108.82,134.23 115.66,134.23 116.62,133.28 119.87,133.28 121.45,131.69 123.56,131.69 125.01,130.25 126.58,130.25 127.17,129.66 127.17,128.85 126.99,128.67 126.99,128.09 v2(127.19,127.89)
  BOTTOM w0.114: U35.F53 126.87,127.57 v2(127.19,127.89)
INT_HDMITX0N_C: length 20.8
  TOP w0.114: U18.24 20.45,68.79 20.28,68.97 18.09,68.97 17.07,69.98 16.56,69.98 v3(16.17,70.38) 15.77,69.98 R312.2 14.75,69.98 14.55,69.77 13.72,69.77 12.57,70.92 12.57,72.06 11.97,72.67 10.34,72.67 9.75,72.08 9.75,67 9.59,66.84 9.46,66.84 CN12.9
INT_HDMITX0N_C_R: length 3
  TOP w0.114: U18.7 27.17,68.79 27.27,68.7 28.16,68.7 28.33,68.88 28.83,68.88 C398.2
INT_HDMITX0P: length 139
  TOP w0.114: v1(31.11,68.42) 31.11,68.43 31,68.54 30.24,68.54 30.07,68.37 C405.1
  IN2 w0.127: v5(127.17,127.17) 126.73,127.62 126.73,128.77 126.91,128.95 126.91,129.56 126.48,129.99 124.9,129.99 123.46,131.44 121.35,131.44 119.77,133.02 116.51,133.02 115.55,133.98 108.93,133.98 108.28,133.34 106.54,133.34 103.17,129.97 101.54,129.97 96.63,125.06 96.63,117.68 90.04,111.09 90.04,110.76 87.15,107.87 82.89,107.87 76.42,101.41 74.22,101.41 73.14,100.33 67.91,100.33 67.4,99.82 55.57,99.82 46.32,90.57 46.32,89.43 45.05,88.16 45.05,84.35 35.75,75.05 34.12,75.05 32.6,73.53 32.6,69.61 31.69,68.7 31.39,68.7 v1(31.11,68.42)
  BOTTOM w0.114: U35.G53 126.92,126.92 v5(127.17,127.17)
INT_HDMITX0P_C: length 20.8
  TOP w0.114: U18.25 17.85,68.39 16.84,69.41 16.47,69.41 v3(16.17,69.11) 15.87,69.41 15.55,69.41 15.35,69.2 R312.1 13.48,69.2 12,70.68 12,71.83 11.4,72.42 10.44,72.42 9.99,71.98 9.99,66.9 9.69,66.59 9.49,66.59 9.09,66.2 CN12.7
INT_HDMITX0P_C_R: length 3
  TOP w0.114: U18.6 27.26,68.39 27.32,68.46 28.26,68.46 28.43,68.64 28.85,68.64 C405.2
INT_HDMITX1N: length 139.5
  TOP w0.114: C406.1 30.46,66.66 33.21,66.66 v1(33.49,66.95)
  IN2 w0.127: v1(33.49,66.95) 33.77,66.67 34.25,66.67 35.75,68.17 35.75,68.35 35.14,68.95 35.14,69.34 35.47,69.67 35.86,69.67 36.47,69.07 36.65,69.07 36.83,69.25 36.83,69.43 36.22,70.03 36.22,70.42 36.55,70.75 36.94,70.75 37.55,70.15 37.73,70.15 37.91,70.32 37.91,70.5 37.3,71.11 37.3,71.5 37.63,71.83 38.02,71.83 38.63,71.22 38.81,71.22 42.13,74.54 42.13,77.85 49.44,85.17 49.44,89.33 57.9,97.79 75.93,97.79 83.98,105.84 88,105.84 93.94,111.78 95.69,111.78 98.89,114.98 98.89,116.73 98.67,116.96 98.67,122.53 104.07,127.94 104.55,127.94 107.92,131.3 108.8,131.3 109.47,131.97 113.47,131.97 116.09,129.36 118.43,129.36 118.88,128.9 121.99,128.9 122.88,128.01 123.66,128.01 123.97,127.71 124.28,127.71 v5(124.44,127.86)
  BOTTOM w0.114: U35.E58 124.07,128.22 v5(124.44,127.86)
INT_HDMITX1N_C: length 12.5
  TOP w0.114: CN12.6 10.82,65.53 11.47,65.53 13.54,67.59 14.97,67.59 R314.2 15.21,67.56 16.9,67.56 v3(17.26,67.92) 17.61,67.56 18.76,67.56 19.19,68 U18.26
INT_HDMITX1N_C_R: length 3.7
  TOP w0.114: U18.5 27.09,68 27.14,67.94 27.9,67.94 28.54,67.31 28.54,66.8 28.69,66.65 28.88,66.65 C406.2

# Allegro board Quanta ZRW REV F - BoardView (.BRD).brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PCH_SPI_SI: length 42
  IN1 w0.127: v1(177.13,100.25) 177.13,100.33 177.43,100.63 177.43,101.67 175.64,103.46 173.85,103.46 171.31,106 171.31,107.07 171.09,107.29 171.09,108.32 171.28,108.51 171.28,109.43 171.28,111 170.38,111.9 166.3,111.9 165.5,111.1 164.15,111.1 163.78,110.73 161.59,110.73 161.28,110.42 160.14,110.42 159.99,110.57 158.47,110.57 158.2,110.31 v5(158.2,110)
  BOTTOM w0.076: U35.AV3 155.45,110.56 156.32,110.56 156.52,110.37 156.93,110.37 157.19,110.11 158.1,110.11 v5(158.2,110)
  BOTTOM w0.114: R691.2 177.9,93.22 178.6,93.93 178.6,99.49 177.76,100.33 177.76,100.47 R658.1 177.37,100.48 177.14,100.25 v1(177.13,100.25)
PCH_SPI_SI_EC: length 100.8
  IN1 w0.127: v1(194.91,48.13) 194.38,48.13 193.55,48.96 193.55,50.71 190.84,53.42 190.84,61.19 192.93,63.28 192.93,68.02 192.71,68.23 192.71,73.88 190.22,76.37 186.75,76.37 186.34,76.78 186.13,76.78 185.84,76.49 185.63,76.49 185.48,76.64 185.48,76.85 185.77,77.14 185.77,77.35 185.62,77.5 185.41,77.5 185.12,77.21 184.91,77.21 184.76,77.36 184.76,77.57 185.05,77.86 185.05,78.07 184.9,78.22 184.69,78.22 184.4,77.93 184.19,77.93 184.04,78.08 184.04,78.29 184.33,78.58 184.33,78.79 184.18,78.94 183.97,78.94 183.68,78.65 183.47,78.65 183.32,78.8 183.32,79.01 183.61,79.3 183.61,79.51 183.5,79.62 183.5,80.34 179.79,84.05 179.79,84.22 179.18,84.83 178.78,84.83 178.55,85.06 178.55,85.85 177.1,87.29 177.1,88.2 176.95,88.35 176.04,88.35 175.89,88.5 175.89,88.71 176.04,88.86 176.95,88.86 177.1,89.01 177.1,90.65 176.95,90.8 175.93,90.8 175.73,90.59 175.73,89.43 175.58,89.28 175.37,89.28 175.22,89.43 175.22,91.15 175.37,91.3 176.95,91.3 177.1,91.45 177.1,91.66 176.95,91.81 175.37,91.81 175.22,91.96 175.22,92.17 175.37,92.32 176.95,92.32 177.1,92.47 177.1,92.68 176.95,92.83 176.18,92.83 176.03,92.98 176.03,93.19 176.18,93.34 176.7,93.34 176.82,93.46 176.82,93.72 176.7,93.84 176.18,93.84 176.03,93.99 176.03,94.2 176.18,94.35 176.52,94.35 176.64,94.48 176.64,94.73 176.52,94.86 175.74,94.86 175.54,94.66 175.54,93.15 v1(175.16,92.77)
  BOTTOM w0.114: R641.1 R654.1 179.16,101.35 179.16,92.83 178.57,92.25 176.43,92.25 175.97,92.71 175.22,92.71 v1(175.16,92.77) ; U45.102 195.91,46.87 195.41,47.37 195.41,48.25 R735.1 v1(194.91,48.13)
PCH_SPI_SI_R: length 7.2
  BOTTOM w0.114: R641.2 177.26,105.28 176.36,105.28 176.11,105.02 U39.5 176.87,104.17 177.13,103.92 177.13,101.88 R658.2
PCH_SPI_SO: length 42.9
  IN1 w0.127: v1(172.29,107.82) 172.32,107.84 172.32,108.85 172.94,109.47 172.94,113.41 173.33,113.8 174.26,113.8 174.45,113.98 174.45,114.46 v1(174,114.91) 173.8,114.7 172.48,114.7 171.87,114.09 167.9,114.09 167.27,113.46 162.75,113.46 162.24,112.94 157.9,112.94 156.65,111.69 156.65,109.7 157.14,109.22 157.62,109.22 v5(158.13,108.71)
  BOTTOM w0.089: U35.AW3 155.53,110.03 155.66,109.9 156.3,109.9 156.49,109.71 156.49,109.3 156.68,109.11 157.72,109.11 v5(158.13,108.71)
  BOTTOM w0.114: v1(172.29,107.82) 171.95,107.82 171.42,107.3 171.42,106.14 169.45,104.17 169.45,103.19 R650.1 ; v1(174,114.91) 174,114.93 173.57,114.5 173.57,114.22 172.97,113.62 R604.1
PCH_SPI_SO_EC: length 101.6
  IN1 w0.127: v1(173.38,107.91) 172.75,107.28 172.75,105.16 174.16,103.74 175.96,103.74 177.88,101.82 177.88,99.83 176.85,98.8 176.85,96.91 176.72,96.79 175.55,96.79 175.43,96.66 175.43,96.41 175.55,96.28 176.52,96.28 176.64,96.15 176.64,95.9 176.52,95.77 174.76,95.77 174.64,95.64 174.64,95.39 174.76,95.26 177.18,95.26 177.38,95.06 177.38,87.62 179.15,85.85 179.41,85.85 180.07,85.19 180.07,84.16 183.78,80.46 183.78,79.73 186.86,76.65 190.33,76.65 192.99,74 192.99,68.45 193.21,68.23 193.21,63.16 191.12,61.08 191.12,53.53 193.83,50.83 193.83,49.08 194.27,48.64 195.01,48.64 v1(195.48,49.1)
  BOTTOM w0.114: R594.1 173.2,114.58 R588.1 173.35,115.69 174.54,115.69 174.94,116.1 176.51,116.1 177.37,115.25 177.37,113.89 176.92,113.44 176.92,110.72 174.71,108.51 173.98,108.51 v1(173.38,107.91) ; U45.103 196.31,46.98 196.01,47.28 196.01,47.35 v1(195.85,47.52) 195.8,47.57 195.8,48.5 R736.1 195.83,48.76 v1(195.48,49.1)
PCH_SPI_SO_R: length 3.8
  BOTTOM w0.114: R594.2 172.37,113.99 172.19,113.81 R604.2 172.19,113.24 172.48,112.95 173.14,112.95 173.57,112.52 U39.2
PCH_SUSACK#: length 97.9
  IN1 w0.127: v1(196.28,32.58) 196.28,32.68 195.76,33.19 195.76,33.88 195.16,34.48 195.16,36.03 195.59,36.47 195.59,43.34 196.06,43.8 196.06,45.56 192.91,48.7 189.57,52.04 189.57,61.87 184.99,66.45 184.99,72.53 181.27,76.25 181.27,80.06 179.41,81.91 178.41,81.91 177.57,82.75 177.57,83.5 177.27,83.8 177.27,85.33 173.95,88.65 173.95,93.21 172.24,94.93 172.24,97.22 171.4,98.06 171.4,100.23 170.1,101.52 170.1,101.91 170.71,102.51 170.71,104.08 168.81,105.98 168.81,106.4 168.17,107.04 168.17,107.88 168.11,107.95 168.11,109.01 v1(168.54,109.44)
  BOTTOM w0.114: v1(196.28,32.58) 198.78,32.58 200.31,31.05 U45.48 ; v1(168.54,109.44) 168.54,109.57 168.29,109.83 168.29,110.28 168.63,110.62 R617.2
PCH_SUSPWRACK: length 24.4
  IN1 w0.132: v1(167.91,109.59) 167.91,109.51 166.8,108.4 166.76,108.4 165.39,107.03 162.41,107.03 162.33,107.11 161.45,107.11 160.15,105.81 158.51,105.81 158.21,106.1 157.23,106.1 155.26,108.08 153.23,108.08 150.49,110.82 150.49,111.92 v2(150.03,112.38)
  BOTTOM w0.114: v1(167.91,109.59) 167.9,109.59 167.72,109.41 R622.2 ; v2(150.03,112.38) 149.68,112.73 U35.AR13
PCH_SUSPWRACK_R: length 88.1
  IN1 w0.127: v1(196.3,37.33) 195.85,37.79 195.85,43.23 196.31,43.7 196.31,45.66 189.83,52.14 189.83,61.97 185.24,66.56 185.24,72.68 181.57,76.35 181.57,80.11 179.52,82.16 178.52,82.16 177.83,82.86 177.83,83.6 177.52,83.91 177.52,85.44 174.21,88.75 174.21,93.32 173.39,94.13 173.39,100.26 172.18,101.47 172.18,102.24 170.96,103.46 170.96,104.18 169.71,105.43 169.71,106.47 169.1,107.08 169.1,107.63 168.6,108.13 v1(168.58,108.13)
  BOTTOM w0.114: v1(168.58,108.13) 168.5,108.21 R622.1 ; U45.79 193.11,37.11 193.26,37.26 196.23,37.26 v1(196.3,37.33)
PCH_TRST#: length 9.9
  BOTTOM w0.076: U35.C61 122.42,129.85 122.71,130.14 122.71,132.34 122.71,132.35 122.71,132.62 122.25,133.08 122.25,133.6 122.22,133.62 122.22,133.98
  BOTTOM w0.114: R534.2 121.24,136.9 R549.1 121.24,135.89 121.4,135.73 122.52,135.73 122.95,135.3 122.95,134.9 122.22,134.17 122.22,133.98
PCH_VRALERT#: length 17.7
  TOP w0.114: R211.2 162.39,110.23 161.33,111.29 159.41,111.29 158.96,111.74 155.8,111.74 155.62,111.92 154.74,111.92 TP19.1 154.14,112.52 153.63,112.52 153.17,112.98 153.17,113.88 152.27,114.78 150.94,114.78 v2(150.51,115.21)
  BOTTOM w0.114: v2(150.51,115.21) 150.49,115.19 U35.AM11
PCI_PLTRST#: length 27.9
  TOP w0.114: 171.03,106.55 170.65,106.55 170.43,106.33 U14.1 ; 171.03,106.55 171.08,106.5 U14.2 ; 171.03,106.55 171.03,106.55 171.03,106.9 171.03,108.12 170.85,108.3 170.5,108.3 169.46,109.34 169.05,109.34 168.72,109.01 168.36,109.01 168.31,109.06 167.15,109.06 167.05,108.96 166.08,108.96 165.48,109.56 164.71,109.56 164.38,109.22 163.79,109.22 163.25,109.76 161.53,109.76 160.44,110.85 156.1,110.85 v1(155.97,110.97) 155.97,110.98 155.45,111.5 154.29,111.5 152.96,112.83 152.45,112.83 152.24,113.05 152.24,113.88 151.76,114.36 150.97,114.36 v2(150.95,114.33)
  BOTTOM w0.076: 151.22,114.13 151.31,114.13 U35.AN10
  BOTTOM w0.114: v2(150.95,114.33) 150.95,114.36 151.18,114.13 151.22,114.13
PCIE_CLKREQ_WLAN#: length 31.2
  TOP w0.114: R253.1 183.35,92.71 182.92,93.14 182.92,94.15 v1(182.84,94.23) 182.84,96.39 183.98,97.52 R241.1 184.51,97.66 Q23.3 ; v1(178.78,107.44) 178.65,107.56 v3(177.53,107.56) 175.22,107.56 174.46,106.8 174.45,106.8 174.33,106.69 174.33,105.4 173.96,105.02 R224.1
  IN1 w0.127: v1(178.78,107.44) 179.08,107.44 182.82,103.71 182.82,101.19 183.3,100.71 183.3,97.49 183.22,97.41 183.22,95.12 182.84,94.74 v1(182.84,94.23)
PCIE_LAN_WAKE#: length 195.5
  TOP w0.114: v1(183.35,93.34) 183.37,93.34 183.6,93.57 R244.1 ; v1(161.09,84.83) v3(161.09,86.64) 161.46,87.01 161.46,88.77 162.64,89.95 v1(163.53,89.95) 164.24,90.66 164.24,91.22 164.81,91.79 164.81,92.97 R250.1
  IN1 w0.127: v1(50.25,86.48) 51.6,86.48 56.7,81.38 57.71,81.38 57.99,81.1 57.99,79.81 59.85,77.95 61.13,77.95 62.75,76.32 v1(62.98,76.32)
  IN2 w0.127: v1(179.41,83.82) 179.48,83.88 179.48,86.16 182.33,89.02 182.33,92.27 182.26,92.35 182.26,92.88 182.71,93.34 v1(183.35,93.34) ; v1(62.98,76.32) 72.99,76.32 78.83,82.16 87.59,82.16 90.51,85.09 v1(90.51,86.86)
  BOTTOM w0.076: 155.03,104.9 155.03,104.91 154.84,104.91 154.09,105.65 153.25,105.65 153.06,105.85 151.96,105.85 151.65,106.16 150.99,106.16 150.87,106.27 149.93,106.27 149.65,106.55 148.86,106.55 148.25,107.15 148.25,108.31 U35.BB15
  BOTTOM w0.114: v1(161.09,84.83) 159.41,83.16 150.04,83.16 145.72,87.47 145.59,87.47 145.58,87.48 95.19,87.48 94.86,87.14 90.79,87.14 v1(90.51,86.86) ; v1(179.41,83.82) 178.9,84.32 178.69,84.32 177.99,85.03 172.26,85.03 171.18,86.11 166.96,86.11 163.65,89.42 163.65,89.82 v1(163.53,89.95) 163.09,90.39 162.39,90.39 161.37,91.42 161.37,94.05 160.95,94.46 159.07,94.46 157.87,95.66 157.87,96.31 157.06,97.13 157.06,98.7 156.18,99.58 156.18,100.89 155.66,101.41 155.66,104.27 155.03,104.9 ; R713.2 50,86.74 v1(50.25,86.48)
PCIE_LAN_WAKE#_R: length 14.2
  TOP w0.114: v1(42.2,87.96) 41.95,87.7 40.4,87.7 40.17,87.47 39.84,87.47 39.36,86.99 38.98,86.99 38.65,87.32 U15.21
  BOTTOM w0.114: R702.2 47.1,88.5 Q39.1 ; v1(42.2,87.96) 42.46,87.96 v3(43.42,86.99) 45.43,86.99 46.57,88.13 Q39.1 ; Q39.1 47.84,88.13 48.35,88.65 R709.1
PCIE_RCOMPN: length 7.7
  BOTTOM w0.076: 157.7,129.28 157.57,129.28 157.26,128.96 156.04,128.96 155.98,128.9 155.69,128.9 155.63,128.96 155.37,128.96 154.82,128.41 154.76,128.41 154.57,128.22 154.57,128.07 154.15,127.65 U35.F5
  BOTTOM w0.305: 157.7,129.28 158.6,130.17 158.68,130.25 159.06,130.25 R562.2
PCIE_RCOMPP: length 7.9
  BOTTOM w0.076: U35.E5 154.15,128.28 154.52,128.65 154.67,128.65 154.9,128.88 154.9,129.13 154.88,129.15 154.88,129.41 155.13,129.66 155.54,129.66 156.02,130.14 156.46,130.14 156.94,130.63 157.3,130.63
  BOTTOM w0.305: R562.1 159.96,131.94 159.85,131.94 158.89,130.99 158.53,130.63 157.3,130.63
PCIE_REQ_LAN#_R: length 6.4
  TOP w0.114: U15.12 35.7,83.41 v1(36.13,82.98) 36.92,82.19 R276.1 R277.2 39.2,81.79 Q25.1
PCIE_RX5+_LAN: length 172.4
  TOP w0.114: v1(42.47,70.86) 42.76,71.15 42.76,75.65 44.89,77.78 44.89,82.06 v3(44.39,82.57) 44.89,83.08 44.89,84.64 43.94,85.59 41.88,85.59 C375.2
  IN2 w0.127: v1(42.47,70.86) 42.72,71.11 42.72,71.45 43.8,72.54 73.19,72.54 75.5,74.84 84.79,74.84 90.97,81.02 93.03,81.02 95.01,83 95.01,90.34 96.46,91.79 96.46,108.52 102.2,114.26 102.2,117.47 101.49,118.18 101.49,121.31 105.27,125.09 106.11,125.09 109.08,128.06 112.97,128.06 115.05,125.98 116.58,125.98 117.71,124.85 121.82,124.85 122.5,124.18 138.6,124.18 139.39,124.96 140.66,124.96 141.22,124.41 143.42,124.41 144.74,125.73 146.04,125.73 146.62,126.31 146.62,127.81 v2(147.3,128.49)
  BOTTOM w0.114: v2(147.3,128.49) 147.48,128.49 U35.E16
PCIE_RX5+_LAN_C: length 3
  TOP w0.114: U15.17 38.65,85.72 38.71,85.78 39.3,85.78 39.49,85.59 40.34,85.59 C375.1
PCIE_RX5-_LAN: length 172.5
  TOP w0.114: C372.2 41.89,85.84 44.04,85.84 45.14,84.74 45.14,83.09 v3(45.66,82.57) 45.14,82.05 45.14,77.68 43,75.55 43,71.15 v1(43.29,70.86)
  IN2 w0.127: v2(147.3,127.88) 147,127.88 146.85,127.73 146.85,126.22 146.14,125.51 144.83,125.51 143.85,124.53 143.85,124.48 143.53,124.15 141.11,124.15 140.55,124.71 139.49,124.71 138.7,123.92 122.39,123.92 121.72,124.59 117.6,124.59 116.47,125.73 114.95,125.73 112.86,127.81 109.18,127.81 106.21,124.84 105.37,124.84 101.74,121.2 101.74,118.28 102.45,117.57 102.45,114.15 96.71,108.41 96.71,91.69 95.26,90.24 95.26,82.9 93.13,80.77 91.07,80.77 84.89,74.59 75.6,74.59 73.3,72.28 43.91,72.28 42.97,71.35 42.97,71.18 v1(43.29,70.86)
  BOTTOM w0.114: v2(147.3,127.88) 147.61,127.88 147.75,127.75 U35.F16
PCIE_RX5-_LAN_C: length 3
  TOP w0.114: U15.18 38.65,86.12 38.75,86.01 39.4,86.01 39.59,85.82 40.31,85.82 C372.1
PCIE_RX6+_WLAN: length 61.5
  IN2 w0.127: v2(147.27,127.26) 147.4,127.26 147.76,126.89 147.76,126.18 148.1,125.85 148.93,125.85 149.31,125.47 151.6,125.47 151.73,125.34 154.65,125.34 155.18,124.81 155.51,124.81 156,125.3 158.35,125.3 158.41,125.24 160.79,125.24 161.53,125.98 162.14,125.98 162.88,125.24 163.54,125.24 164.35,126.06 166.2,126.06 166.86,126.72 168.72,126.72 170.22,125.22 170.76,125.22 171.11,124.87 171.11,122.73 172.81,121.03 172.81,120.4 173.78,119.43 174.45,119.43 175.87,118 175.87,116.37 176.85,115.39 176.85,114.35 177.13,114.07 177.13,113.69 178.93,111.88 178.93,110.64 180.38,109.19 180.38,105.76 182.33,103.81 182.33,100.2 v1(182.71,99.82)
  BOTTOM w0.114: v2(147.27,127.26) 146.95,127.57 U35.F18 ; v1(182.71,99.82) 182.47,99.58 182.26,99.58 181.28,98.6 181.15,98.6 181.02,98.72 CN10.41
PCIE_RX6-_WLAN: length 61.5
  IN2 w0.127: v1(182.71,99.18) 182.27,99.63 182.27,99.9 182.08,100.09 182.08,103.7 180.12,105.66 180.12,109.09 178.68,110.54 178.68,111.78 176.87,113.58 176.87,113.97 176.59,114.25 176.59,115.29 175.62,116.26 175.62,117.9 174.34,119.17 173.67,119.17 172.55,120.29 172.55,120.92 170.85,122.62 170.85,124.76 170.65,124.96 170.12,124.96 168.62,126.46 166.97,126.46 166.31,125.8 164.46,125.8 163.64,124.99 162.77,124.99 162.04,125.73 161.63,125.73 160.9,124.99 158.31,124.99 158.25,125.05 156.11,125.05 155.62,124.56 155.08,124.56 154.54,125.09 151.6,125.09 151.47,125.22 149.21,125.22 148.83,125.6 147.99,125.6 147.51,126.08 147.51,126.41 v5(147.29,126.63)
  BOTTOM w0.114: CN10.43 181.02,98.23 181.15,98.35 181.38,98.35 182.36,99.34 182.56,99.34 v1(182.71,99.18) ; v5(147.29,126.63) 146.93,126.63 146.83,126.73 U35.G18
PCIE_TX5+: length 7.2
  BOTTOM w0.076: 146.32,133.98 146.32,133.96 146.28,133.92 146.28,130.8 146.29,130.79 146.25,130.71 146.24,130.68 146.24,130.59 146.29,130.44 146.29,130.19 146.24,130.04 146.22,129.99 146.22,129.66 U35.D19
  BOTTOM w0.114: 146.32,133.98 146.32,135.39 146.67,135.74 C669.1
PCIE_TX5+_LAN: length 171.7
  TOP w0.114: v1(43.59,77.66) 43.59,78.08 42.95,78.71 42.95,81.47 41.61,82.81 37.07,82.81 36.17,83.72 36.17,84.26 36.1,84.32 U15.13
  IN2 w0.127: v1(43.59,77.66) 46.65,74.6 73.59,74.6 76.07,77.07 84.25,77.07 89.42,82.24 92.67,82.24 93.38,82.96 93.38,93.93 94.83,95.37 94.83,109.22 100.37,114.75 100.37,116.96 99.86,117.47 99.86,122.02 104.58,126.74 105.05,126.74 108.41,130.11 109.05,130.11 109.89,130.96 112.41,130.96 115.35,128.01 116.87,128.01 117.64,127.25 121.64,127.25 122.65,126.23 138.5,126.23 139.01,126.74 139.64,126.74 140.8,127.91 140.8,133.49 144.07,136.76 146.22,136.76 146.49,137.03 146.49,137.54 v1(146.62,137.66)
  BOTTOM w0.114: C669.2 146.49,136.84 146.49,137.5 146.52,137.52 146.52,137.57 v1(146.62,137.66)
PCIE_TX5-: length 7.1
  BOTTOM w0.076: 146.08,133.98 146.08,133.96 146.12,133.92 146.12,130.82 146.1,130.78 146.08,130.72 146.08,130.56 146.1,130.49 146.13,130.41 146.13,130.22 146.11,130.17 146.07,130.07 146.06,130.01 146.06,129.72 145.98,129.64 U35.C19
  BOTTOM w0.114: 146.08,133.98 146.08,135.49 146.25,135.66 146.25,135.82 146.19,135.88 C668.1
PCIE_TX5-_LAN: length 171.7
  TOP w0.114: v1(44.17,78.24) 43.77,78.24 43.19,78.81 43.19,81.57 41.71,83.05 37.17,83.05 36.41,83.82 36.41,84.23 36.5,84.32 U15.14
  IN2 w0.127: v1(44.17,78.24) 44.17,77.44 46.76,74.85 73.48,74.85 75.96,77.33 84.14,77.33 89.31,82.5 92.56,82.5 93.13,83.06 93.13,94.03 94.58,95.48 94.58,109.32 100.11,114.86 100.11,116.86 99.61,117.37 99.61,122.12 104.48,127 104.94,127 108.31,130.36 108.94,130.36 109.79,131.21 112.51,131.21 115.46,128.27 116.98,128.27 117.74,127.5 121.74,127.5 122.76,126.49 138.39,126.49 138.9,127 139.53,127 140.55,128.01 140.55,133.6 143.97,137.02 146.12,137.02 146.24,137.13 146.24,137.41 v5(145.98,137.66)
  BOTTOM w0.114: v5(145.98,137.66) 146.25,137.4 146.25,136.72 146.19,136.66 C668.2
PCIE_TX6+: length 12.3
  BOTTOM w0.076: 144.92,132.95 144.92,132.9 145.2,132.61 145.2,130.26 145.29,130.17 U35.C20
  BOTTOM w0.114: 144.92,132.95 144.31,133.56 144.31,139.34 145.42,140.45 145.42,140.73 145.53,140.84 145.88,140.84 C649.1
PCIE_TX6+_WLAN: length 83.2
  BOTTOM w0.114: C649.2 145.79,141.26 145.47,141.26 145.42,141.31 145.42,141.79 145.24,141.97 145.24,142.53 147.37,144.66 156.39,144.66 158.18,142.87 160.29,142.87 161.98,141.18 161.98,139.07 164.03,137.02 165.47,137.02 165.7,137.25 167.06,137.25 167.42,137.61 167.81,137.61 168.16,137.97 169.41,137.97 169.67,137.7 175.86,137.7 177.1,136.46 177.1,132.5 177.84,131.76 178.09,131.76 179.71,130.15 179.71,123.02 v3(178.93,122.25) 179.48,121.7 179.48,117.48 180.35,116.61 182.07,116.61 183.49,115.19 183.49,111.01 182.56,110.08 182.56,107.87 181.57,106.88 181.57,100.29 181.38,100.1 181.15,100.1 181.02,100.23 CN10.35
PCIE_TX6-: length 12.3
  BOTTOM w0.076: 144.73,132.79 144.74,132.78 144.8,132.78 145.03,132.55 145.03,130.23 145,130.19 145,129.79 145.29,129.5 U35.D20
  BOTTOM w0.114: 144.73,132.79 144.07,133.46 144.07,139.44 145,140.37 C648.1
PCIE_TX6-_WLAN: length 83.2
  BOTTOM w0.114: C648.2 145,142.63 147.27,144.9 156.49,144.9 158.28,143.11 160.39,143.11 162.22,141.28 162.22,139.17 164.13,137.26 165.37,137.26 165.6,137.49 166.96,137.49 167.32,137.85 167.71,137.85 168.06,138.21 169.51,138.21 169.77,137.95 175.96,137.95 177.34,136.56 177.34,132.6 177.94,132 178.19,132 179.95,130.25 179.95,122.5 v3(180.2,122.25) 179.72,121.76 179.72,117.58 180.45,116.85 182.17,116.85 183.73,115.29 183.73,110.91 182.8,109.98 182.8,107.77 181.81,106.78 181.81,100.19 181.48,99.85 181.15,99.85 181.02,99.72 CN10.37
PCLK_TPM: length 122.1
  TOP w0.114: v1(216.29,48.15) 216.28,48.15 215.33,49.1 208.26,49.1 207.26,48.1 200.01,48.1 199.41,47.49 199.41,47.44 198.25,46.28 193.96,46.28 193.62,46.62 v1(192.92,46.62)
  IN1 w0.127: v1(192.92,46.62) 191.65,46.62 189.37,48.91 189.37,49.48 187.92,50.92 187.92,54.58 184.98,57.53 184.98,62.84 182.96,64.85 182.96,70.37 182.78,70.54 179.32,70.54 179.12,70.75 179.12,73.78 179.24,73.91 179.5,73.91 179.63,73.78 179.63,71.2 179.77,71.05 179.98,71.05 180.13,71.2 180.13,73.27 180.26,73.4 180.51,73.4 180.64,73.27 180.64,71.2 180.79,71.05 182.78,71.05 182.96,71.23 182.96,72.22 179.6,75.57 179.6,79.36 178.7,80.26 177.28,80.26 176.26,81.28 176.03,81.28 175.11,82.19 175.11,85.15 172.3,87.96 172.3,88.36 171.96,88.71 170.31,88.71 168.94,90.07 168.94,93.89 169.02,93.98 v1(169.38,93.98)
  IN2 w0.127: v5(165.06,107.77) 165.06,106.93 165.52,106.47 165.52,105.44 166.12,104.83 167,104.83 167.79,104.04 167.79,102.68 168.18,102.29 168.18,98.44 168.3,98.31 168.3,97.14 170.55,94.89 170.55,94.31 170.22,93.98 v1(169.38,93.98)
  BOTTOM w0.114: v5(165.06,107.77) 164.93,107.64 164.49,107.64 R626.1 ; v1(216.29,48.15) 216.06,48.39 U44.21
PD#: length 11
  TOP w0.114: U23.47 36.2,35.71 36.51,36.01 36.51,36.42 36.87,36.78 37.12,36.78 37.22,36.88 37.72,36.88 C494.1 38.96,37.98 39.45,38.47 R372.2 40.73,38.47 R369.1 v1(41.72,38.6) 41.96,38.6 D16.2 D15.2
PEG_RX0: length 41.5
  IN2 w0.127: v2(150.03,127.27) 150.03,127.31 150.86,128.14 151.11,128.14 152.49,129.51 157.65,129.51 160.49,132.36 162.09,132.36 164.33,134.59 164.33,136.42 165.54,137.63 165.54,138.33 166.2,138.99 166.2,139.19 v1(166.08,139.31)
  BOTTOM w0.114: v1(166.08,139.31) 166.24,139.48 166.24,141.33 162.39,145.18 162.39,147.07 162.68,147.35 162.94,147.35 163.86,148.27 163.86,148.71 163.75,148.82 163.75,149.7 166.25,152.19 167.22,152.19 167.34,152.31 C632.1 ; U35.G13 149.93,127.27 v2(150.03,127.27)
PEG_RX1: length 46.8
  IN2 w0.127: v1(166.26,138.04) 166.33,137.97 166.33,136.96 166.37,136.92 166.37,136.12 166.71,135.78 166.71,133.57 166.08,132.94 163.79,132.94 160.94,130.09 159.32,130.09 157.87,128.65 154.39,128.65 153.91,128.16 152.96,128.16 152.79,127.99 152.36,127.99 151.49,127.12 151.1,127.12 v2(150.95,127.27)
  BOTTOM w0.114: v2(150.95,127.27) 150.79,127.27 U35.F11 ; C627.1 167.34,154.65 167.22,154.53 166.99,154.53 166.45,155.08 165.84,155.08 165.44,154.68 165.44,153.12 162.74,150.41 162.74,149.82 161.66,148.74 161.66,144.88 165.4,141.13 165.4,138.97 165.85,138.52 166.22,138.52 166.41,138.34 166.41,138.2 v1(166.26,138.04)
PEG_RX2: length 46.6
  IN2 w0.076: 148.55,128.72 148.55,128.71 148.58,128.69 148.58,128.02 148.56,128 148.56,127.16 148.42,127.03 148.33,127.03 v2(148.21,127.15)
  IN2 w0.127: v1(164.33,139.92) 162.7,138.3 162.7,136.75 159.02,133.07 154.77,133.07 153.96,132.25 152.92,132.25 150.74,130.07 149.49,130.07 148.55,129.14 148.55,128.72
  BOTTOM w0.114: U35.G16 147.75,127.1 147.9,127.26 148.11,127.26 v2(148.21,127.15) ; C626.1 167.34,156.59 167.24,156.69 166.34,156.69 164.81,155.15 164.81,153.28 162.24,150.72 162.24,150.1 161.15,149.01 161.15,144.68 163.87,141.97 163.87,139.87 164,139.75 164.15,139.75 v1(164.33,139.92)
PEG_RX3: length 49.3
  IN2 w0.076: 149.46,128.53 149.49,128.51 149.49,127.2 149.36,127.07 149.24,127.07 v2(149.12,127.2)
  IN2 w0.127: 149.46,128.53 149.46,128.93 149.84,129.31 151.19,129.31 152.18,130.3 155.23,130.3 155.71,130.78 157.82,130.78 161.02,133.98 162.09,133.98 163.12,135.01 163.12,135.99 163.46,136.33 163.46,137.31 163.98,137.83 163.98,138.4 164.13,138.55 164.4,138.55 v1(164.43,138.58)
  BOTTOM w0.114: v2(149.12,127.2) 148.84,127.2 148.66,127.37 U35.F15 ; C609.1 167.34,158.59 167.19,158.75 166.33,158.75 165.57,157.98 165.57,156.97 163.92,155.32 163.92,153.54 160.78,150.4 160.78,149.74 160.41,149.37 160.41,144.38 163.13,141.66 163.13,139.55 164.13,138.55 164.4,138.55 v1(164.43,138.58)
PEG_RX#0: length 41.5
  IN2 w0.127: v1(166.71,139.31) 166.46,139.06 166.46,138.88 165.8,138.22 165.8,137.53 164.58,136.31 164.58,134.49 162.2,132.1 160.6,132.1 157.75,129.26 152.59,129.26 151.22,127.88 150.97,127.88 150.48,127.4 150.48,127.09 v5(150.03,126.65)
  BOTTOM w0.114: U35.H13 149.95,126.65 v5(150.03,126.65) ; C638.1 167.15,151.95 166.35,151.95 164,149.6 164,148.92 164.1,148.81 164.1,148.17 163.04,147.11 162.78,147.11 162.64,146.97 162.64,145.28 166.48,141.43 166.48,139.54 v1(166.71,139.31)
PEG_RX#1: length 46.8
  IN2 w0.127: v2(150.95,126.65) 151.17,126.87 151.6,126.87 152.46,127.73 152.9,127.73 153.07,127.91 154.01,127.91 154.5,128.39 157.98,128.39 159.43,129.84 161.05,129.84 163.89,132.69 166.18,132.69 166.97,133.47 166.97,135.89 166.62,136.23 166.62,137.03 166.59,137.07 166.59,137.74 v1(166.89,138.04)
  BOTTOM w0.114: U35.G11 150.77,126.65 v2(150.95,126.65) ; C629.1 166.97,154.29 166.89,154.29 166.35,154.83 165.94,154.83 165.68,154.58 165.68,153.02 162.98,150.31 162.98,149.72 161.9,148.64 161.9,144.98 165.65,141.23 165.65,139.07 165.95,138.76 166.32,138.76 166.65,138.44 166.65,138.29 v1(166.89,138.04)
PEG_RX#2: length 46.5
  IN2 w0.076: 148.77,128.72 148.74,128.7 148.74,127.95 148.73,127.93 148.73,127.09 148.55,126.92 148.55,126.89 v2(148.21,126.54)
  IN2 w0.127: v1(164.33,139.29) 164.05,139.29 162.95,138.19 162.95,136.64 159.12,132.81 154.88,132.81 154.06,132 153.03,132 150.84,129.82 149.59,129.82 148.77,128.99 148.77,128.72
  BOTTOM w0.114: C610.1 167.16,156.93 166.24,156.93 164.57,155.25 164.57,153.39 162,150.82 162,150.2 160.91,149.11 160.91,144.58 163.63,141.87 163.63,139.77 163.9,139.51 164.11,139.51 v1(164.33,139.29) ; v2(148.21,126.54) 147.93,126.27 U35.H16
PEG_RX#3: length 49.3
  IN2 w0.076: 149.68,128.52 149.65,128.49 149.65,127.13 149.44,126.92 149.44,126.89 v2(149.12,126.57)
  IN2 w0.127: 149.68,128.52 149.68,128.78 149.95,129.05 151.3,129.05 152.29,130.04 155.33,130.04 155.82,130.53 157.93,130.53 161.13,133.73 162.2,133.73 163.37,134.9 163.37,135.89 163.72,136.23 163.72,137.21 164.43,137.92 v1(164.43,137.94)
  BOTTOM w0.114: U35.G15 149.01,126.57 v2(149.12,126.57) ; v1(164.43,137.94) 164.4,137.94 162.89,139.45 162.89,141.56 160.17,144.28 160.17,149.47 160.54,149.84 160.54,150.5 163.68,153.64 163.68,155.42 165.33,157.07 165.33,158.08 166.23,158.99 167.07,158.99 C607.1
PEG_RXN0_C: length 10
  IN2 w0.127: v1(170.38,152.46) 170.52,152.61 170.52,153.01 171.03,153.51 174.26,153.51 175.1,152.68 v1(175.25,152.68)
  BOTTOM w0.114: U34.AB9 v1(175.25,152.68) ; v1(170.38,152.46) 170.59,152.67 170.59,152.83 170.47,152.94 170.18,152.94 169.54,152.29 169.12,152.29 168.79,151.96 168.32,151.96 C638.2
PEG_RXN1_C: length 9
  IN2 w0.127: v1(175.27,153.51) 174.97,153.82 174.68,153.82 174.45,154.05 171.81,154.05 170.93,154.94 169.93,154.94 v1(169.67,154.67)
  BOTTOM w0.114: U34.AC10 174.88,153.9 v1(175.27,153.51) ; C629.2 168.61,154.42 168.78,154.42 169.29,154.92 169.42,154.92 v1(169.67,154.67)
PEG_RXN2_C: length 7.9
  IN2 w0.127: v1(168.87,156.88) 168.94,156.82 170.9,156.82 171.58,156.13 173.57,156.13 173.92,155.78 173.92,155.78 174.16,155.55 174.16,155.42 v1(174.42,155.16)
  BOTTOM w0.114: C610.2 168.54,156.69 168.68,156.69 v1(168.87,156.88) ; U34.AC11 v1(174.42,155.16)
PEG_RXN3_C: length 9.5
  IN2 w0.127: v1(175.26,156) 175.09,156.16 175.09,156.71 174.64,157.17 174.26,157.17 173.78,157.66 172.43,157.66 171.16,158.92 169.23,158.92 v1(169.08,159.08)
  BOTTOM w0.114: C607.2 168.48,158.89 168.89,158.89 v1(169.08,159.08) ; U34.AB12 v1(175.26,156)
PEG_RXP0_C: length 10
  IN2 w0.127: v1(171.15,152.46) 171.1,152.51 170.93,152.51 170.78,152.66 170.78,152.9 171.13,153.26 174.15,153.26 174.42,152.99 v1(174.42,152.7)
  BOTTOM w0.114: C632.2 168.12,152.35 168.26,152.21 168.69,152.21 169.02,152.54 169.44,152.54 170.08,153.18 170.57,153.18 170.83,152.93 170.83,152.79 v1(171.15,152.46) ; v1(174.42,152.7) 174.73,152.7 174.83,152.8 U34.AC9
PEG_RXP1_C: length 9
  IN2 w0.127: v1(175.26,154.32) 175.02,154.07 174.78,154.07 174.55,154.3 171.92,154.3 171.03,155.19 169.93,155.19 v1(169.67,155.45)
  BOTTOM w0.114: v1(169.67,155.45) 169.37,155.16 169.19,155.16 168.68,154.66 168.4,154.66 C627.2 ; v1(175.26,154.32) 175.26,154.13 175.49,153.9 U34.AB10
PEG_RXP2_C: length 7.9
  IN2 w0.127: v1(173.62,155.16) 173.79,155.16 173.9,155.27 173.9,155.44 173.67,155.67 173.67,155.68 173.47,155.88 171.48,155.88 170.79,156.56 169.18,156.56 168.87,156.25 v1(168.87,156.24)
  BOTTOM w0.114: v1(168.87,156.24) 168.67,156.45 168.47,156.45 C626.2 ; U34.AD11 173.66,154.74 173.6,154.81 173.6,155.13 v1(173.62,155.16)
PEG_RXP3_C: length 9.5
  IN2 w0.127: v1(169.08,158.44) 169.3,158.67 171.05,158.67 172.32,157.4 173.67,157.4 174.16,156.92 174.53,156.92 174.84,156.61 174.84,156.2 174.62,155.99 v1(174.43,155.99)
  BOTTOM w0.114: U34.AC12 174.83,155.81 174.66,155.99 v1(174.43,155.99) ; v1(169.08,158.44) 168.86,158.65 168.53,158.65 C609.2
PEG_TX0: length 31.4
  IN2 w0.127: v1(170.74,150.21) 170.28,149.75 169.94,149.75 169.41,149.22 168.73,149.22 167.71,150.24 166.71,150.24 166.33,150.62 165.82,150.62 165.06,149.86 165.06,149.55 163.8,148.28 162.6,148.28 162.14,147.82 160.01,147.82 159.12,146.93 158.89,146.93 154.7,142.74 154.7,142.42 154.75,142.36 v1(155.03,142.36)
  BOTTOM w0.114: v1(170.74,150.21) 170.57,150.38 170.57,150.52 170.78,150.72 171.54,150.72 U34.AG6 ; v1(155.03,142.36) 154.77,142.11 154.47,142.11 154.37,142.21 152.9,142.21 152.32,141.64 152.32,140.46 152.62,140.17 152.62,137.58 152.82,137.37 152.82,136.85 152.75,136.78 C652.1
PEG_TX1: length 29.3
  IN2 w0.127: v1(153.5,141.47) 153.68,141.65 153.68,143.16 158.01,147.49 158.01,148.12 158.8,148.91 161.78,148.91 162.17,149.3 163.23,149.3 163.92,149.98 163.92,150.42 165.26,151.76 168.19,151.76 168.78,151.16 168.94,151.16 v1(169.41,150.69)
  BOTTOM w0.114: v1(153.5,141.47) 153.78,141.19 153.78,139.3 C655.1 ; v1(169.41,150.69) 169.14,150.96 169.14,151.21 169.39,151.47 171.02,151.47 171.35,151.8 171.87,151.8 172.12,151.55 172.31,151.55 U34.AF7
PEG_TX2: length 32
  IN2 w0.127: v1(151.52,141.11) 151.71,141.3 151.97,141.3 152.18,141.3 153.17,142.29 153.17,143.37 157.51,147.7 157.51,148.4 158.56,149.45 161.59,149.45 161.94,149.81 162.14,149.81 164.6,152.27 168.99,152.27 169.52,151.74 172.89,151.74 173.28,152.13 173.28,152.54 173.44,152.7 v1(173.62,152.7)
  BOTTOM w0.114: v1(173.62,152.7) 173.62,152.72 U34.AE9 ; v1(151.52,141.11) 151.33,140.92 151.33,140.28 151.61,140 151.61,139.07 151.82,138.87 C662.1
PEG_TX3: length 34.7
  IN2 w0.127: v1(147.92,140.97) 147.7,141.18 147.7,141.28 148.48,142.06 151.8,142.06 152.41,142.67 152.41,143.69 156.74,148.02 156.74,148.78 158.65,150.68 161.93,150.68 164.53,153.28 166.01,153.28 v1(166.31,152.98)
  BOTTOM w0.114: v1(147.92,140.97) 147.74,140.79 147.74,140.54 147.17,139.96 146.23,139.96 145.88,139.62 145.88,139.5 146,139.39 146.33,139.39 C660.1 ; U34.AG9 171.63,153.29 171.55,153.37 171.09,153.37 170.72,153.74 169.92,153.74 169.3,153.12 168.48,153.12 168.38,153.22 166.54,153.22 v1(166.31,152.98)
PEG_TX#0: length 31.4
  IN2 w0.127: v1(155.03,141.73) 154.44,142.31 154.44,142.85 158.79,147.19 159.01,147.19 159.9,148.08 162.04,148.08 162.5,148.54 163.69,148.54 164.81,149.65 164.81,149.96 165.72,150.87 166.44,150.87 166.82,150.49 167.82,150.49 168.84,149.47 169.31,149.47 v1(170.05,150.22)
  BOTTOM w0.114: v1(155.03,141.73) 154.88,141.87 154.87,141.87 154.37,141.87 154.27,141.97 153,141.97 152.57,141.54 152.57,140.56 152.86,140.27 152.86,137.68 153.06,137.47 153.06,136.97 C653.2 ; U34.AG7 171.63,151.22 171.37,150.96 170.68,150.96 170.33,150.62 170.33,150.5 v1(170.05,150.22)
PEG_TX#1: length 29.4
  IN2 w0.127: v1(154.14,141.47) 153.94,141.68 153.94,143.06 158.27,147.39 158.27,148.01 158.91,148.65 161.88,148.65 162.27,149.04 163.34,149.04 164.17,149.88 164.17,150.31 165.37,151.51 168.08,151.51 168.74,150.84 v1(168.74,150.72)
  BOTTOM w0.114: C656.1 154.03,139.21 154.03,141.29 154.01,141.31 154.01,141.35 v1(154.14,141.47) ; U34.AE7 172.87,151.79 172.22,151.79 171.97,152.04 171.25,152.04 170.92,151.71 169.29,151.71 168.9,151.31 168.9,150.87 v1(168.74,150.72)
PEG_TX#2: length 32
  IN2 w0.127: v1(172.86,152.68) 173.03,152.51 173.03,152.24 172.78,151.99 169.63,151.99 169.09,152.52 164.5,152.52 162.04,150.06 161.84,150.06 161.48,149.7 158.45,149.7 157.25,148.5 157.25,147.81 152.92,143.48 152.92,142.39 152.08,141.55 151.17,141.55 150.89,141.27 v1(150.89,141.11)
  BOTTOM w0.114: v1(150.89,141.11) 151.09,140.9 151.09,140.18 151.37,139.9 151.37,139.15 C661.1 ; v1(172.86,152.68) U34.AF9
PEG_TX#3: length 34.7
  IN2 w0.127: v1(166.31,153.76) 166.08,153.54 164.43,153.54 161.82,150.94 158.54,150.94 156.49,148.88 156.49,148.12 152.16,143.79 152.16,142.77 151.7,142.31 148.37,142.31 147.45,141.39 147.45,141.13 v1(147.28,140.97)
  BOTTOM w0.114: v1(166.31,153.76) 166.61,153.46 168.48,153.46 168.58,153.36 169.2,153.36 169.82,153.98 170.82,153.98 171.19,153.62 171.51,153.62 171.63,153.74 U34.AG10 ; v1(147.28,140.97) 147.5,140.75 147.5,140.64 147.07,140.2 146.13,140.2 145.8,139.88 145.64,139.72 145.64,139.72 C654.1
PEGX_RST#: length 49.6
  TOP w0.114: Q16.2 197.46,136.65 v1(197.33,136.52) ; v1(165.7,144.93) 165.75,144.93 165.77,144.9 165.77,144.88 166.51,144.14 167.73,144.14 168.17,144.58 168.17,148.48 R86.1 ; v1(178.02,137.92) 178.02,137.86 179.35,136.52 v3(183.35,136.52) 184.3,137.47 185.57,137.47 185.89,137.79 185.89,138.3 186.09,138.5 188.35,138.5 188.53,138.32 188.53,137.87 188.82,137.58 190.36,137.58 190.54,137.76 R114.2 R132.1 192.46,136.5 192.49,136.53 U7.4 193.37,137.17 v1(192.7,137.84)
  IN1 w0.127: v1(178.02,137.92) 176.87,139.06 173.42,139.06 172.75,139.73 170.1,139.73 165.7,144.13 v1(165.7,144.93)
  IN2 w0.127: v1(192.7,137.84) 193.13,137.41 196.45,137.41 v1(197.33,136.52)
PERSTB: length 8.6
  TOP w0.114: R264.2 R263.2 43.65,86.61 43.52,86.74 v3(43.4,86.74) 40.55,86.74 40.2,86.38 38.82,86.38 38.69,86.52 U15.19
PEX_CLKREQ#: length 12.4
  TOP w0.114: R92.1 171.8,144.4 v1(172.4,145) 172.71,144.7 v3(173.16,144.7) 173.22,144.65 Q10.1 175.35,146.04 R91.1
  BOTTOM w0.114: U34.AC6 174.41,150.2 174.41,147.93 174.21,147.72 173.82,147.72 173.65,147.54 173.65,145.89 172.96,145.21 172.61,145.21 v1(172.4,145)
PEX_PLLVDD: length 5.1
  TOP w0.508: C96.2 176.05,157.4 v1(176.05,157.62) 176.05,158.03 C92.1 ; v1(168.03,161.46) C80.1 167.35,163.29 R72.2
  BOTTOM w0.254: U34.AA14 176.45,157.22 v1(176.05,157.62) 176.47,158.05 U34.AA15
PEX_TERMP: length 4.5
  BOTTOM w0.114: R473.2 168.13,166.72 172.04,166.72 U34.AF25
PEX_TSTCLK: length 4.8
  BOTTOM w0.114: 171.97,164.09 172.24,163.82 U34.AF22
  BOTTOM w0.127: R481.2 168.47,164.3 171.76,164.3 171.97,164.09
PEX_TSTCLK#: length 5.5
  BOTTOM w0.127: R481.1 168.09,164.59 171.89,164.59 172.25,164.23 172.83,164.23 U34.AE22
PHASE_A: length 7.8
  TOP w0.508: v1(146.11,162.09) PR60.1
  IN1 w0.635: v1(147.41,162.05) 148.03,162.67 148.03,163.68 148.68,164.33 148.68,166.49 147.92,167.25 147.92,167.28 v1(147.43,167.76)
  vias: v1(143.7,162.25)
PHASE_B1: length 7
  TOP w0.508: v1(126.96,163.44) 126.96,163.17 PR57.1
  IN1 w0.635: v1(127.24,169.06) 128.23,168.07 128.23,165.48 127.6,164.84 v1(127.6,163.95)
  vias: v1(128.08,163.52)
PHASE_B2: length 7.7
  TOP w0.508: v1(136.67,162.37) PR58.1
  IN1 w0.635: v1(136.61,168.02) 138.14,166.49 138.14,164.46 137.38,163.7 v1(137.38,162.3)
PHASE_C: length 8
  TOP w0.508: v1(159.47,161.16) PR59.1
  IN1 w0.635: v1(158.46,162.43) 159.09,163.06 159.09,167.38 v1(158.58,167.89)
  vias: v1(159.09,162.25)
PIRQA#: length 13.8
  BOTTOM w0.076: 160.28,106.97 160.13,106.83 155.28,106.83 154.8,107.31 154.01,107.31 153.82,107.5 152.74,107.5 152.4,107.84 151.73,107.84 151.41,108.16 151,108.16 150.85,108.32 U35.BB11
  BOTTOM w0.114: 160.28,106.97 162.43,106.97 v1(162.67,106.73) 163.48,106.73 R631.1
PLTRST#: length 347.8
  TOP w0.114: v1(178.7,79.62) 178.52,79.8 178.52,81.63 v1(181.22,84.32) ; R214.1 173.01,108.36 172.79,108.58 v1(172.78,108.58) 172.45,108.25 172.05,108.25 171.73,107.94 U14.4 ; U10.2 174.21,131.44 174.46,131.19 175.84,131.19 176.06,130.97 176.06,129.84 178.82,127.08 178.82,124.79 178.57,124.54 177.98,124.54 177.48,125.05 177.48,125.32 176.61,126.18 175.02,126.18 174.37,125.53 174.37,124.71 174.59,124.49 174.59,123.21 173.72,122.34 173.72,118.51 174.94,117.29 174.94,116.85 173.47,115.39 173.47,114.2 173.98,113.69 173.98,113.64 v1(174.33,113.28) ; v1(49.08,83.56) 47.05,85.59 R264.1 ; v1(205.98,52.65) 206.31,52.32 208.62,52.32 209,52.7 209.77,52.7 212.35,50.12 215.2,50.12 217.82,47.49 219.32,47.49 v1(219.39,47.42) ; v1(95.85,88.13) 96.61,88.9 96.61,90.33 95.4,91.54 94.21,91.54 90.85,88.18 v1(85.46,88.18) ; v1(185,99.89) 183.53,99.89 183.17,100.25 182.38,100.25 182.08,99.94 182.08,97.15 181.88,96.95 181.88,94.84 181.65,94.61 180.77,94.61 180.18,95.2 180.18,99.79 179.09,100.88 179.09,102.25 v1(178.98,102.36)
  IN1 w0.127: v1(174.33,113.28) 173.75,112.7 173.75,109.55 v1(172.78,108.58) 172.99,108.38 173.65,108.38 174.08,107.95 174.08,107.18 174.33,106.93 174.33,106.47 174.81,105.99 174.83,105.99 178.46,102.36 v1(178.98,102.36) 178.88,102.26 178.88,98.78 178.17,98.07 178.17,88.94 181.22,85.89 v1(181.22,84.32) ; v1(174.08,80.36) 174.08,80.41 174.31,80.64 175.98,80.64 177,79.62 v1(178.7,79.62)
  IN2 w0.127: v1(85.46,88.18) 85.46,83.33 84.8,82.67 78.62,82.67 73.49,77.54 57.7,77.54 56.81,76.65 55.94,76.65 54.98,77.62 53.64,77.62 49.08,82.17 v1(49.08,83.56)
  BOTTOM w0.114: R749.1 213.12,34.51 216.52,37.92 216.52,44.09 218.65,46.22 R742.1 219.1,46.22 219.39,46.5 v1(219.39,47.42) ; v1(185,99.89) 186.41,101.3 188.52,101.3 188.62,101.2 188.62,100.92 188.91,100.63 190.28,100.63 192.25,98.67 R671.1 192.75,98.17 193.56,97.35 195.03,97.35 199.43,92.96 199.43,81.91 198.44,80.93 198.44,73.99 199.79,72.64 203.67,72.64 208.55,67.76 208.55,53.58 207.57,52.6 206.03,52.6 v1(205.98,52.65) ; v1(174.08,80.36) 174.33,80.11 174.33,79.37 174.21,79.24 171.64,79.24 169.59,81.29 165.93,81.29 161.97,85.26 157.17,85.26 154.45,87.98 96.82,87.98 v3(96.81,87.98) 96.81,87.98 96.01,87.98 v1(95.85,88.13)
PM_EXTTS#0: length 4
  TOP w0.114: R347.2 162.46,49.01 v1(162.75,49.3)
  BOTTOM w0.114: v1(162.75,49.3) 162.74,49.29 JDIM2.198
PM_EXTTS#1: length 3.1
  TOP w0.114: v1(163.64,61.84) 163.66,61.84 164,61.51 R324.2
  BOTTOM w0.114: JDIM1.198 162.74,61.56 163.03,61.84 v1(163.64,61.84)
PMON: length 69.5
  TOP w0.114: v1(211.16,197.13) 211.01,196.97 PC7.2 PR342.2 ; PR25.1 157.98,187.58 158.2,187.36 158.2,187.3 v1(158.32,187.18)
  IN1 w0.127: v1(202.45,192.91) 203.39,192.91 203.52,192.78 205.07,192.78 206.28,193.99 208.94,193.99 209.26,193.67 210.46,193.67 210.59,193.8 210.59,196.55 v1(211.16,197.13)
  IN2 w0.127: v1(158.32,187.18) 158.32,189.59 160.62,191.89 163.16,191.89 166.59,195.32 175,195.32 175.8,196.12 177.47,196.12 178.13,195.46 181.94,195.46 182.13,195.27 185.41,195.27 v1(186.14,196.01)
  BOTTOM w0.114: v1(202.45,192.91) 202.2,192.65 200.48,192.65 199.8,193.33 192.32,193.33 191.46,194.2 190.67,194.2 188.56,196.31 186.45,196.31 v1(186.14,196.01) ; v1(211.16,197.13) 211.14,197.1 PR172.1
PROC_PWRGD: length 6.7
  BOTTOM w0.114: R544.2 R554.1 113.13,131.62 117.27,131.62 U35.A68
PROCHOT_EC: length 5.3
  TOP w0.114: Q30.2 207.48,35.67 R380.2 207.95,36.15 208.07,36.15 v1(208.52,36.6) 209.16,37.23 209.16,37.56 209.12,37.6 v1(209.12,37.61)
  BOTTOM w0.114: U45.17 209.01,37.52 209.11,37.61 v1(209.12,37.61)
PS_FB_CLAMP: length 12.7
  BOTTOM w0.114: U34.F3 189.37,147.69 189.37,145.97 188.23,144.83 187.21,144.83 185.66,143.28 184.77,143.28 183.35,141.86 183.35,140.09 R525.1
PTP_PWR_EN#: length 27.1
  IN1 w0.127: v1(205.45,44.06) 205.36,43.98 205.36,39.91 205.16,39.71 205.16,38.08 204.94,37.87 204.94,36.09 205.47,35.56 205.47,32.88 206.13,32.23 206.13,29.52 206.85,28.8 206.85,27.78 207.73,26.9 207.73,25.12 209.57,23.29 209.57,22.8 v1(210.15,22.22)
  BOTTOM w0.114: v1(205.45,44.06) 205.45,44.45 205.11,44.78 U45.125 ; v1(210.15,22.22) 209.27,23.1 R754.1
PWM1_B: length 31.7
  TOP w0.203: v1(129.91,172.87) 130.22,172.87 130.92,173.57 130.92,181.43 131.86,182.36 134.45,182.36 136.37,184.29 136.73,184.29 v3(137.1,184.65) 137.54,185.1 140.97,185.1 141.48,184.59 143.21,184.59 143.73,185.11 143.92,185.11 PR27.2
  BOTTOM w0.203: PR228.2 124.04,171.32 124.17,171.45 124.99,171.45 127.02,173.48 128.69,173.48 129.12,173.05 129.73,173.05 v1(129.91,172.87)
PWM2_B: length 23.3
  TOP w0.203: PR29.2 141.06,184.02 v3(140.93,183.89) 137.63,183.89 136.26,182.52 136.26,178.81 v1(139.18,175.89)
  IN2 w0.203: v1(139.18,175.89) 138.65,175.89 v1(133.18,170.43)
  BOTTOM w0.203: v1(133.18,170.43) PR233.2
PWM-VID: length 80.3
  TOP w0.114: v1(197.7,100.33) 197.41,100.61 PR123.1
  IN2 w0.127: v1(197.7,100.33) 198.84,99.18 206.34,99.18 207.42,100.26 208.31,100.26 212.01,103.97 212.01,114.15 209.72,116.44 209.72,120.36 208.85,121.23 208.85,125.37 206.23,127.99 206.23,133.12 207.5,134.39 207.5,139.14 207.05,139.59 206.19,139.59 205.25,140.53 199.58,140.53 195.9,144.22 193.99,144.22 193.62,144.59 193.62,147.63 v1(190.23,151.02)
  BOTTOM w0.102: v1(190.23,151.02) 189.83,151.42 U34.E7
PWM_A: length 8.8
  TOP w0.203: PR43.1 146.52,175.26 v1(146.39,175.13)
  BOTTOM w0.203: PR237.2 144.11,170.68 v3(144.41,170.99) 144.77,171.34 144.77,175.03 145.38,175.64 145.88,175.64 v1(146.39,175.13)
PWM_C: length 7.6
  TOP w0.203: v1(155.16,174.87) 155.28,174.87 155.84,175.43 155.84,175.96 PR47.1
  BOTTOM w0.203: v1(155.16,174.87) 155.16,172.69 v1(154.65,172.18) 155.16,171.67 155.16,169.93 PR239.2
PWRLED#: length 200
  TOP w0.508: R426.1 R432.1 58.26,9.78 v1(58.25,9.77) 58.41,9.62 v1(58.41,8.53) 58.41,7.84 57.92,7.35 R436.1
  IN1 w0.127: v1(83.27,20.93) 83.38,21.03 83.38,21.13 84.17,21.92 85.02,21.92 90.01,26.91 97.03,26.91 99.53,29.41 119.65,29.41 129.5,19.55 165.54,19.55 165.6,19.5 167.04,19.5 175.88,10.66 192.11,10.66 192.87,11.43 192.87,15.24 193.91,16.28 197.88,16.28 198.18,15.97 207.1,15.97 211.38,20.25 211.38,24.04 209.77,25.66 209.77,26.74 207.9,28.61 207.9,29.5 207.34,30.06 207.34,33.49 v1(206.49,34.34)
  IN2 w0.127: v1(58.25,9.77) 61.33,9.77 62.47,10.92 69.86,10.92 71.56,12.62 75.76,12.62 81.14,18 82.46,18 82.89,18.44 82.89,20.54 v1(83.27,20.93)
  BOTTOM w0.114: v1(206.49,34.34) 206.79,34.34 207.17,34.71 U45.24
R_SPK+: length 44.5
  IN1 w1.016: 65.34,16.4 63.06,16.4 62.32,17.14 53.94,17.14 50.51,20.57 50.51,30.45 48.76,32.2 48.76,35.71 48.48,35.99 48.45,35.99 45.17,39.26 39.99,39.26 38.7,37.97
  vias: v1(36.92,35.1) v1(37.3,35.84) v1(66.05,17.88) v1(66.36,17.29) v3(67.09,19.1)
R_SPK+_1:
  vias: v1(67.27,14.37) v1(67.27,13.73) v3(66.48,14.14)
R_SPK-: length 52.9
  IN1 w1.016: 40.73,37.33 41.52,38.12 44.69,38.12 47.61,35.2 47.61,31.7 49.36,29.94 49.36,19.96 53.4,15.92 61.76,15.92 62.47,15.21 66.94,15.21 68.2,16.47 68.2,19.58 67.57,20.21 65.41,20.21 64.65,19.45
  vias: v1(37.66,35.3) v1(38.29,35.3) v1(63.89,18.13) v1(64.35,18.61) v1(64.96,18.79)
R_SPK-_1:
  vias: v1(64.55,14.11) v1(64.55,13.48) v1(65.14,13.69)
RAM_ID1: length 8.7
  BOTTOM w0.076: U35.AP2 156.37,112.63 156.54,112.63 156.76,112.57 156.88,112.57 156.99,112.62 157.17,112.62 157.17,112.62 157.22,112.62 157.24,112.6 157.4,112.6 157.43,112.63 160.36,112.63
  BOTTOM w0.114: R611.1 163.71,111.54 163.42,111.25 162.35,111.25 161.99,111.61 161.99,111.65 161.81,111.83 R610.2 161.35,111.83 160.55,112.63 160.36,112.63
RAM_ID2: length 12.2
  BOTTOM w0.076: 160.36,113 160.19,113 159.98,112.8 157.44,112.8 157.41,112.83 157.22,112.83 157.21,112.85 U35.AP1
  BOTTOM w0.114: R613.1 167.39,112.19 166.22,112.19 R612.2 165.79,112.04 165.57,112.26 161.25,112.26 160.5,113 160.36,113
RAM_ID3: length 9.2
  BOTTOM w0.076: U35.AP3 155.7,112.85 156.08,112.47 156.52,112.47 156.74,112.41 156.91,112.41 156.93,112.39 157.07,112.39 157.11,112.35 157.42,112.35 157.51,112.26 160.36,112.26
  BOTTOM w0.114: R615.1 R614.2 162.32,110.82 162.14,111 162.14,111.09 161.96,111.27 161.35,111.27 161.1,111.53 161.1,111.7 160.54,112.26 160.36,112.26
REGN6V: length 12.5
  TOP w0.254: v1(205.96,199.46) 206.4,199.9 PR1.1
  IN2 w0.254: v1(205.96,199.46) 205.88,199.39 203.42,199.39 203.29,199.26 203.29,195.88 202.3,194.89 v1(201.89,194.89)
  BOTTOM w0.178: PU5.24 202.65,195.34 202.63,195.37 201.8,195.37 201.71,195.45 PC122.1
  BOTTOM w0.254: v1(201.89,194.89) 201.5,194.89 201.1,195.28 PC122.1
REGOUT:
  vias: v3(38.39,90.5)
RF_EN: length 4.3
  BOTTOM w0.114: R774.2 190.61,96.13 189.44,94.97 v3(189.32,94.97) 189.3,94.97 189.29,94.97 CN10.56
RING2: length 23.2
  BOTTOM w1.016: 29.04,28.7 29.08,28.67 29.08,28.19 26.54,25.65 20.36,25.65 18.14,23.43 18.14,14.1 17.79,13.76
  vias: v1(17.56,12.62) v1(18.2,12.62) v1(27.85,35.53) v1(28.54,35.35) v3(29.5,33.3)
RING2_R: length 13.9
  IN1 w0.762: 14.95,10.41 14.06,10.41 13.3,9.65 11.6,9.65 10.91,8.96 3.11,8.96 CN21.3
  vias: v1(15.05,10.97) v1(15.05,10.31) v3(15.89,10.18)
ROM_CS: length 15.4
  TOP w0.114: v1(191.03,155.99) 191.59,155.43 192.23,155.43 192.82,154.83 192.82,151.08 193.61,150.29 193.61,147.68 v1(194.93,146.36) 195.92,145.37 195.92,144.43 R93.1
  BOTTOM w0.102: U34.D12 190.63,155.6 v1(191.03,155.99)
ROM_SCLK: length 17.5
  BOTTOM w0.114: R495.2 R492.1 v3(203.48,148.76) 203.48,149.79 202.83,150.44 198.85,150.44 195.82,153.47 194.57,153.47 193.36,154.69 192.95,154.69 192.47,155.17 192,155.17 191.59,155.58 U34.C12
ROM_SI: length 18.4
  BOTTOM w0.114: U34.B12 192.37,155.44 192.52,155.44 193.06,154.9 193.45,154.9 194.66,153.68 196.01,153.68 199.03,150.67 203.03,150.67 v1(205.04,148.66) 205.46,148.25 205.87,148.25 R493.1 206.35,146.81 R496.2
ROM_SO: length 19.2
  BOTTOM w0.114: R494.2 R491.1 207.69,148.3 v1(207.3,148.69) 207.12,148.87 205.44,148.87 204.98,149.32 204.84,149.32 203.26,150.9 199.16,150.9 196.11,153.94 194.72,153.94 193.07,155.58 U34.A12
RREF: length 3.2
  TOP w0.305: 59.52,24.89 60.54,25.9 v3(60.54,26.62) R398.1
RSET: length 2.9
  TOP w0.203: U15.31 34.9,89.95 34.68,90.17 34.04,90.17 v1(33.77,90.44)
  BOTTOM w0.254: v1(33.77,90.44) 33.86,90.35 R701.2
RSMRST#: length 94.8
  IN2 w0.127: v1(176.87,78) 177.28,78 177.84,78.56 181.04,78.56 183.46,76.13 191.88,76.13 192.42,75.59 192.42,61.13 191.68,60.39 191.68,52.37 193.31,50.75 193.31,47.39 195.97,44.73 198.29,44.73 v1(198.77,44.24)
  BOTTOM w0.114: v1(176.87,78) 177.38,78.51 177.38,80.84 174.55,83.66 172,83.66 170.86,84.8 168.72,84.8 168.6,84.93 166.47,84.93 163.2,88.2 162.42,88.2 161.21,89.42 158.79,89.42 157.88,90.32 157.88,91.57 155.41,94.05 155.41,98.69 154.91,99.19 v3(154.91,99.82) 153.63,101.09 R655.1 ; v1(198.77,44.24) 199.33,44.24 199.91,44.83 U45.112
RTC_RST#: length 285
  TOP w0.114: R299.2 82.88,74.41 82.89,74.42 C380.1 81.76,75.04 81.24,75.56 v1(81.24,75.69) 81.24,75.79 81.99,76.54 84.03,76.54 84.76,77.26 85.64,77.26 86.19,76.71 86.19,69.21 84.77,67.79 v3(84.77,61.84) 84.77,50.87 104.03,31.62 164.71,31.62 165.8,32.71 171.06,32.71 171.3,32.95 173.99,32.95 174.89,33.85 174.89,41.22 174.59,41.52 170.19,41.52 168.74,42.97 PQ6060.3 167.86,44.29 167.58,44.01 165.39,44.01 163.18,46.22 161.63,46.22 159.85,48 159.85,56.89 158.33,58.42 158.33,68.19 157.06,69.46 157.06,73.78 155.08,75.76 155.05,75.76 149.62,81.2 149.62,81.23 149.54,81.3 149.54,86.69 150.99,88.13 153.94,88.13 154.7,87.37 154.7,87.35 158.25,83.79 159.7,83.79 160.82,82.67 162.27,82.67 v1(162.52,82.93) 161.81,83.64 160.59,83.64 159.86,84.37 159.86,87.25 160.51,87.9 160.51,89.37 162.16,91.02 162.95,91.02 163.28,91.36 163.28,93.68 162.73,94.23 162.28,94.23 161.38,95.13 158.51,95.13 158.27,94.89 157,94.89 156.99,94.9 154.92,94.9 148.93,100.88 148.93,103.23 149.2,103.5 149.2,105.93 149.69,106.42 149.69,108.2 148.17,109.72 148.17,109.85 147.79,110.23 147.79,113.92 v2(148.21,114.33) ; v1(174.03,84.15) 174.08,84.1 R268.2
  IN1 w0.127: v1(174.03,84.15) 173.39,83.51 171.47,83.51 169.3,85.67 168.8,85.67 168.49,85.37 168.49,83.82 167.47,82.8 165.44,82.8 165.32,82.93 v1(162.52,82.93)
  BOTTOM w0.114: v2(148.21,114.33) 147.98,114.33 147.75,114.56 U35.AM16 ; v1(81.24,75.69) 81.24,76.12 82.25,77.12 J1.1
RTC_X1: length 34.7
  TOP w0.114: Y2.1 159.2,93.57 158.45,92.82 C351.2 157.71,92.46 R255.1 156.5,92.46 156.11,92.85 154.64,92.85 v3(154.24,93.24) 153.9,92.9 151.74,92.9 146.93,97.7 146.93,106.91 145.83,108.01 145.83,110.51 146.85,111.53 146.85,114.5 v2(147.29,114.94)
  BOTTOM w0.114: U35.AM18 147.04,114.68 147.29,114.94 v2(147.29,114.94)
RTC_X2: length 34.7
  TOP w0.114: Y2.2 158.57,91.08 C362.2 157.97,91.68 R255.2 156.01,92.6 154.88,92.6 v3(154.24,91.97) 153.56,92.66 151.64,92.66 146.69,97.6 146.69,106.81 145.58,107.92 145.58,110.6 145.96,110.98 145.96,114.25 146.1,114.38 v2(146.38,114.38)
  BOTTOM w0.114: U35.AM20 146.19,114.41 146.35,114.41 v2(146.38,114.38)
RX_AVCC: length 3.5
  TOP w0.203: U13.28 25.22,109.58 25.41,109.77 v1(25.77,109.77) ; v1(25.54,106.37) 25.13,106.78 U13.21 ; U13.27 v1(25.5,109.18)
  vias: v3(25.77,107.84)
RX_IVDD: length 28.4
  TOP w0.203: v1(21.6,112.31) 21.33,112.04 U13.37 ; U13.39 20.53,112.04 v1(20.36,112.21) ; U13.20 v1(23.73,104.95)
  BOTTOM w0.635: C717.2 22.34,112.17 22.34,114.83 22.87,115.36 25.64,115.36 26.63,114.37 26.63,106.02 25.57,104.95 v1(23.73,104.95) 22.97,105.71 20.99,105.71 20.21,104.92 v1(19.75,104.92) 19.62,104.92 19.03,105.52
  vias: v3(20.97,112.64)
RX_IVDD33: length 2.6
  TOP w0.203: 25.59,110.46 25.11,109.98 U13.29 ; 25.72,110.87 25.46,110.87 24.98,110.38 U13.30
  vias: v1(25.77,111.45)
S5_ON: length 330.1
  TOP w0.114: v1(76.31,68.32) 76.29,68.35 PQ9.2 77.18,69.34 78.19,70.35 81.66,70.35 82.26,69.76 82.26,68.19 82.13,68.07 PQ13.2 v1(82.99,67.15)
  IN1 w0.127: v1(106.13,132.3) 105.47,132.3 104.2,131.03 102.24,131.03 95.91,124.71 95.91,124.12 89.83,118.04 88.65,118.04 85.06,114.46 85.06,111.88 83.83,110.64 80.02,110.64 74.89,105.51 57.95,105.51 56.53,104.08 56.53,98.57 53.68,95.73 53.68,88.45 56.45,85.68 56.45,82.57 57.11,81.91 57.97,81.91 58.55,81.33 58.55,79.99 60.08,78.46 61.38,78.46 62.52,77.31 67.32,77.31 v1(76.31,68.32) ; v1(59.68,30.15) 59.14,30.68 57.14,30.68 52.72,35.1 52.72,37.31 49.77,40.25 49.77,59.58 52.65,62.47 52.65,67.57 v1(52.54,67.69) ; v1(82.99,67.15) 82.99,59.97 100.98,41.98 159.12,41.98 159.75,41.35 174.1,41.35 174.16,41.4 177.13,41.4 178.88,43.15 185.76,43.15 188.42,45.8 193,45.8 v1(193.13,45.93)
  IN2 w0.127: v1(76.31,68.32) 74.79,66.8 64.99,66.8 64.35,66.16 63.46,66.16 61.94,67.69 v1(52.54,67.69)
  BOTTOM w0.114: U45.100 195.11,46.65 193.78,47.99 193.78,48.49 R741.1 193.26,48.25 v3(193.26,47.34) 193.26,47.11 193.41,46.96 193.41,46.16 193.18,45.93 v1(193.13,45.93) ; v1(106.13,132.3) 105.99,132.45 PR249.2 ; PQ35.2 59.22,29.69 v1(59.68,30.15)
S5D: length 41.8
  TOP w0.508: v1(68.67,31.42) 76.85,31.42 79.72,34.29 v1(81.09,34.29)
  IN2 w0.127: v1(60.59,31.8) 60.97,31.42 v1(68.67,31.42)
  BOTTOM w0.114: 62.9,33.14 61.94,33.14 v1(60.59,31.8) 59.5,31.8 58.94,32.36 56.58,32.36 55.56,33.37 PC282.2 54.57,33.87 PR335.2 PR334.2 ; v1(68.67,31.42) 71.62,31.42 v3(73.01,30.02) PQ37.2
SATA_DEVSLP1: length 5.8
  BOTTOM w0.076: 159.6,126.74 157.6,126.74 157.12,126.26 157.12,126 156.96,125.84 156.71,125.84 156.43,125.96 U35.J2
  BOTTOM w0.114: 159.6,126.74 159.77,126.58 160.71,126.58 R574.1
SATA_DEVSLP2: length 8.6
  BOTTOM w0.076: 159.55,126.49 158.2,126.49 157.82,126.11 157.82,125.47 157.7,125.34 157.19,125.34 156.86,125.67 156.67,125.67 156.47,125.76 156.32,125.82 155.79,125.83 U35.J3
  BOTTOM w0.114: R575.1 161.83,126.99 161.51,126.67 161.51,126.48 161.36,126.34 159.7,126.34 159.55,126.49
SATA_RXN0: length 167.7
  TOP w0.114: v1(221.32,35.94) 221.32,35.7 C507.2
  IN2 w0.127: v5(145.46,127.27) 145.88,127.69 145.88,128.14 146.39,128.65 146.39,129.84 148.65,132.1 150.43,132.1 153.53,135.2 158.13,135.2 160.06,137.13 160.06,137.92 163.41,141.27 166.41,141.27 166.84,140.84 167.22,140.84 170.37,137.69 170.37,137.08 171.99,135.45 172.58,135.45 174.4,133.63 174.4,132.19 175.68,130.9 175.68,129.1 176.8,127.98 176.8,123 177.78,122.02 177.97,121.83 177.98,121.83 177.98,120.71 179.29,119.4 179.29,118.99 179.49,118.79 179.49,117.54 180,117.04 180,114.83 183.68,111.14 183.68,107.94 184.87,106.75 185.97,106.75 186.52,106.19 186.52,99.74 193.79,92.48 194.12,92.48 195.16,91.43 195.16,90.09 196.08,89.17 196.08,70.36 195.92,70.21 195.92,63.55 195.36,62.99 195.36,58.67 195.34,58.67 195.08,58.42 195.08,52.27 196.38,50.97 196.38,49.95 196.84,49.5 196.84,48.25 197.62,47.47 198.69,47.47 199.84,46.32 206.39,46.32 207.37,45.33 211.49,45.33 219.67,37.16 220.84,37.16 221.63,36.36 221.63,36.24 v1(221.32,35.94)
  BOTTOM w0.114: v5(145.46,127.27) 145.76,127.57 U35.F20
SATA_RXN0_C: length 8.3
  TOP w0.114: C507.1 222.99,35.79 223.46,35.79 224.21,36.53 224.21,37.2 224.32,37.31 224.57,37.31 v3(225.39,36.5) 226.23,37.34 228.16,37.34 CN14.5
SATA_RXN1: length 137.1
  IN2 w0.127: v1(226.19,97.64) 226.19,98.42 225.2,99.41 218.51,99.41 214.7,95.6 194.87,95.6 193.26,97.21 193.26,98.24 194.27,99.26 194.27,104.27 191.54,107 191.54,108.38 187.28,112.64 186.86,112.64 182.92,116.59 182.92,120.57 182.62,120.86 182.19,120.86 181.5,121.56 181.5,121.69 180.99,122.2 180.99,122.99 180.51,123.47 180.51,124.23 180.39,124.34 180.39,127.62 179.79,128.22 179.79,129.15 179.08,129.87 179.08,131.97 179.39,132.28 179.39,133.6 178.65,134.34 178.42,134.34 177.61,135.15 177.61,135.58 173.82,139.37 173.82,139.61 171.88,141.55 171.43,141.55 168.51,144.47 165.67,144.47 165.41,144.22 162.19,144.22 156.52,138.55 148.93,138.55 146.51,136.13 145.26,136.13 141.57,132.44 141.57,130.32 142.2,129.68 142.2,129.18 143.65,127.73 144.06,127.73 v2(144.55,127.25)
  BOTTOM w0.114: v2(144.55,127.25) 144.87,126.92 U35.G21 ; v1(226.19,97.64) 226.19,98.33 226.3,98.45 C744.2
